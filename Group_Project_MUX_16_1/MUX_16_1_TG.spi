*** SPICE deck for cell MUX_16_1_TG{lay} from library MUX_16_1
*** Created on Sun May 10, 2020 06:15:49
*** Last revised on Sun May 10, 2020 23:24:50
*** Written on Sun May 10, 2020 23:24:55 by Electric VLSI Design System, version 9.07
*** Layout tech: mocmos, foundry MOSIS
*** UC SPICE *** , MIN_RESIST 4.0, MIN_CAPAC 0.1FF
***    P-Active:	areacap=0.9FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    N-Active:	areacap=0.9FF/um^2,	edgecap=0.0FF/um,	res=3.0ohms/sq
***    Polysilicon-1:	areacap=0.1467FF/um^2,	edgecap=0.0608FF/um,	res=6.2ohms/sq
***    Polysilicon-2:	areacap=1.0FF/um^2,	edgecap=0.0FF/um,	res=50.0ohms/sq
***    Transistor-Poly:	areacap=0.09FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    Poly-Cut:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=2.2ohms/sq
***    Active-Cut:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    Metal-1:	areacap=0.1209FF/um^2,	edgecap=0.1104FF/um,	res=0.078ohms/sq
***    Via1:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=1.0ohms/sq
***    Metal-2:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via2:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.9ohms/sq
***    Metal-3:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via3:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-4:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via4:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-5:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via5:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-6:	areacap=0.0423FF/um^2,	edgecap=0.1273FF/um,	res=0.036ohms/sq
***    Hi-Res:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=1.0ohms/sq

*** TOP LEVEL CELL: MUX_16_1:MUX_16_1_TG{lay}
Mnmos@0 net@0 net@1#7nmos@0_poly-right I4 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@1 net@1 S1#48nmos@1_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=26.879P AD=1.684P PS=65.462U PD=5.425U
Mnmos@2 net@0 S1#6nmos@2_poly-left I6 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@3 net@18 net@2#11nmos@3_poly-right I5 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@4 net@2#4contact@26_metal-1-n-act S1#13nmos@4_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=26.879P AD=1.684P PS=65.462U PD=5.425U
Mnmos@5 net@18 S1#51nmos@5_poly-left I7 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@6 net@14 net@97#8nmos@6_poly-right net@0 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@7 net@97 S2#7nmos@7_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=26.879P AD=1.684P PS=65.462U PD=5.425U
Mnmos@8 net@14 S2#25nmos@8_poly-left net@18 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@9 net@104 net@105#7nmos@9_poly-right I0 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@10 net@105 S1#40nmos@10_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=26.879P AD=1.684P PS=65.462U PD=5.425U
Mnmos@11 net@104 S1#26nmos@11_poly-left I2 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@12 net@123 net@106#11nmos@12_poly-right I1 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@13 net@106#4contact@95_metal-1-n-act S1#33nmos@13_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=26.879P AD=1.684P PS=65.462U PD=5.425U
Mnmos@14 net@123 S1#43nmos@14_poly-left I3 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@15 net@199 net@210#8nmos@15_poly-right net@104 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@16 net@210 S2#5nmos@16_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=26.879P AD=1.684P PS=65.462U PD=5.425U
Mnmos@17 net@199 S2#17nmos@17_poly-left net@123 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@18 net@349 net@350#6nmos@18_poly-right net@199 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@19 net@350 S0#2nmos@19_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=26.879P AD=1.684P PS=65.462U PD=5.425U
Mnmos@20 net@349 S0#10nmos@20_poly-left net@14 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@21 net@514 net@576 I12 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@22 net@576#4pin@204_metal-1 S1#55nmos@22_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=26.879P AD=1.684P PS=65.462U PD=5.425U
Mnmos@23 net@514 S1#57nmos@23_poly-left I14 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@24 net@610 net@578 I13 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@25 net@578#2contact@208_metal-1-n-act S1#72nmos@25_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=26.879P AD=1.684P PS=65.462U PD=5.425U
Mnmos@26 net@610 S1#62nmos@26_poly-left I15 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@27 net@523 net@495#6nmos@27_poly-right net@514 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@28 net@495 S2#39nmos@28_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=26.879P AD=1.684P PS=65.462U PD=5.425U
Mnmos@29 net@523 S2#29nmos@29_poly-left net@610 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@30 net@726 net@727#7nmos@30_poly-right I8 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@31 net@727 S1#102nmos@31_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=26.879P AD=1.684P PS=65.462U PD=5.425U
Mnmos@32 net@726 S1#88nmos@32_poly-left I10 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@33 net@747 net@728#11nmos@33_poly-right I9 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@34 net@728#4contact@277_metal-1-n-act S1#95nmos@34_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=26.879P AD=1.684P PS=65.462U PD=5.425U
Mnmos@35 net@747 S1#105nmos@35_poly-left I11 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@36 net@518 net@844#8nmos@36_poly-right net@726 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@37 net@844 S2#37nmos@37_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=26.879P AD=1.684P PS=65.462U PD=5.425U
Mnmos@38 net@518 S2#48nmos@38_poly-left net@747 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@39 net@508 net@510#6nmos@39_poly-right net@518 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@40 net@510 S0#17nmos@40_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=26.879P AD=1.684P PS=65.462U PD=5.425U
Mnmos@41 net@508 S0#25nmos@41_poly-left net@523 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@42 out net@1014#6nmos@42_poly-right net@508 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@43 net@1014 S3#2nmos@43_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=26.879P AD=1.684P PS=65.462U PD=5.425U
Mnmos@44 out S3#10nmos@44_poly-left net@349 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@0 I4 S1#49pmos@0_poly-left net@0 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@1 vdd S1#54pmos@1_poly-right net@1 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=39.774P PS=5.425U PD=69.032U
Mpmos@2 I6 net@1#8pmos@2_poly-left net@0 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@3 I5 S1#15pmos@3_poly-left net@18 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@4 vdd S1#19pmos@4_poly-right net@2#4contact@26_metal-1-n-act vdd PMOS L=0.35U W=1.75U AS=1.684P AD=39.774P PS=5.425U PD=69.032U
Mpmos@5 I7 net@2 net@18 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@6 net@0 S2#15pmos@6_poly-left net@14 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@7 vdd S2#21pmos@7_poly-right net@97 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=39.774P PS=5.425U PD=69.032U
Mpmos@8 net@18 net@97#9pmos@8_poly-left net@14 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@9 I0 S1#41pmos@9_poly-left net@104 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@10 vdd S1#46pmos@10_poly-right net@105 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=39.774P PS=5.425U PD=69.032U
Mpmos@11 I2 net@105#8pmos@11_poly-left net@104 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@12 I1 S1#35pmos@12_poly-left net@123 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@13 vdd S1#39pmos@13_poly-right net@106#4contact@95_metal-1-n-act vdd PMOS L=0.35U W=1.75U AS=1.684P AD=39.774P PS=5.425U PD=69.032U
Mpmos@14 I3 net@106 net@123 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@15 net@104 S2#9pmos@15_poly-left net@199 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@16 vdd S2#13pmos@16_poly-right net@210 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=39.774P PS=5.425U PD=69.032U
Mpmos@17 net@123 net@210#9pmos@17_poly-left net@199 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@18 net@199 S0#4pmos@18_poly-left net@349 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@19 vdd S0#8pmos@19_poly-right net@350 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=39.774P PS=5.425U PD=69.032U
Mpmos@20 net@14 net@350#9pmos@20_poly-left net@349 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@21 I12 S1#60pmos@21_poly-left net@514 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@22 vdd S1#68pmos@22_poly-right net@576#4pin@204_metal-1 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=39.774P PS=5.425U PD=69.032U
Mpmos@23 I14 net@576#2pmos@23_poly-left net@514 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@24 I13 S1#73pmos@24_poly-left net@610 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@25 vdd S1#76pmos@25_poly-right net@578#2contact@208_metal-1-n-act vdd PMOS L=0.35U W=1.75U AS=1.684P AD=39.774P PS=5.425U PD=69.032U
Mpmos@26 I15 net@578#11pmos@26_poly-left net@610 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@27 net@514 S2#46pmos@27_poly-left net@523 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@28 vdd S2#51pmos@28_poly-right net@495 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=39.774P PS=5.425U PD=69.032U
Mpmos@29 net@610 net@495#7pmos@29_poly-left net@523 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@30 I8 S1#103pmos@30_poly-left net@726 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@31 vdd S1#108pmos@31_poly-right net@727 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=39.774P PS=5.425U PD=69.032U
Mpmos@32 I10 net@727#8pmos@32_poly-left net@726 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@33 I9 S1#97pmos@33_poly-left net@747 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@34 vdd S1#101pmos@34_poly-right net@728#4contact@277_metal-1-n-act vdd PMOS L=0.35U W=1.75U AS=1.684P AD=39.774P PS=5.425U PD=69.032U
Mpmos@35 I11 net@728 net@747 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@36 net@726 S2#40pmos@36_poly-left net@518 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@37 vdd S2#44pmos@37_poly-right net@844 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=39.774P PS=5.425U PD=69.032U
Mpmos@38 net@747 net@844#9pmos@38_poly-left net@518 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@39 net@518 S0#19pmos@39_poly-left net@508 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@40 vdd S0#23pmos@40_poly-right net@510 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=39.774P PS=5.425U PD=69.032U
Mpmos@41 net@523 net@510#9pmos@41_poly-left net@508 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@42 net@508 S3#4pmos@42_poly-left out vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@43 vdd S3#8pmos@43_poly-right net@1014 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=39.774P PS=5.425U PD=69.032U
Mpmos@44 net@349 net@1014#9pmos@44_poly-left out vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
** Extracted Parasitic Capacitors ***
C0 I4 0 4.78fF
C1 net@0 0 16.814fF
C2 net@1 0 1.643fF
C3 S1 0 26.441fF
C4 I6 0 5.909fF
C5 I5 0 4.78fF
C6 net@18 0 13.451fF
C7 net@2#4contact@26_metal-1-n-act 0 1.643fF
C8 I7 0 5.909fF
C9 net@14 0 24.441fF
C10 net@97 0 1.643fF
C11 S2 0 36.033fF
C12 I0 0 12.603fF
C13 net@104 0 16.814fF
C14 net@105 0 1.643fF
C15 I2 0 13.799fF
C16 I1 0 12.638fF
C17 net@123 0 13.451fF
C18 net@106#4contact@95_metal-1-n-act 0 1.643fF
C19 I3 0 13.795fF
C20 net@199 0 12.136fF
C21 net@210 0 1.643fF
C22 net@349 0 19.051fF
C23 net@350 0 1.643fF
C24 S0 0 48.439fF
C25 I12 0 4.78fF
C26 net@514 0 16.814fF
C27 net@576#4pin@204_metal-1 0 1.643fF
C28 S1#64contact@192_metal-1-polysilicon-1 0 26.418fF
C29 I14 0 5.909fF
C30 I13 0 4.78fF
C31 net@610 0 13.451fF
C32 net@578#2contact@208_metal-1-n-act 0 1.643fF
C33 I15 0 5.909fF
C34 net@523 0 23.29fF
C35 net@495 0 1.643fF
C36 I8 0 12.603fF
C37 net@726 0 16.814fF
C38 net@727 0 1.643fF
C39 I10 0 13.799fF
C40 I9 0 12.638fF
C41 net@747 0 13.451fF
C42 net@728#4contact@277_metal-1-n-act 0 1.643fF
C43 I11 0 13.795fF
C44 net@518 0 11.655fF
C45 net@844 0 1.643fF
C46 net@508 0 9.593fF
C47 net@510 0 1.643fF
C48 out 0 8.095fF
C49 net@1014 0 1.643fF
C50 S3 0 21.15fF
C51 S1#9pin@2_polysilicon-1 0 0.149fF
C52 S1#50pin@5_polysilicon-1 0 0.13fF
C53 S1#53pin@6_polysilicon-1 0 0.171fF
C54 S1#7pin@11_polysilicon-1 0 0.137fF
C55 S1#8pin@12_polysilicon-1 0 0.177fF
C56 net@1#9pin@13_polysilicon-1 0 0.113fF
C57 net@1#10pin@14_polysilicon-1 0 0.156fF
C58 net@1#3pin@15_polysilicon-1 0 0.149fF
C59 net@1#4pin@17_polysilicon-1 0 0.184fF
C60 S1#14pin@25_polysilicon-1 0 0.149fF
C61 S1#16pin@28_polysilicon-1 0 0.13fF
C62 S1#17pin@29_polysilicon-1 0 0.171fF
C63 S1#52pin@34_polysilicon-1 0 0.137fF
C64 S1#11pin@35_polysilicon-1 0 0.177fF
C65 net@2#1pin@36_polysilicon-1 0 0.113fF
C66 net@2#2pin@37_polysilicon-1 0 0.156fF
C67 net@2#3pin@38_polysilicon-1 0 0.149fF
C68 net@2#6pin@40_polysilicon-1 0 0.184fF
C69 S2#8pin@48_polysilicon-1 0 0.149fF
C70 S2#16pin@51_polysilicon-1 0 0.13fF
C71 S2#19pin@52_polysilicon-1 0 0.171fF
C72 S2#26pin@56_polysilicon-1 0 0.137fF
C73 S2#2pin@57_polysilicon-1 0 0.177fF
C74 net@97#10pin@58_polysilicon-1 0 0.113fF
C75 net@97#11pin@59_polysilicon-1 0 0.156fF
C76 net@97#6pin@60_polysilicon-1 0 0.149fF
C77 net@97#2pin@62_polysilicon-1 0 0.184fF
C78 S1#29pin@77_polysilicon-1 0 0.149fF
C79 S1#42pin@80_polysilicon-1 0 0.13fF
C80 S1#45pin@81_polysilicon-1 0 0.171fF
C81 S1#27pin@86_polysilicon-1 0 0.137fF
C82 S1#28pin@87_polysilicon-1 0 0.177fF
C83 net@105#9pin@88_polysilicon-1 0 0.113fF
C84 net@105#10pin@89_polysilicon-1 0 0.156fF
C85 net@105#3pin@90_polysilicon-1 0 0.149fF
C86 net@105#4pin@92_polysilicon-1 0 0.184fF
C87 S1#34pin@100_polysilicon-1 0 0.149fF
C88 S1#36pin@103_polysilicon-1 0 0.13fF
C89 S1#37pin@104_polysilicon-1 0 0.171fF
C90 S1#44pin@109_polysilicon-1 0 0.137fF
C91 S1#31pin@110_polysilicon-1 0 0.177fF
C92 net@106#1pin@111_polysilicon-1 0 0.113fF
C93 net@106#2pin@112_polysilicon-1 0 0.156fF
C94 net@106#3pin@113_polysilicon-1 0 0.149fF
C95 net@106#6pin@115_polysilicon-1 0 0.184fF
C96 S2#6pin@123_polysilicon-1 0 0.149fF
C97 S2#10pin@126_polysilicon-1 0 0.13fF
C98 S2#11pin@127_polysilicon-1 0 0.171fF
C99 S2#18pin@131_polysilicon-1 0 0.137fF
C100 S2#4pin@132_polysilicon-1 0 0.177fF
C101 net@210#10pin@133_polysilicon-1 0 0.113fF
C102 net@210#11pin@134_polysilicon-1 0 0.156fF
C103 net@210#6pin@135_polysilicon-1 0 0.149fF
C104 net@210#2pin@137_polysilicon-1 0 0.184fF
C105 S0#3pin@161_polysilicon-1 0 0.149fF
C106 S0#5pin@164_polysilicon-1 0 0.13fF
C107 S0#6pin@165_polysilicon-1 0 0.171fF
C108 S0#11pin@170_polysilicon-1 0 0.137fF
C109 S0#1pin@171_polysilicon-1 0 0.177fF
C110 net@350#10pin@172_polysilicon-1 0 0.113fF
C111 net@350#11pin@173_polysilicon-1 0 0.156fF
C112 net@350#4pin@174_polysilicon-1 0 0.149fF
C113 net@350#5pin@176_polysilicon-1 0 0.184fF
C114 S1#56pin@190_polysilicon-1 0 0.149fF
C115 S1#61pin@193_polysilicon-1 0 0.13fF
C116 S1#65pin@194_polysilicon-1 0 0.171fF
C117 S1#58pin@199_polysilicon-1 0 0.137fF
C118 S1#59pin@200_polysilicon-1 0 0.177fF
C119 net@576#3pin@201_polysilicon-1 0 0.113fF
C120 net@576#6pin@202_polysilicon-1 0 0.156fF
C121 net@576#7pin@203_polysilicon-1 0 0.149fF
C122 net@576#1pin@205_polysilicon-1 0 0.184fF
C123 S1#70pin@213_polysilicon-1 0 0.149fF
C124 S1#74pin@216_polysilicon-1 0 0.13fF
C125 S1#75pin@217_polysilicon-1 0 0.171fF
C126 S1#63pin@222_polysilicon-1 0 0.137fF
C127 S1#67pin@223_polysilicon-1 0 0.177fF
C128 net@578#9pin@224_polysilicon-1 0 0.113fF
C129 net@578#10pin@225_polysilicon-1 0 0.156fF
C130 net@578#7pin@226_polysilicon-1 0 0.149fF
C131 net@578#1pin@228_polysilicon-1 0 0.184fF
C132 S2#32pin@236_polysilicon-1 0 0.149fF
C133 S2#47pin@239_polysilicon-1 0 0.13fF
C134 S2#50pin@240_polysilicon-1 0 0.171fF
C135 S2#30pin@244_polysilicon-1 0 0.137fF
C136 S2#31pin@245_polysilicon-1 0 0.177fF
C137 net@495#8pin@246_polysilicon-1 0 0.113fF
C138 net@495#9pin@247_polysilicon-1 0 0.156fF
C139 net@495#2pin@248_polysilicon-1 0 0.149fF
C140 net@495#3pin@250_polysilicon-1 0 0.184fF
C141 S1#91pin@265_polysilicon-1 0 0.149fF
C142 S1#104pin@268_polysilicon-1 0 0.13fF
C143 S1#107pin@269_polysilicon-1 0 0.171fF
C144 S1#89pin@274_polysilicon-1 0 0.137fF
C145 S1#90pin@275_polysilicon-1 0 0.177fF
C146 net@727#9pin@276_polysilicon-1 0 0.113fF
C147 net@727#10pin@277_polysilicon-1 0 0.156fF
C148 net@727#3pin@278_polysilicon-1 0 0.149fF
C149 net@727#4pin@280_polysilicon-1 0 0.184fF
C150 S1#96pin@288_polysilicon-1 0 0.149fF
C151 S1#98pin@291_polysilicon-1 0 0.13fF
C152 S1#99pin@292_polysilicon-1 0 0.171fF
C153 S1#106pin@297_polysilicon-1 0 0.137fF
C154 S1#93pin@298_polysilicon-1 0 0.177fF
C155 net@728#1pin@299_polysilicon-1 0 0.113fF
C156 net@728#2pin@300_polysilicon-1 0 0.156fF
C157 net@728#3pin@301_polysilicon-1 0 0.149fF
C158 net@728#6pin@303_polysilicon-1 0 0.184fF
C159 S2#38pin@311_polysilicon-1 0 0.149fF
C160 S2#41pin@314_polysilicon-1 0 0.13fF
C161 S2#42pin@315_polysilicon-1 0 0.171fF
C162 S2#49pin@319_polysilicon-1 0 0.137fF
C163 S2#36pin@320_polysilicon-1 0 0.177fF
C164 net@844#10pin@321_polysilicon-1 0 0.113fF
C165 net@844#11pin@322_polysilicon-1 0 0.156fF
C166 net@844#6pin@323_polysilicon-1 0 0.149fF
C167 net@844#2pin@325_polysilicon-1 0 0.184fF
C168 S0#18pin@349_polysilicon-1 0 0.149fF
C169 S0#20pin@352_polysilicon-1 0 0.13fF
C170 S0#21pin@353_polysilicon-1 0 0.171fF
C171 S0#26pin@358_polysilicon-1 0 0.137fF
C172 S0#16pin@359_polysilicon-1 0 0.177fF
C173 net@510#10pin@360_polysilicon-1 0 0.113fF
C174 net@510#11pin@361_polysilicon-1 0 0.156fF
C175 net@510#4pin@362_polysilicon-1 0 0.149fF
C176 net@510#5pin@364_polysilicon-1 0 0.184fF
C177 S3#3pin@393_polysilicon-1 0 0.149fF
C178 S3#5pin@396_polysilicon-1 0 0.13fF
C179 S3#6pin@397_polysilicon-1 0 0.171fF
C180 S3#11pin@402_polysilicon-1 0 0.137fF
C181 S3#1pin@403_polysilicon-1 0 0.177fF
C182 net@1014#10pin@404_polysilicon-1 0 0.113fF
C183 net@1014#11pin@405_polysilicon-1 0 0.156fF
C184 net@1014#4pin@406_polysilicon-1 0 0.149fF
C185 net@1014#5pin@408_polysilicon-1 0 0.184fF
** Extracted Parasitic Resistors ***
R0 net@2 net@2#1pin@36_polysilicon-1 7.75
R1 net@2#1pin@36_polysilicon-1 net@2#1pin@36_polysilicon-1##0 9.042
R2 net@2#1pin@36_polysilicon-1##0 net@2#1pin@36_polysilicon-1##1 9.042
R3 net@2#1pin@36_polysilicon-1##1 net@2#1pin@36_polysilicon-1##2 9.042
R4 net@2#1pin@36_polysilicon-1##2 net@2#1pin@36_polysilicon-1##3 9.042
R5 net@2#1pin@36_polysilicon-1##3 net@2#1pin@36_polysilicon-1##4 9.042
R6 net@2#1pin@36_polysilicon-1##4 net@2#2pin@37_polysilicon-1 9.042
R7 net@2#2pin@37_polysilicon-1 net@2#2pin@37_polysilicon-1##0 9.3
R8 net@2#2pin@37_polysilicon-1##0 net@2#2pin@37_polysilicon-1##1 9.3
R9 net@2#2pin@37_polysilicon-1##1 net@2#2pin@37_polysilicon-1##2 9.3
R10 net@2#2pin@37_polysilicon-1##2 net@2#2pin@37_polysilicon-1##3 9.3
R11 net@2#2pin@37_polysilicon-1##3 net@2#2pin@37_polysilicon-1##4 9.3
R12 net@2#2pin@37_polysilicon-1##4 net@2#2pin@37_polysilicon-1##5 9.3
R13 net@2#2pin@37_polysilicon-1##5 net@2#2pin@37_polysilicon-1##6 9.3
R14 net@2#2pin@37_polysilicon-1##6 net@2#3pin@38_polysilicon-1 9.3
R15 net@1#3pin@15_polysilicon-1 net@1#3pin@15_polysilicon-1##0 8.37
R16 net@1#3pin@15_polysilicon-1##0 net@1#3pin@15_polysilicon-1##1 8.37
R17 net@1#3pin@15_polysilicon-1##1 net@1#3pin@15_polysilicon-1##2 8.37
R18 net@1#3pin@15_polysilicon-1##2 net@1#3pin@15_polysilicon-1##3 8.37
R19 net@1#3pin@15_polysilicon-1##3 net@1#4pin@17_polysilicon-1 8.37
R20 net@1#7nmos@0_poly-right net@1#7nmos@0_poly-right##0 6.2
R21 net@1#7nmos@0_poly-right##0 net@1#4pin@17_polysilicon-1 6.2
R22 S1#6nmos@2_poly-left S1#6nmos@2_poly-left##0 6.975
R23 S1#6nmos@2_poly-left##0 S1#7pin@11_polysilicon-1 6.975
R24 S1#7pin@11_polysilicon-1 S1#7pin@11_polysilicon-1##0 9.772
R25 S1#7pin@11_polysilicon-1##0 S1#7pin@11_polysilicon-1##1 9.772
R26 S1#7pin@11_polysilicon-1##1 S1#7pin@11_polysilicon-1##2 9.772
R27 S1#7pin@11_polysilicon-1##2 S1#7pin@11_polysilicon-1##3 9.772
R28 S1#7pin@11_polysilicon-1##3 S1#7pin@11_polysilicon-1##4 9.772
R29 S1#7pin@11_polysilicon-1##4 S1#7pin@11_polysilicon-1##5 9.772
R30 S1#7pin@11_polysilicon-1##5 S1#7pin@11_polysilicon-1##6 9.772
R31 S1#7pin@11_polysilicon-1##6 S1#7pin@11_polysilicon-1##7 9.772
R32 S1#7pin@11_polysilicon-1##7 S1#7pin@11_polysilicon-1##8 9.772
R33 S1#7pin@11_polysilicon-1##8 S1#7pin@11_polysilicon-1##9 9.772
R34 S1#7pin@11_polysilicon-1##9 S1#7pin@11_polysilicon-1##10 9.772
R35 S1#7pin@11_polysilicon-1##10 S1#7pin@11_polysilicon-1##11 9.772
R36 S1#7pin@11_polysilicon-1##11 S1#7pin@11_polysilicon-1##12 9.772
R37 S1#7pin@11_polysilicon-1##12 S1#7pin@11_polysilicon-1##13 9.772
R38 S1#7pin@11_polysilicon-1##13 S1#7pin@11_polysilicon-1##14 9.772
R39 S1#7pin@11_polysilicon-1##14 S1#7pin@11_polysilicon-1##15 9.772
R40 S1#7pin@11_polysilicon-1##15 S1#7pin@11_polysilicon-1##16 9.772
R41 S1#7pin@11_polysilicon-1##16 S1#7pin@11_polysilicon-1##17 9.772
R42 S1#7pin@11_polysilicon-1##17 S1#7pin@11_polysilicon-1##18 9.772
R43 S1#7pin@11_polysilicon-1##18 S1#7pin@11_polysilicon-1##19 9.772
R44 S1#7pin@11_polysilicon-1##19 S1#7pin@11_polysilicon-1##20 9.772
R45 S1#7pin@11_polysilicon-1##20 S1#7pin@11_polysilicon-1##21 9.772
R46 S1#7pin@11_polysilicon-1##21 S1#8pin@12_polysilicon-1 9.772
R47 S1 S1##0 8.267
R48 S1##0 S1##1 8.267
R49 S1##1 S1#9pin@2_polysilicon-1 8.267
R50 net@1#8pmos@2_poly-left net@1#9pin@13_polysilicon-1 7.75
R51 net@1#9pin@13_polysilicon-1 net@1#9pin@13_polysilicon-1##0 9.042
R52 net@1#9pin@13_polysilicon-1##0 net@1#9pin@13_polysilicon-1##1 9.042
R53 net@1#9pin@13_polysilicon-1##1 net@1#9pin@13_polysilicon-1##2 9.042
R54 net@1#9pin@13_polysilicon-1##2 net@1#9pin@13_polysilicon-1##3 9.042
R55 net@1#9pin@13_polysilicon-1##3 net@1#9pin@13_polysilicon-1##4 9.042
R56 net@1#9pin@13_polysilicon-1##4 net@1#10pin@14_polysilicon-1 9.042
R57 net@1#10pin@14_polysilicon-1 net@1#10pin@14_polysilicon-1##0 9.3
R58 net@1#10pin@14_polysilicon-1##0 net@1#10pin@14_polysilicon-1##1 9.3
R59 net@1#10pin@14_polysilicon-1##1 net@1#10pin@14_polysilicon-1##2 9.3
R60 net@1#10pin@14_polysilicon-1##2 net@1#10pin@14_polysilicon-1##3 9.3
R61 net@1#10pin@14_polysilicon-1##3 net@1#10pin@14_polysilicon-1##4 9.3
R62 net@1#10pin@14_polysilicon-1##4 net@1#10pin@14_polysilicon-1##5 9.3
R63 net@1#10pin@14_polysilicon-1##5 net@1#10pin@14_polysilicon-1##6 9.3
R64 net@1#10pin@14_polysilicon-1##6 net@1#3pin@15_polysilicon-1 9.3
R65 S1 S1##0 9.881
R66 S1##0 S1##1 9.881
R67 S1##1 S1##2 9.881
R68 S1##2 S1##3 9.881
R69 S1##3 S1##4 9.881
R70 S1##4 S1##5 9.881
R71 S1##5 S1##6 9.881
R72 S1##6 S1#11pin@35_polysilicon-1 9.881
R73 net@2#6pin@40_polysilicon-1 net@2#6pin@40_polysilicon-1##0 9.042
R74 net@2#6pin@40_polysilicon-1##0 net@2#6pin@40_polysilicon-1##1 9.042
R75 net@2#6pin@40_polysilicon-1##1 net@2#6pin@40_polysilicon-1##2 9.042
R76 net@2#6pin@40_polysilicon-1##2 net@2#6pin@40_polysilicon-1##3 9.042
R77 net@2#6pin@40_polysilicon-1##3 net@2#6pin@40_polysilicon-1##4 9.042
R78 net@2#6pin@40_polysilicon-1##4 net@2#4contact@26_metal-1-n-act 9.042
R79 S1 S1##0 9.881
R80 S1##0 S1##1 9.881
R81 S1##1 S1##2 9.881
R82 S1##2 S1##3 9.881
R83 S1##3 S1##4 9.881
R84 S1##4 S1##5 9.881
R85 S1##5 S1##6 9.881
R86 S1##6 S1#8pin@12_polysilicon-1 9.881
R87 S1#13nmos@4_poly-right S1#13nmos@4_poly-right##0 7.233
R88 S1#13nmos@4_poly-right##0 S1#13nmos@4_poly-right##1 7.233
R89 S1#13nmos@4_poly-right##1 S1#14pin@25_polysilicon-1 7.233
R90 S1#15pmos@3_poly-left S1#15pmos@3_poly-left##0 6.2
R91 S1#15pmos@3_poly-left##0 S1#16pin@28_polysilicon-1 6.2
R92 S1#16pin@28_polysilicon-1 S1#16pin@28_polysilicon-1##0 9.896
R93 S1#16pin@28_polysilicon-1##0 S1#16pin@28_polysilicon-1##1 9.896
R94 S1#16pin@28_polysilicon-1##1 S1#16pin@28_polysilicon-1##2 9.896
R95 S1#16pin@28_polysilicon-1##2 S1#16pin@28_polysilicon-1##3 9.896
R96 S1#16pin@28_polysilicon-1##3 S1#16pin@28_polysilicon-1##4 9.896
R97 S1#16pin@28_polysilicon-1##4 S1#16pin@28_polysilicon-1##5 9.896
R98 S1#16pin@28_polysilicon-1##5 S1#16pin@28_polysilicon-1##6 9.896
R99 S1#16pin@28_polysilicon-1##6 S1#16pin@28_polysilicon-1##7 9.896
R100 S1#16pin@28_polysilicon-1##7 S1#16pin@28_polysilicon-1##8 9.896
R101 S1#16pin@28_polysilicon-1##8 S1#16pin@28_polysilicon-1##9 9.896
R102 S1#16pin@28_polysilicon-1##9 S1#16pin@28_polysilicon-1##10 9.896
R103 S1#16pin@28_polysilicon-1##10 S1#16pin@28_polysilicon-1##11 9.896
R104 S1#16pin@28_polysilicon-1##11 S1#17pin@29_polysilicon-1 9.896
R105 S1#17pin@29_polysilicon-1 S1#17pin@29_polysilicon-1##0 9.521
R106 S1#17pin@29_polysilicon-1##0 S1#17pin@29_polysilicon-1##1 9.521
R107 S1#17pin@29_polysilicon-1##1 S1#17pin@29_polysilicon-1##2 9.521
R108 S1#17pin@29_polysilicon-1##2 S1#17pin@29_polysilicon-1##3 9.521
R109 S1#17pin@29_polysilicon-1##3 S1#17pin@29_polysilicon-1##4 9.521
R110 S1#17pin@29_polysilicon-1##4 S1#17pin@29_polysilicon-1##5 9.521
R111 S1#17pin@29_polysilicon-1##5 S1 9.521
R112 S1#14pin@25_polysilicon-1 S1#14pin@25_polysilicon-1##0 5.425
R113 S1#14pin@25_polysilicon-1##0 S1#19pmos@4_poly-right 5.425
R114 net@1#4pin@17_polysilicon-1 net@1#4pin@17_polysilicon-1##0 9.042
R115 net@1#4pin@17_polysilicon-1##0 net@1#4pin@17_polysilicon-1##1 9.042
R116 net@1#4pin@17_polysilicon-1##1 net@1#4pin@17_polysilicon-1##2 9.042
R117 net@1#4pin@17_polysilicon-1##2 net@1#4pin@17_polysilicon-1##3 9.042
R118 net@1#4pin@17_polysilicon-1##3 net@1#4pin@17_polysilicon-1##4 9.042
R119 net@1#4pin@17_polysilicon-1##4 net@1 9.042
R120 net@2#3pin@38_polysilicon-1 net@2#3pin@38_polysilicon-1##0 8.37
R121 net@2#3pin@38_polysilicon-1##0 net@2#3pin@38_polysilicon-1##1 8.37
R122 net@2#3pin@38_polysilicon-1##1 net@2#3pin@38_polysilicon-1##2 8.37
R123 net@2#3pin@38_polysilicon-1##2 net@2#3pin@38_polysilicon-1##3 8.37
R124 net@2#3pin@38_polysilicon-1##3 net@2#6pin@40_polysilicon-1 8.37
R125 net@106 net@106#1pin@111_polysilicon-1 7.75
R126 net@106#1pin@111_polysilicon-1 net@106#1pin@111_polysilicon-1##0 9.042
R127 net@106#1pin@111_polysilicon-1##0 net@106#1pin@111_polysilicon-1##1 9.042
R128 net@106#1pin@111_polysilicon-1##1 net@106#1pin@111_polysilicon-1##2 9.042
R129 net@106#1pin@111_polysilicon-1##2 net@106#1pin@111_polysilicon-1##3 9.042
R130 net@106#1pin@111_polysilicon-1##3 net@106#1pin@111_polysilicon-1##4 9.042
R131 net@106#1pin@111_polysilicon-1##4 net@106#2pin@112_polysilicon-1 9.042
R132 net@106#2pin@112_polysilicon-1 net@106#2pin@112_polysilicon-1##0 9.3
R133 net@106#2pin@112_polysilicon-1##0 net@106#2pin@112_polysilicon-1##1 9.3
R134 net@106#2pin@112_polysilicon-1##1 net@106#2pin@112_polysilicon-1##2 9.3
R135 net@106#2pin@112_polysilicon-1##2 net@106#2pin@112_polysilicon-1##3 9.3
R136 net@106#2pin@112_polysilicon-1##3 net@106#2pin@112_polysilicon-1##4 9.3
R137 net@106#2pin@112_polysilicon-1##4 net@106#2pin@112_polysilicon-1##5 9.3
R138 net@106#2pin@112_polysilicon-1##5 net@106#2pin@112_polysilicon-1##6 9.3
R139 net@106#2pin@112_polysilicon-1##6 net@106#3pin@113_polysilicon-1 9.3
R140 net@105#3pin@90_polysilicon-1 net@105#3pin@90_polysilicon-1##0 8.37
R141 net@105#3pin@90_polysilicon-1##0 net@105#3pin@90_polysilicon-1##1 8.37
R142 net@105#3pin@90_polysilicon-1##1 net@105#3pin@90_polysilicon-1##2 8.37
R143 net@105#3pin@90_polysilicon-1##2 net@105#3pin@90_polysilicon-1##3 8.37
R144 net@105#3pin@90_polysilicon-1##3 net@105#4pin@92_polysilicon-1 8.37
R145 net@105#7nmos@9_poly-right net@105#7nmos@9_poly-right##0 6.2
R146 net@105#7nmos@9_poly-right##0 net@105#4pin@92_polysilicon-1 6.2
R147 S2 S2##0 9.881
R148 S2##0 S2##1 9.881
R149 S2##1 S2##2 9.881
R150 S2##2 S2##3 9.881
R151 S2##3 S2##4 9.881
R152 S2##4 S2##5 9.881
R153 S2##5 S2##6 9.881
R154 S2##6 S2#2pin@57_polysilicon-1 9.881
R155 S1#26nmos@11_poly-left S1#26nmos@11_poly-left##0 6.975
R156 S1#26nmos@11_poly-left##0 S1#27pin@86_polysilicon-1 6.975
R157 S1#27pin@86_polysilicon-1 S1#27pin@86_polysilicon-1##0 9.772
R158 S1#27pin@86_polysilicon-1##0 S1#27pin@86_polysilicon-1##1 9.772
R159 S1#27pin@86_polysilicon-1##1 S1#27pin@86_polysilicon-1##2 9.772
R160 S1#27pin@86_polysilicon-1##2 S1#27pin@86_polysilicon-1##3 9.772
R161 S1#27pin@86_polysilicon-1##3 S1#27pin@86_polysilicon-1##4 9.772
R162 S1#27pin@86_polysilicon-1##4 S1#27pin@86_polysilicon-1##5 9.772
R163 S1#27pin@86_polysilicon-1##5 S1#27pin@86_polysilicon-1##6 9.772
R164 S1#27pin@86_polysilicon-1##6 S1#27pin@86_polysilicon-1##7 9.772
R165 S1#27pin@86_polysilicon-1##7 S1#27pin@86_polysilicon-1##8 9.772
R166 S1#27pin@86_polysilicon-1##8 S1#27pin@86_polysilicon-1##9 9.772
R167 S1#27pin@86_polysilicon-1##9 S1#27pin@86_polysilicon-1##10 9.772
R168 S1#27pin@86_polysilicon-1##10 S1#27pin@86_polysilicon-1##11 9.772
R169 S1#27pin@86_polysilicon-1##11 S1#27pin@86_polysilicon-1##12 9.772
R170 S1#27pin@86_polysilicon-1##12 S1#27pin@86_polysilicon-1##13 9.772
R171 S1#27pin@86_polysilicon-1##13 S1#27pin@86_polysilicon-1##14 9.772
R172 S1#27pin@86_polysilicon-1##14 S1#27pin@86_polysilicon-1##15 9.772
R173 S1#27pin@86_polysilicon-1##15 S1#27pin@86_polysilicon-1##16 9.772
R174 S1#27pin@86_polysilicon-1##16 S1#27pin@86_polysilicon-1##17 9.772
R175 S1#27pin@86_polysilicon-1##17 S1#27pin@86_polysilicon-1##18 9.772
R176 S1#27pin@86_polysilicon-1##18 S1#27pin@86_polysilicon-1##19 9.772
R177 S1#27pin@86_polysilicon-1##19 S1#27pin@86_polysilicon-1##20 9.772
R178 S1#27pin@86_polysilicon-1##20 S1#27pin@86_polysilicon-1##21 9.772
R179 S1#27pin@86_polysilicon-1##21 S1#28pin@87_polysilicon-1 9.772
R180 S1 S1##0 8.267
R181 S1##0 S1##1 8.267
R182 S1##1 S1#29pin@77_polysilicon-1 8.267
R183 net@105#8pmos@11_poly-left net@105#9pin@88_polysilicon-1 7.75
R184 net@105#9pin@88_polysilicon-1 net@105#9pin@88_polysilicon-1##0 9.042
R185 net@105#9pin@88_polysilicon-1##0 net@105#9pin@88_polysilicon-1##1 9.042
R186 net@105#9pin@88_polysilicon-1##1 net@105#9pin@88_polysilicon-1##2 9.042
R187 net@105#9pin@88_polysilicon-1##2 net@105#9pin@88_polysilicon-1##3 9.042
R188 net@105#9pin@88_polysilicon-1##3 net@105#9pin@88_polysilicon-1##4 9.042
R189 net@105#9pin@88_polysilicon-1##4 net@105#10pin@89_polysilicon-1 9.042
R190 net@105#10pin@89_polysilicon-1 net@105#10pin@89_polysilicon-1##0 9.3
R191 net@105#10pin@89_polysilicon-1##0 net@105#10pin@89_polysilicon-1##1 9.3
R192 net@105#10pin@89_polysilicon-1##1 net@105#10pin@89_polysilicon-1##2 9.3
R193 net@105#10pin@89_polysilicon-1##2 net@105#10pin@89_polysilicon-1##3 9.3
R194 net@105#10pin@89_polysilicon-1##3 net@105#10pin@89_polysilicon-1##4 9.3
R195 net@105#10pin@89_polysilicon-1##4 net@105#10pin@89_polysilicon-1##5 9.3
R196 net@105#10pin@89_polysilicon-1##5 net@105#10pin@89_polysilicon-1##6 9.3
R197 net@105#10pin@89_polysilicon-1##6 net@105#3pin@90_polysilicon-1 9.3
R198 net@97#2pin@62_polysilicon-1 net@97#2pin@62_polysilicon-1##0 9.042
R199 net@97#2pin@62_polysilicon-1##0 net@97#2pin@62_polysilicon-1##1 9.042
R200 net@97#2pin@62_polysilicon-1##1 net@97#2pin@62_polysilicon-1##2 9.042
R201 net@97#2pin@62_polysilicon-1##2 net@97#2pin@62_polysilicon-1##3 9.042
R202 net@97#2pin@62_polysilicon-1##3 net@97#2pin@62_polysilicon-1##4 9.042
R203 net@97#2pin@62_polysilicon-1##4 net@97 9.042
R204 S1 S1##0 9.881
R205 S1##0 S1##1 9.881
R206 S1##1 S1##2 9.881
R207 S1##2 S1##3 9.881
R208 S1##3 S1##4 9.881
R209 S1##4 S1##5 9.881
R210 S1##5 S1##6 9.881
R211 S1##6 S1#31pin@110_polysilicon-1 9.881
R212 net@106#6pin@115_polysilicon-1 net@106#6pin@115_polysilicon-1##0 9.042
R213 net@106#6pin@115_polysilicon-1##0 net@106#6pin@115_polysilicon-1##1 9.042
R214 net@106#6pin@115_polysilicon-1##1 net@106#6pin@115_polysilicon-1##2 9.042
R215 net@106#6pin@115_polysilicon-1##2 net@106#6pin@115_polysilicon-1##3 9.042
R216 net@106#6pin@115_polysilicon-1##3 net@106#6pin@115_polysilicon-1##4 9.042
R217 net@106#6pin@115_polysilicon-1##4 net@106#4contact@95_metal-1-n-act 9.042
R218 S1 S1##0 9.881
R219 S1##0 S1##1 9.881
R220 S1##1 S1##2 9.881
R221 S1##2 S1##3 9.881
R222 S1##3 S1##4 9.881
R223 S1##4 S1##5 9.881
R224 S1##5 S1##6 9.881
R225 S1##6 S1#28pin@87_polysilicon-1 9.881
R226 S1#33nmos@13_poly-right S1#33nmos@13_poly-right##0 7.233
R227 S1#33nmos@13_poly-right##0 S1#33nmos@13_poly-right##1 7.233
R228 S1#33nmos@13_poly-right##1 S1#34pin@100_polysilicon-1 7.233
R229 S1#35pmos@12_poly-left S1#35pmos@12_poly-left##0 6.2
R230 S1#35pmos@12_poly-left##0 S1#36pin@103_polysilicon-1 6.2
R231 S1#36pin@103_polysilicon-1 S1#36pin@103_polysilicon-1##0 9.896
R232 S1#36pin@103_polysilicon-1##0 S1#36pin@103_polysilicon-1##1 9.896
R233 S1#36pin@103_polysilicon-1##1 S1#36pin@103_polysilicon-1##2 9.896
R234 S1#36pin@103_polysilicon-1##2 S1#36pin@103_polysilicon-1##3 9.896
R235 S1#36pin@103_polysilicon-1##3 S1#36pin@103_polysilicon-1##4 9.896
R236 S1#36pin@103_polysilicon-1##4 S1#36pin@103_polysilicon-1##5 9.896
R237 S1#36pin@103_polysilicon-1##5 S1#36pin@103_polysilicon-1##6 9.896
R238 S1#36pin@103_polysilicon-1##6 S1#36pin@103_polysilicon-1##7 9.896
R239 S1#36pin@103_polysilicon-1##7 S1#36pin@103_polysilicon-1##8 9.896
R240 S1#36pin@103_polysilicon-1##8 S1#36pin@103_polysilicon-1##9 9.896
R241 S1#36pin@103_polysilicon-1##9 S1#36pin@103_polysilicon-1##10 9.896
R242 S1#36pin@103_polysilicon-1##10 S1#36pin@103_polysilicon-1##11 9.896
R243 S1#36pin@103_polysilicon-1##11 S1#37pin@104_polysilicon-1 9.896
R244 S1#37pin@104_polysilicon-1 S1#37pin@104_polysilicon-1##0 9.521
R245 S1#37pin@104_polysilicon-1##0 S1#37pin@104_polysilicon-1##1 9.521
R246 S1#37pin@104_polysilicon-1##1 S1#37pin@104_polysilicon-1##2 9.521
R247 S1#37pin@104_polysilicon-1##2 S1#37pin@104_polysilicon-1##3 9.521
R248 S1#37pin@104_polysilicon-1##3 S1#37pin@104_polysilicon-1##4 9.521
R249 S1#37pin@104_polysilicon-1##4 S1#37pin@104_polysilicon-1##5 9.521
R250 S1#37pin@104_polysilicon-1##5 S1 9.521
R251 S1#34pin@100_polysilicon-1 S1#34pin@100_polysilicon-1##0 5.425
R252 S1#34pin@100_polysilicon-1##0 S1#39pmos@13_poly-right 5.425
R253 net@105#4pin@92_polysilicon-1 net@105#4pin@92_polysilicon-1##0 9.042
R254 net@105#4pin@92_polysilicon-1##0 net@105#4pin@92_polysilicon-1##1 9.042
R255 net@105#4pin@92_polysilicon-1##1 net@105#4pin@92_polysilicon-1##2 9.042
R256 net@105#4pin@92_polysilicon-1##2 net@105#4pin@92_polysilicon-1##3 9.042
R257 net@105#4pin@92_polysilicon-1##3 net@105#4pin@92_polysilicon-1##4 9.042
R258 net@105#4pin@92_polysilicon-1##4 net@105 9.042
R259 net@106#3pin@113_polysilicon-1 net@106#3pin@113_polysilicon-1##0 8.37
R260 net@106#3pin@113_polysilicon-1##0 net@106#3pin@113_polysilicon-1##1 8.37
R261 net@106#3pin@113_polysilicon-1##1 net@106#3pin@113_polysilicon-1##2 8.37
R262 net@106#3pin@113_polysilicon-1##2 net@106#3pin@113_polysilicon-1##3 8.37
R263 net@106#3pin@113_polysilicon-1##3 net@106#6pin@115_polysilicon-1 8.37
R264 S2 S2##0 9.881
R265 S2##0 S2##1 9.881
R266 S2##1 S2##2 9.881
R267 S2##2 S2##3 9.881
R268 S2##3 S2##4 9.881
R269 S2##4 S2##5 9.881
R270 S2##5 S2##6 9.881
R271 S2##6 S2#4pin@132_polysilicon-1 9.881
R272 net@210#2pin@137_polysilicon-1 net@210#2pin@137_polysilicon-1##0 9.042
R273 net@210#2pin@137_polysilicon-1##0 net@210#2pin@137_polysilicon-1##1 9.042
R274 net@210#2pin@137_polysilicon-1##1 net@210#2pin@137_polysilicon-1##2 9.042
R275 net@210#2pin@137_polysilicon-1##2 net@210#2pin@137_polysilicon-1##3 9.042
R276 net@210#2pin@137_polysilicon-1##3 net@210#2pin@137_polysilicon-1##4 9.042
R277 net@210#2pin@137_polysilicon-1##4 net@210 9.042
R278 S2#5nmos@16_poly-right S2#5nmos@16_poly-right##0 7.233
R279 S2#5nmos@16_poly-right##0 S2#5nmos@16_poly-right##1 7.233
R280 S2#5nmos@16_poly-right##1 S2#6pin@123_polysilicon-1 7.233
R281 S2#7nmos@7_poly-right S2#7nmos@7_poly-right##0 7.233
R282 S2#7nmos@7_poly-right##0 S2#7nmos@7_poly-right##1 7.233
R283 S2#7nmos@7_poly-right##1 S2#8pin@48_polysilicon-1 7.233
R284 S2#9pmos@15_poly-left S2#9pmos@15_poly-left##0 6.2
R285 S2#9pmos@15_poly-left##0 S2#10pin@126_polysilicon-1 6.2
R286 S2#10pin@126_polysilicon-1 S2#10pin@126_polysilicon-1##0 9.896
R287 S2#10pin@126_polysilicon-1##0 S2#10pin@126_polysilicon-1##1 9.896
R288 S2#10pin@126_polysilicon-1##1 S2#10pin@126_polysilicon-1##2 9.896
R289 S2#10pin@126_polysilicon-1##2 S2#10pin@126_polysilicon-1##3 9.896
R290 S2#10pin@126_polysilicon-1##3 S2#10pin@126_polysilicon-1##4 9.896
R291 S2#10pin@126_polysilicon-1##4 S2#10pin@126_polysilicon-1##5 9.896
R292 S2#10pin@126_polysilicon-1##5 S2#10pin@126_polysilicon-1##6 9.896
R293 S2#10pin@126_polysilicon-1##6 S2#10pin@126_polysilicon-1##7 9.896
R294 S2#10pin@126_polysilicon-1##7 S2#10pin@126_polysilicon-1##8 9.896
R295 S2#10pin@126_polysilicon-1##8 S2#10pin@126_polysilicon-1##9 9.896
R296 S2#10pin@126_polysilicon-1##9 S2#10pin@126_polysilicon-1##10 9.896
R297 S2#10pin@126_polysilicon-1##10 S2#10pin@126_polysilicon-1##11 9.896
R298 S2#10pin@126_polysilicon-1##11 S2#11pin@127_polysilicon-1 9.896
R299 S2#11pin@127_polysilicon-1 S2#11pin@127_polysilicon-1##0 9.521
R300 S2#11pin@127_polysilicon-1##0 S2#11pin@127_polysilicon-1##1 9.521
R301 S2#11pin@127_polysilicon-1##1 S2#11pin@127_polysilicon-1##2 9.521
R302 S2#11pin@127_polysilicon-1##2 S2#11pin@127_polysilicon-1##3 9.521
R303 S2#11pin@127_polysilicon-1##3 S2#11pin@127_polysilicon-1##4 9.521
R304 S2#11pin@127_polysilicon-1##4 S2#11pin@127_polysilicon-1##5 9.521
R305 S2#11pin@127_polysilicon-1##5 S2 9.521
R306 S2#6pin@123_polysilicon-1 S2#6pin@123_polysilicon-1##0 5.425
R307 S2#6pin@123_polysilicon-1##0 S2#13pmos@16_poly-right 5.425
R308 net@106#11nmos@12_poly-right net@106#11nmos@12_poly-right##0 6.2
R309 net@106#11nmos@12_poly-right##0 net@106#6pin@115_polysilicon-1 6.2
R310 net@210#6pin@135_polysilicon-1 net@210#6pin@135_polysilicon-1##0 8.37
R311 net@210#6pin@135_polysilicon-1##0 net@210#6pin@135_polysilicon-1##1 8.37
R312 net@210#6pin@135_polysilicon-1##1 net@210#6pin@135_polysilicon-1##2 8.37
R313 net@210#6pin@135_polysilicon-1##2 net@210#6pin@135_polysilicon-1##3 8.37
R314 net@210#6pin@135_polysilicon-1##3 net@210#2pin@137_polysilicon-1 8.37
R315 S2#15pmos@6_poly-left S2#15pmos@6_poly-left##0 6.2
R316 S2#15pmos@6_poly-left##0 S2#16pin@51_polysilicon-1 6.2
R317 S1#40nmos@10_poly-right S1#40nmos@10_poly-right##0 7.233
R318 S1#40nmos@10_poly-right##0 S1#40nmos@10_poly-right##1 7.233
R319 S1#40nmos@10_poly-right##1 S1#29pin@77_polysilicon-1 7.233
R320 net@210#8nmos@15_poly-right net@210#8nmos@15_poly-right##0 6.2
R321 net@210#8nmos@15_poly-right##0 net@210#2pin@137_polysilicon-1 6.2
R322 S1#41pmos@9_poly-left S1#41pmos@9_poly-left##0 6.2
R323 S1#41pmos@9_poly-left##0 S1#42pin@80_polysilicon-1 6.2
R324 S2#17nmos@17_poly-left S2#17nmos@17_poly-left##0 6.975
R325 S2#17nmos@17_poly-left##0 S2#18pin@131_polysilicon-1 6.975
R326 S2#18pin@131_polysilicon-1 S2#18pin@131_polysilicon-1##0 9.772
R327 S2#18pin@131_polysilicon-1##0 S2#18pin@131_polysilicon-1##1 9.772
R328 S2#18pin@131_polysilicon-1##1 S2#18pin@131_polysilicon-1##2 9.772
R329 S2#18pin@131_polysilicon-1##2 S2#18pin@131_polysilicon-1##3 9.772
R330 S2#18pin@131_polysilicon-1##3 S2#18pin@131_polysilicon-1##4 9.772
R331 S2#18pin@131_polysilicon-1##4 S2#18pin@131_polysilicon-1##5 9.772
R332 S2#18pin@131_polysilicon-1##5 S2#18pin@131_polysilicon-1##6 9.772
R333 S2#18pin@131_polysilicon-1##6 S2#18pin@131_polysilicon-1##7 9.772
R334 S2#18pin@131_polysilicon-1##7 S2#18pin@131_polysilicon-1##8 9.772
R335 S2#18pin@131_polysilicon-1##8 S2#18pin@131_polysilicon-1##9 9.772
R336 S2#18pin@131_polysilicon-1##9 S2#18pin@131_polysilicon-1##10 9.772
R337 S2#18pin@131_polysilicon-1##10 S2#18pin@131_polysilicon-1##11 9.772
R338 S2#18pin@131_polysilicon-1##11 S2#18pin@131_polysilicon-1##12 9.772
R339 S2#18pin@131_polysilicon-1##12 S2#18pin@131_polysilicon-1##13 9.772
R340 S2#18pin@131_polysilicon-1##13 S2#18pin@131_polysilicon-1##14 9.772
R341 S2#18pin@131_polysilicon-1##14 S2#18pin@131_polysilicon-1##15 9.772
R342 S2#18pin@131_polysilicon-1##15 S2#18pin@131_polysilicon-1##16 9.772
R343 S2#18pin@131_polysilicon-1##16 S2#18pin@131_polysilicon-1##17 9.772
R344 S2#18pin@131_polysilicon-1##17 S2#18pin@131_polysilicon-1##18 9.772
R345 S2#18pin@131_polysilicon-1##18 S2#18pin@131_polysilicon-1##19 9.772
R346 S2#18pin@131_polysilicon-1##19 S2#18pin@131_polysilicon-1##20 9.772
R347 S2#18pin@131_polysilicon-1##20 S2#18pin@131_polysilicon-1##21 9.772
R348 S2#18pin@131_polysilicon-1##21 S2#4pin@132_polysilicon-1 9.772
R349 S2 S2##0 8.267
R350 S2##0 S2##1 8.267
R351 S2##1 S2#6pin@123_polysilicon-1 8.267
R352 net@210#9pmos@17_poly-left net@210#10pin@133_polysilicon-1 7.75
R353 S1#43nmos@14_poly-left S1#43nmos@14_poly-left##0 6.975
R354 S1#43nmos@14_poly-left##0 S1#44pin@109_polysilicon-1 6.975
R355 S2#16pin@51_polysilicon-1 S2#16pin@51_polysilicon-1##0 9.896
R356 S2#16pin@51_polysilicon-1##0 S2#16pin@51_polysilicon-1##1 9.896
R357 S2#16pin@51_polysilicon-1##1 S2#16pin@51_polysilicon-1##2 9.896
R358 S2#16pin@51_polysilicon-1##2 S2#16pin@51_polysilicon-1##3 9.896
R359 S2#16pin@51_polysilicon-1##3 S2#16pin@51_polysilicon-1##4 9.896
R360 S2#16pin@51_polysilicon-1##4 S2#16pin@51_polysilicon-1##5 9.896
R361 S2#16pin@51_polysilicon-1##5 S2#16pin@51_polysilicon-1##6 9.896
R362 S2#16pin@51_polysilicon-1##6 S2#16pin@51_polysilicon-1##7 9.896
R363 S2#16pin@51_polysilicon-1##7 S2#16pin@51_polysilicon-1##8 9.896
R364 S2#16pin@51_polysilicon-1##8 S2#16pin@51_polysilicon-1##9 9.896
R365 S2#16pin@51_polysilicon-1##9 S2#16pin@51_polysilicon-1##10 9.896
R366 S2#16pin@51_polysilicon-1##10 S2#16pin@51_polysilicon-1##11 9.896
R367 S2#16pin@51_polysilicon-1##11 S2#19pin@52_polysilicon-1 9.896
R368 net@210#10pin@133_polysilicon-1 net@210#10pin@133_polysilicon-1##0 9.042
R369 net@210#10pin@133_polysilicon-1##0 net@210#10pin@133_polysilicon-1##1 9.042
R370 net@210#10pin@133_polysilicon-1##1 net@210#10pin@133_polysilicon-1##2 9.042
R371 net@210#10pin@133_polysilicon-1##2 net@210#10pin@133_polysilicon-1##3 9.042
R372 net@210#10pin@133_polysilicon-1##3 net@210#10pin@133_polysilicon-1##4 9.042
R373 net@210#10pin@133_polysilicon-1##4 net@210#11pin@134_polysilicon-1 9.042
R374 net@210#11pin@134_polysilicon-1 net@210#11pin@134_polysilicon-1##0 9.3
R375 net@210#11pin@134_polysilicon-1##0 net@210#11pin@134_polysilicon-1##1 9.3
R376 net@210#11pin@134_polysilicon-1##1 net@210#11pin@134_polysilicon-1##2 9.3
R377 net@210#11pin@134_polysilicon-1##2 net@210#11pin@134_polysilicon-1##3 9.3
R378 net@210#11pin@134_polysilicon-1##3 net@210#11pin@134_polysilicon-1##4 9.3
R379 net@210#11pin@134_polysilicon-1##4 net@210#11pin@134_polysilicon-1##5 9.3
R380 net@210#11pin@134_polysilicon-1##5 net@210#11pin@134_polysilicon-1##6 9.3
R381 net@210#11pin@134_polysilicon-1##6 net@210#6pin@135_polysilicon-1 9.3
R382 S1#42pin@80_polysilicon-1 S1#42pin@80_polysilicon-1##0 9.896
R383 S1#42pin@80_polysilicon-1##0 S1#42pin@80_polysilicon-1##1 9.896
R384 S1#42pin@80_polysilicon-1##1 S1#42pin@80_polysilicon-1##2 9.896
R385 S1#42pin@80_polysilicon-1##2 S1#42pin@80_polysilicon-1##3 9.896
R386 S1#42pin@80_polysilicon-1##3 S1#42pin@80_polysilicon-1##4 9.896
R387 S1#42pin@80_polysilicon-1##4 S1#42pin@80_polysilicon-1##5 9.896
R388 S1#42pin@80_polysilicon-1##5 S1#42pin@80_polysilicon-1##6 9.896
R389 S1#42pin@80_polysilicon-1##6 S1#42pin@80_polysilicon-1##7 9.896
R390 S1#42pin@80_polysilicon-1##7 S1#42pin@80_polysilicon-1##8 9.896
R391 S1#42pin@80_polysilicon-1##8 S1#42pin@80_polysilicon-1##9 9.896
R392 S1#42pin@80_polysilicon-1##9 S1#42pin@80_polysilicon-1##10 9.896
R393 S1#42pin@80_polysilicon-1##10 S1#42pin@80_polysilicon-1##11 9.896
R394 S1#42pin@80_polysilicon-1##11 S1#45pin@81_polysilicon-1 9.896
R395 S1#45pin@81_polysilicon-1 S1#45pin@81_polysilicon-1##0 9.521
R396 S1#45pin@81_polysilicon-1##0 S1#45pin@81_polysilicon-1##1 9.521
R397 S1#45pin@81_polysilicon-1##1 S1#45pin@81_polysilicon-1##2 9.521
R398 S1#45pin@81_polysilicon-1##2 S1#45pin@81_polysilicon-1##3 9.521
R399 S1#45pin@81_polysilicon-1##3 S1#45pin@81_polysilicon-1##4 9.521
R400 S1#45pin@81_polysilicon-1##4 S1#45pin@81_polysilicon-1##5 9.521
R401 S1#45pin@81_polysilicon-1##5 S1 9.521
R402 S2#19pin@52_polysilicon-1 S2#19pin@52_polysilicon-1##0 9.521
R403 S2#19pin@52_polysilicon-1##0 S2#19pin@52_polysilicon-1##1 9.521
R404 S2#19pin@52_polysilicon-1##1 S2#19pin@52_polysilicon-1##2 9.521
R405 S2#19pin@52_polysilicon-1##2 S2#19pin@52_polysilicon-1##3 9.521
R406 S2#19pin@52_polysilicon-1##3 S2#19pin@52_polysilicon-1##4 9.521
R407 S2#19pin@52_polysilicon-1##4 S2#19pin@52_polysilicon-1##5 9.521
R408 S2#19pin@52_polysilicon-1##5 S2 9.521
R409 S1#44pin@109_polysilicon-1 S1#44pin@109_polysilicon-1##0 9.772
R410 S1#44pin@109_polysilicon-1##0 S1#44pin@109_polysilicon-1##1 9.772
R411 S1#44pin@109_polysilicon-1##1 S1#44pin@109_polysilicon-1##2 9.772
R412 S1#44pin@109_polysilicon-1##2 S1#44pin@109_polysilicon-1##3 9.772
R413 S1#44pin@109_polysilicon-1##3 S1#44pin@109_polysilicon-1##4 9.772
R414 S1#44pin@109_polysilicon-1##4 S1#44pin@109_polysilicon-1##5 9.772
R415 S1#44pin@109_polysilicon-1##5 S1#44pin@109_polysilicon-1##6 9.772
R416 S1#44pin@109_polysilicon-1##6 S1#44pin@109_polysilicon-1##7 9.772
R417 S1#44pin@109_polysilicon-1##7 S1#44pin@109_polysilicon-1##8 9.772
R418 S1#44pin@109_polysilicon-1##8 S1#44pin@109_polysilicon-1##9 9.772
R419 S1#44pin@109_polysilicon-1##9 S1#44pin@109_polysilicon-1##10 9.772
R420 S1#44pin@109_polysilicon-1##10 S1#44pin@109_polysilicon-1##11 9.772
R421 S1#44pin@109_polysilicon-1##11 S1#44pin@109_polysilicon-1##12 9.772
R422 S1#44pin@109_polysilicon-1##12 S1#44pin@109_polysilicon-1##13 9.772
R423 S1#44pin@109_polysilicon-1##13 S1#44pin@109_polysilicon-1##14 9.772
R424 S1#44pin@109_polysilicon-1##14 S1#44pin@109_polysilicon-1##15 9.772
R425 S1#44pin@109_polysilicon-1##15 S1#44pin@109_polysilicon-1##16 9.772
R426 S1#44pin@109_polysilicon-1##16 S1#44pin@109_polysilicon-1##17 9.772
R427 S1#44pin@109_polysilicon-1##17 S1#44pin@109_polysilicon-1##18 9.772
R428 S1#44pin@109_polysilicon-1##18 S1#44pin@109_polysilicon-1##19 9.772
R429 S1#44pin@109_polysilicon-1##19 S1#44pin@109_polysilicon-1##20 9.772
R430 S1#44pin@109_polysilicon-1##20 S1#44pin@109_polysilicon-1##21 9.772
R431 S1#44pin@109_polysilicon-1##21 S1#31pin@110_polysilicon-1 9.772
R432 S1#29pin@77_polysilicon-1 S1#29pin@77_polysilicon-1##0 5.425
R433 S1#29pin@77_polysilicon-1##0 S1#46pmos@10_poly-right 5.425
R434 S1 S1##0 8.267
R435 S1##0 S1##1 8.267
R436 S1##1 S1#34pin@100_polysilicon-1 8.267
R437 S2#8pin@48_polysilicon-1 S2#8pin@48_polysilicon-1##0 5.425
R438 S2#8pin@48_polysilicon-1##0 S2#21pmos@7_poly-right 5.425
R439 net@350#4pin@174_polysilicon-1 net@350#4pin@174_polysilicon-1##0 8.37
R440 net@350#4pin@174_polysilicon-1##0 net@350#4pin@174_polysilicon-1##1 8.37
R441 net@350#4pin@174_polysilicon-1##1 net@350#4pin@174_polysilicon-1##2 8.37
R442 net@350#4pin@174_polysilicon-1##2 net@350#4pin@174_polysilicon-1##3 8.37
R443 net@350#4pin@174_polysilicon-1##3 net@350#5pin@176_polysilicon-1 8.37
R444 net@350#6nmos@18_poly-right net@350#6nmos@18_poly-right##0 6.2
R445 net@350#6nmos@18_poly-right##0 net@350#5pin@176_polysilicon-1 6.2
R446 S0 S0##0 9.881
R447 S0##0 S0##1 9.881
R448 S0##1 S0##2 9.881
R449 S0##2 S0##3 9.881
R450 S0##3 S0##4 9.881
R451 S0##4 S0##5 9.881
R452 S0##5 S0##6 9.881
R453 S0##6 S0#1pin@171_polysilicon-1 9.881
R454 net@350#5pin@176_polysilicon-1 net@350#5pin@176_polysilicon-1##0 9.042
R455 net@350#5pin@176_polysilicon-1##0 net@350#5pin@176_polysilicon-1##1 9.042
R456 net@350#5pin@176_polysilicon-1##1 net@350#5pin@176_polysilicon-1##2 9.042
R457 net@350#5pin@176_polysilicon-1##2 net@350#5pin@176_polysilicon-1##3 9.042
R458 net@350#5pin@176_polysilicon-1##3 net@350#5pin@176_polysilicon-1##4 9.042
R459 net@350#5pin@176_polysilicon-1##4 net@350 9.042
R460 S0#2nmos@19_poly-right S0#2nmos@19_poly-right##0 7.233
R461 S0#2nmos@19_poly-right##0 S0#2nmos@19_poly-right##1 7.233
R462 S0#2nmos@19_poly-right##1 S0#3pin@161_polysilicon-1 7.233
R463 S0#4pmos@18_poly-left S0#4pmos@18_poly-left##0 6.2
R464 S0#4pmos@18_poly-left##0 S0#5pin@164_polysilicon-1 6.2
R465 S0#5pin@164_polysilicon-1 S0#5pin@164_polysilicon-1##0 9.896
R466 S0#5pin@164_polysilicon-1##0 S0#5pin@164_polysilicon-1##1 9.896
R467 S0#5pin@164_polysilicon-1##1 S0#5pin@164_polysilicon-1##2 9.896
R468 S0#5pin@164_polysilicon-1##2 S0#5pin@164_polysilicon-1##3 9.896
R469 S0#5pin@164_polysilicon-1##3 S0#5pin@164_polysilicon-1##4 9.896
R470 S0#5pin@164_polysilicon-1##4 S0#5pin@164_polysilicon-1##5 9.896
R471 S0#5pin@164_polysilicon-1##5 S0#5pin@164_polysilicon-1##6 9.896
R472 S0#5pin@164_polysilicon-1##6 S0#5pin@164_polysilicon-1##7 9.896
R473 S0#5pin@164_polysilicon-1##7 S0#5pin@164_polysilicon-1##8 9.896
R474 S0#5pin@164_polysilicon-1##8 S0#5pin@164_polysilicon-1##9 9.896
R475 S0#5pin@164_polysilicon-1##9 S0#5pin@164_polysilicon-1##10 9.896
R476 S0#5pin@164_polysilicon-1##10 S0#5pin@164_polysilicon-1##11 9.896
R477 S0#5pin@164_polysilicon-1##11 S0#6pin@165_polysilicon-1 9.896
R478 S0#6pin@165_polysilicon-1 S0#6pin@165_polysilicon-1##0 9.521
R479 S0#6pin@165_polysilicon-1##0 S0#6pin@165_polysilicon-1##1 9.521
R480 S0#6pin@165_polysilicon-1##1 S0#6pin@165_polysilicon-1##2 9.521
R481 S0#6pin@165_polysilicon-1##2 S0#6pin@165_polysilicon-1##3 9.521
R482 S0#6pin@165_polysilicon-1##3 S0#6pin@165_polysilicon-1##4 9.521
R483 S0#6pin@165_polysilicon-1##4 S0#6pin@165_polysilicon-1##5 9.521
R484 S0#6pin@165_polysilicon-1##5 S0 9.521
R485 S0#3pin@161_polysilicon-1 S0#3pin@161_polysilicon-1##0 5.425
R486 S0#3pin@161_polysilicon-1##0 S0#8pmos@19_poly-right 5.425
R487 S0#10nmos@20_poly-left S0#10nmos@20_poly-left##0 6.975
R488 S0#10nmos@20_poly-left##0 S0#11pin@170_polysilicon-1 6.975
R489 S0#11pin@170_polysilicon-1 S0#11pin@170_polysilicon-1##0 9.772
R490 S0#11pin@170_polysilicon-1##0 S0#11pin@170_polysilicon-1##1 9.772
R491 S0#11pin@170_polysilicon-1##1 S0#11pin@170_polysilicon-1##2 9.772
R492 S0#11pin@170_polysilicon-1##2 S0#11pin@170_polysilicon-1##3 9.772
R493 S0#11pin@170_polysilicon-1##3 S0#11pin@170_polysilicon-1##4 9.772
R494 S0#11pin@170_polysilicon-1##4 S0#11pin@170_polysilicon-1##5 9.772
R495 S0#11pin@170_polysilicon-1##5 S0#11pin@170_polysilicon-1##6 9.772
R496 S0#11pin@170_polysilicon-1##6 S0#11pin@170_polysilicon-1##7 9.772
R497 S0#11pin@170_polysilicon-1##7 S0#11pin@170_polysilicon-1##8 9.772
R498 S0#11pin@170_polysilicon-1##8 S0#11pin@170_polysilicon-1##9 9.772
R499 S0#11pin@170_polysilicon-1##9 S0#11pin@170_polysilicon-1##10 9.772
R500 S0#11pin@170_polysilicon-1##10 S0#11pin@170_polysilicon-1##11 9.772
R501 S0#11pin@170_polysilicon-1##11 S0#11pin@170_polysilicon-1##12 9.772
R502 S0#11pin@170_polysilicon-1##12 S0#11pin@170_polysilicon-1##13 9.772
R503 S0#11pin@170_polysilicon-1##13 S0#11pin@170_polysilicon-1##14 9.772
R504 S0#11pin@170_polysilicon-1##14 S0#11pin@170_polysilicon-1##15 9.772
R505 S0#11pin@170_polysilicon-1##15 S0#11pin@170_polysilicon-1##16 9.772
R506 S0#11pin@170_polysilicon-1##16 S0#11pin@170_polysilicon-1##17 9.772
R507 S0#11pin@170_polysilicon-1##17 S0#11pin@170_polysilicon-1##18 9.772
R508 S0#11pin@170_polysilicon-1##18 S0#11pin@170_polysilicon-1##19 9.772
R509 S0#11pin@170_polysilicon-1##19 S0#11pin@170_polysilicon-1##20 9.772
R510 S0#11pin@170_polysilicon-1##20 S0#11pin@170_polysilicon-1##21 9.772
R511 S0#11pin@170_polysilicon-1##21 S0#1pin@171_polysilicon-1 9.772
R512 S0 S0##0 8.267
R513 S0##0 S0##1 8.267
R514 S0##1 S0#3pin@161_polysilicon-1 8.267
R515 net@350#9pmos@20_poly-left net@350#10pin@172_polysilicon-1 7.75
R516 net@350#10pin@172_polysilicon-1 net@350#10pin@172_polysilicon-1##0 9.042
R517 net@350#10pin@172_polysilicon-1##0 net@350#10pin@172_polysilicon-1##1 9.042
R518 net@350#10pin@172_polysilicon-1##1 net@350#10pin@172_polysilicon-1##2 9.042
R519 net@350#10pin@172_polysilicon-1##2 net@350#10pin@172_polysilicon-1##3 9.042
R520 net@350#10pin@172_polysilicon-1##3 net@350#10pin@172_polysilicon-1##4 9.042
R521 net@350#10pin@172_polysilicon-1##4 net@350#11pin@173_polysilicon-1 9.042
R522 net@350#11pin@173_polysilicon-1 net@350#11pin@173_polysilicon-1##0 9.3
R523 net@350#11pin@173_polysilicon-1##0 net@350#11pin@173_polysilicon-1##1 9.3
R524 net@350#11pin@173_polysilicon-1##1 net@350#11pin@173_polysilicon-1##2 9.3
R525 net@350#11pin@173_polysilicon-1##2 net@350#11pin@173_polysilicon-1##3 9.3
R526 net@350#11pin@173_polysilicon-1##3 net@350#11pin@173_polysilicon-1##4 9.3
R527 net@350#11pin@173_polysilicon-1##4 net@350#11pin@173_polysilicon-1##5 9.3
R528 net@350#11pin@173_polysilicon-1##5 net@350#11pin@173_polysilicon-1##6 9.3
R529 net@350#11pin@173_polysilicon-1##6 net@350#4pin@174_polysilicon-1 9.3
R530 net@2#11nmos@3_poly-right net@2#11nmos@3_poly-right##0 6.2
R531 net@2#11nmos@3_poly-right##0 net@2#6pin@40_polysilicon-1 6.2
R532 net@97#6pin@60_polysilicon-1 net@97#6pin@60_polysilicon-1##0 8.37
R533 net@97#6pin@60_polysilicon-1##0 net@97#6pin@60_polysilicon-1##1 8.37
R534 net@97#6pin@60_polysilicon-1##1 net@97#6pin@60_polysilicon-1##2 8.37
R535 net@97#6pin@60_polysilicon-1##2 net@97#6pin@60_polysilicon-1##3 8.37
R536 net@97#6pin@60_polysilicon-1##3 net@97#2pin@62_polysilicon-1 8.37
R537 S1#48nmos@1_poly-right S1#48nmos@1_poly-right##0 7.233
R538 S1#48nmos@1_poly-right##0 S1#48nmos@1_poly-right##1 7.233
R539 S1#48nmos@1_poly-right##1 S1#9pin@2_polysilicon-1 7.233
R540 net@97#8nmos@6_poly-right net@97#8nmos@6_poly-right##0 6.2
R541 net@97#8nmos@6_poly-right##0 net@97#2pin@62_polysilicon-1 6.2
R542 S1#49pmos@0_poly-left S1#49pmos@0_poly-left##0 6.2
R543 S1#49pmos@0_poly-left##0 S1#50pin@5_polysilicon-1 6.2
R544 S2#25nmos@8_poly-left S2#25nmos@8_poly-left##0 6.975
R545 S2#25nmos@8_poly-left##0 S2#26pin@56_polysilicon-1 6.975
R546 S2#26pin@56_polysilicon-1 S2#26pin@56_polysilicon-1##0 9.772
R547 S2#26pin@56_polysilicon-1##0 S2#26pin@56_polysilicon-1##1 9.772
R548 S2#26pin@56_polysilicon-1##1 S2#26pin@56_polysilicon-1##2 9.772
R549 S2#26pin@56_polysilicon-1##2 S2#26pin@56_polysilicon-1##3 9.772
R550 S2#26pin@56_polysilicon-1##3 S2#26pin@56_polysilicon-1##4 9.772
R551 S2#26pin@56_polysilicon-1##4 S2#26pin@56_polysilicon-1##5 9.772
R552 S2#26pin@56_polysilicon-1##5 S2#26pin@56_polysilicon-1##6 9.772
R553 S2#26pin@56_polysilicon-1##6 S2#26pin@56_polysilicon-1##7 9.772
R554 S2#26pin@56_polysilicon-1##7 S2#26pin@56_polysilicon-1##8 9.772
R555 S2#26pin@56_polysilicon-1##8 S2#26pin@56_polysilicon-1##9 9.772
R556 S2#26pin@56_polysilicon-1##9 S2#26pin@56_polysilicon-1##10 9.772
R557 S2#26pin@56_polysilicon-1##10 S2#26pin@56_polysilicon-1##11 9.772
R558 S2#26pin@56_polysilicon-1##11 S2#26pin@56_polysilicon-1##12 9.772
R559 S2#26pin@56_polysilicon-1##12 S2#26pin@56_polysilicon-1##13 9.772
R560 S2#26pin@56_polysilicon-1##13 S2#26pin@56_polysilicon-1##14 9.772
R561 S2#26pin@56_polysilicon-1##14 S2#26pin@56_polysilicon-1##15 9.772
R562 S2#26pin@56_polysilicon-1##15 S2#26pin@56_polysilicon-1##16 9.772
R563 S2#26pin@56_polysilicon-1##16 S2#26pin@56_polysilicon-1##17 9.772
R564 S2#26pin@56_polysilicon-1##17 S2#26pin@56_polysilicon-1##18 9.772
R565 S2#26pin@56_polysilicon-1##18 S2#26pin@56_polysilicon-1##19 9.772
R566 S2#26pin@56_polysilicon-1##19 S2#26pin@56_polysilicon-1##20 9.772
R567 S2#26pin@56_polysilicon-1##20 S2#26pin@56_polysilicon-1##21 9.772
R568 S2#26pin@56_polysilicon-1##21 S2#2pin@57_polysilicon-1 9.772
R569 S2 S2##0 8.267
R570 S2##0 S2##1 8.267
R571 S2##1 S2#8pin@48_polysilicon-1 8.267
R572 net@97#9pmos@8_poly-left net@97#10pin@58_polysilicon-1 7.75
R573 S1#51nmos@5_poly-left S1#51nmos@5_poly-left##0 6.975
R574 S1#51nmos@5_poly-left##0 S1#52pin@34_polysilicon-1 6.975
R575 net@97#10pin@58_polysilicon-1 net@97#10pin@58_polysilicon-1##0 9.042
R576 net@97#10pin@58_polysilicon-1##0 net@97#10pin@58_polysilicon-1##1 9.042
R577 net@97#10pin@58_polysilicon-1##1 net@97#10pin@58_polysilicon-1##2 9.042
R578 net@97#10pin@58_polysilicon-1##2 net@97#10pin@58_polysilicon-1##3 9.042
R579 net@97#10pin@58_polysilicon-1##3 net@97#10pin@58_polysilicon-1##4 9.042
R580 net@97#10pin@58_polysilicon-1##4 net@97#11pin@59_polysilicon-1 9.042
R581 net@97#11pin@59_polysilicon-1 net@97#11pin@59_polysilicon-1##0 9.3
R582 net@97#11pin@59_polysilicon-1##0 net@97#11pin@59_polysilicon-1##1 9.3
R583 net@97#11pin@59_polysilicon-1##1 net@97#11pin@59_polysilicon-1##2 9.3
R584 net@97#11pin@59_polysilicon-1##2 net@97#11pin@59_polysilicon-1##3 9.3
R585 net@97#11pin@59_polysilicon-1##3 net@97#11pin@59_polysilicon-1##4 9.3
R586 net@97#11pin@59_polysilicon-1##4 net@97#11pin@59_polysilicon-1##5 9.3
R587 net@97#11pin@59_polysilicon-1##5 net@97#11pin@59_polysilicon-1##6 9.3
R588 net@97#11pin@59_polysilicon-1##6 net@97#6pin@60_polysilicon-1 9.3
R589 S1#50pin@5_polysilicon-1 S1#50pin@5_polysilicon-1##0 9.896
R590 S1#50pin@5_polysilicon-1##0 S1#50pin@5_polysilicon-1##1 9.896
R591 S1#50pin@5_polysilicon-1##1 S1#50pin@5_polysilicon-1##2 9.896
R592 S1#50pin@5_polysilicon-1##2 S1#50pin@5_polysilicon-1##3 9.896
R593 S1#50pin@5_polysilicon-1##3 S1#50pin@5_polysilicon-1##4 9.896
R594 S1#50pin@5_polysilicon-1##4 S1#50pin@5_polysilicon-1##5 9.896
R595 S1#50pin@5_polysilicon-1##5 S1#50pin@5_polysilicon-1##6 9.896
R596 S1#50pin@5_polysilicon-1##6 S1#50pin@5_polysilicon-1##7 9.896
R597 S1#50pin@5_polysilicon-1##7 S1#50pin@5_polysilicon-1##8 9.896
R598 S1#50pin@5_polysilicon-1##8 S1#50pin@5_polysilicon-1##9 9.896
R599 S1#50pin@5_polysilicon-1##9 S1#50pin@5_polysilicon-1##10 9.896
R600 S1#50pin@5_polysilicon-1##10 S1#50pin@5_polysilicon-1##11 9.896
R601 S1#50pin@5_polysilicon-1##11 S1#53pin@6_polysilicon-1 9.896
R602 S1#53pin@6_polysilicon-1 S1#53pin@6_polysilicon-1##0 9.521
R603 S1#53pin@6_polysilicon-1##0 S1#53pin@6_polysilicon-1##1 9.521
R604 S1#53pin@6_polysilicon-1##1 S1#53pin@6_polysilicon-1##2 9.521
R605 S1#53pin@6_polysilicon-1##2 S1#53pin@6_polysilicon-1##3 9.521
R606 S1#53pin@6_polysilicon-1##3 S1#53pin@6_polysilicon-1##4 9.521
R607 S1#53pin@6_polysilicon-1##4 S1#53pin@6_polysilicon-1##5 9.521
R608 S1#53pin@6_polysilicon-1##5 S1 9.521
R609 S1#52pin@34_polysilicon-1 S1#52pin@34_polysilicon-1##0 9.772
R610 S1#52pin@34_polysilicon-1##0 S1#52pin@34_polysilicon-1##1 9.772
R611 S1#52pin@34_polysilicon-1##1 S1#52pin@34_polysilicon-1##2 9.772
R612 S1#52pin@34_polysilicon-1##2 S1#52pin@34_polysilicon-1##3 9.772
R613 S1#52pin@34_polysilicon-1##3 S1#52pin@34_polysilicon-1##4 9.772
R614 S1#52pin@34_polysilicon-1##4 S1#52pin@34_polysilicon-1##5 9.772
R615 S1#52pin@34_polysilicon-1##5 S1#52pin@34_polysilicon-1##6 9.772
R616 S1#52pin@34_polysilicon-1##6 S1#52pin@34_polysilicon-1##7 9.772
R617 S1#52pin@34_polysilicon-1##7 S1#52pin@34_polysilicon-1##8 9.772
R618 S1#52pin@34_polysilicon-1##8 S1#52pin@34_polysilicon-1##9 9.772
R619 S1#52pin@34_polysilicon-1##9 S1#52pin@34_polysilicon-1##10 9.772
R620 S1#52pin@34_polysilicon-1##10 S1#52pin@34_polysilicon-1##11 9.772
R621 S1#52pin@34_polysilicon-1##11 S1#52pin@34_polysilicon-1##12 9.772
R622 S1#52pin@34_polysilicon-1##12 S1#52pin@34_polysilicon-1##13 9.772
R623 S1#52pin@34_polysilicon-1##13 S1#52pin@34_polysilicon-1##14 9.772
R624 S1#52pin@34_polysilicon-1##14 S1#52pin@34_polysilicon-1##15 9.772
R625 S1#52pin@34_polysilicon-1##15 S1#52pin@34_polysilicon-1##16 9.772
R626 S1#52pin@34_polysilicon-1##16 S1#52pin@34_polysilicon-1##17 9.772
R627 S1#52pin@34_polysilicon-1##17 S1#52pin@34_polysilicon-1##18 9.772
R628 S1#52pin@34_polysilicon-1##18 S1#52pin@34_polysilicon-1##19 9.772
R629 S1#52pin@34_polysilicon-1##19 S1#52pin@34_polysilicon-1##20 9.772
R630 S1#52pin@34_polysilicon-1##20 S1#52pin@34_polysilicon-1##21 9.772
R631 S1#52pin@34_polysilicon-1##21 S1#11pin@35_polysilicon-1 9.772
R632 S1#9pin@2_polysilicon-1 S1#9pin@2_polysilicon-1##0 5.425
R633 S1#9pin@2_polysilicon-1##0 S1#54pmos@1_poly-right 5.425
R634 S1 S1##0 8.267
R635 S1##0 S1##1 8.267
R636 S1##1 S1#14pin@25_polysilicon-1 8.267
R637 net@510#4pin@362_polysilicon-1 net@510#4pin@362_polysilicon-1##0 8.37
R638 net@510#4pin@362_polysilicon-1##0 net@510#4pin@362_polysilicon-1##1 8.37
R639 net@510#4pin@362_polysilicon-1##1 net@510#4pin@362_polysilicon-1##2 8.37
R640 net@510#4pin@362_polysilicon-1##2 net@510#4pin@362_polysilicon-1##3 8.37
R641 net@510#4pin@362_polysilicon-1##3 net@510#5pin@364_polysilicon-1 8.37
R642 net@510#6nmos@39_poly-right net@510#6nmos@39_poly-right##0 6.2
R643 net@510#6nmos@39_poly-right##0 net@510#5pin@364_polysilicon-1 6.2
R644 S0 S0##0 9.881
R645 S0##0 S0##1 9.881
R646 S0##1 S0##2 9.881
R647 S0##2 S0##3 9.881
R648 S0##3 S0##4 9.881
R649 S0##4 S0##5 9.881
R650 S0##5 S0##6 9.881
R651 S0##6 S0#16pin@359_polysilicon-1 9.881
R652 net@510#5pin@364_polysilicon-1 net@510#5pin@364_polysilicon-1##0 9.042
R653 net@510#5pin@364_polysilicon-1##0 net@510#5pin@364_polysilicon-1##1 9.042
R654 net@510#5pin@364_polysilicon-1##1 net@510#5pin@364_polysilicon-1##2 9.042
R655 net@510#5pin@364_polysilicon-1##2 net@510#5pin@364_polysilicon-1##3 9.042
R656 net@510#5pin@364_polysilicon-1##3 net@510#5pin@364_polysilicon-1##4 9.042
R657 net@510#5pin@364_polysilicon-1##4 net@510 9.042
R658 S0#17nmos@40_poly-right S0#17nmos@40_poly-right##0 7.233
R659 S0#17nmos@40_poly-right##0 S0#17nmos@40_poly-right##1 7.233
R660 S0#17nmos@40_poly-right##1 S0#18pin@349_polysilicon-1 7.233
R661 S0#19pmos@39_poly-left S0#19pmos@39_poly-left##0 6.2
R662 S0#19pmos@39_poly-left##0 S0#20pin@352_polysilicon-1 6.2
R663 S0#20pin@352_polysilicon-1 S0#20pin@352_polysilicon-1##0 9.896
R664 S0#20pin@352_polysilicon-1##0 S0#20pin@352_polysilicon-1##1 9.896
R665 S0#20pin@352_polysilicon-1##1 S0#20pin@352_polysilicon-1##2 9.896
R666 S0#20pin@352_polysilicon-1##2 S0#20pin@352_polysilicon-1##3 9.896
R667 S0#20pin@352_polysilicon-1##3 S0#20pin@352_polysilicon-1##4 9.896
R668 S0#20pin@352_polysilicon-1##4 S0#20pin@352_polysilicon-1##5 9.896
R669 S0#20pin@352_polysilicon-1##5 S0#20pin@352_polysilicon-1##6 9.896
R670 S0#20pin@352_polysilicon-1##6 S0#20pin@352_polysilicon-1##7 9.896
R671 S0#20pin@352_polysilicon-1##7 S0#20pin@352_polysilicon-1##8 9.896
R672 S0#20pin@352_polysilicon-1##8 S0#20pin@352_polysilicon-1##9 9.896
R673 S0#20pin@352_polysilicon-1##9 S0#20pin@352_polysilicon-1##10 9.896
R674 S0#20pin@352_polysilicon-1##10 S0#20pin@352_polysilicon-1##11 9.896
R675 S0#20pin@352_polysilicon-1##11 S0#21pin@353_polysilicon-1 9.896
R676 S0#21pin@353_polysilicon-1 S0#21pin@353_polysilicon-1##0 9.521
R677 S0#21pin@353_polysilicon-1##0 S0#21pin@353_polysilicon-1##1 9.521
R678 S0#21pin@353_polysilicon-1##1 S0#21pin@353_polysilicon-1##2 9.521
R679 S0#21pin@353_polysilicon-1##2 S0#21pin@353_polysilicon-1##3 9.521
R680 S0#21pin@353_polysilicon-1##3 S0#21pin@353_polysilicon-1##4 9.521
R681 S0#21pin@353_polysilicon-1##4 S0#21pin@353_polysilicon-1##5 9.521
R682 S0#21pin@353_polysilicon-1##5 S0 9.521
R683 S0#18pin@349_polysilicon-1 S0#18pin@349_polysilicon-1##0 5.425
R684 S0#18pin@349_polysilicon-1##0 S0#23pmos@40_poly-right 5.425
R685 S0#25nmos@41_poly-left S0#25nmos@41_poly-left##0 6.975
R686 S0#25nmos@41_poly-left##0 S0#26pin@358_polysilicon-1 6.975
R687 S0#26pin@358_polysilicon-1 S0#26pin@358_polysilicon-1##0 9.772
R688 S0#26pin@358_polysilicon-1##0 S0#26pin@358_polysilicon-1##1 9.772
R689 S0#26pin@358_polysilicon-1##1 S0#26pin@358_polysilicon-1##2 9.772
R690 S0#26pin@358_polysilicon-1##2 S0#26pin@358_polysilicon-1##3 9.772
R691 S0#26pin@358_polysilicon-1##3 S0#26pin@358_polysilicon-1##4 9.772
R692 S0#26pin@358_polysilicon-1##4 S0#26pin@358_polysilicon-1##5 9.772
R693 S0#26pin@358_polysilicon-1##5 S0#26pin@358_polysilicon-1##6 9.772
R694 S0#26pin@358_polysilicon-1##6 S0#26pin@358_polysilicon-1##7 9.772
R695 S0#26pin@358_polysilicon-1##7 S0#26pin@358_polysilicon-1##8 9.772
R696 S0#26pin@358_polysilicon-1##8 S0#26pin@358_polysilicon-1##9 9.772
R697 S0#26pin@358_polysilicon-1##9 S0#26pin@358_polysilicon-1##10 9.772
R698 S0#26pin@358_polysilicon-1##10 S0#26pin@358_polysilicon-1##11 9.772
R699 S0#26pin@358_polysilicon-1##11 S0#26pin@358_polysilicon-1##12 9.772
R700 S0#26pin@358_polysilicon-1##12 S0#26pin@358_polysilicon-1##13 9.772
R701 S0#26pin@358_polysilicon-1##13 S0#26pin@358_polysilicon-1##14 9.772
R702 S0#26pin@358_polysilicon-1##14 S0#26pin@358_polysilicon-1##15 9.772
R703 S0#26pin@358_polysilicon-1##15 S0#26pin@358_polysilicon-1##16 9.772
R704 S0#26pin@358_polysilicon-1##16 S0#26pin@358_polysilicon-1##17 9.772
R705 S0#26pin@358_polysilicon-1##17 S0#26pin@358_polysilicon-1##18 9.772
R706 S0#26pin@358_polysilicon-1##18 S0#26pin@358_polysilicon-1##19 9.772
R707 S0#26pin@358_polysilicon-1##19 S0#26pin@358_polysilicon-1##20 9.772
R708 S0#26pin@358_polysilicon-1##20 S0#26pin@358_polysilicon-1##21 9.772
R709 S0#26pin@358_polysilicon-1##21 S0#16pin@359_polysilicon-1 9.772
R710 S0 S0##0 8.267
R711 S0##0 S0##1 8.267
R712 S0##1 S0#18pin@349_polysilicon-1 8.267
R713 net@510#9pmos@41_poly-left net@510#10pin@360_polysilicon-1 7.75
R714 net@510#10pin@360_polysilicon-1 net@510#10pin@360_polysilicon-1##0 9.042
R715 net@510#10pin@360_polysilicon-1##0 net@510#10pin@360_polysilicon-1##1 9.042
R716 net@510#10pin@360_polysilicon-1##1 net@510#10pin@360_polysilicon-1##2 9.042
R717 net@510#10pin@360_polysilicon-1##2 net@510#10pin@360_polysilicon-1##3 9.042
R718 net@510#10pin@360_polysilicon-1##3 net@510#10pin@360_polysilicon-1##4 9.042
R719 net@510#10pin@360_polysilicon-1##4 net@510#11pin@361_polysilicon-1 9.042
R720 net@576 net@576##0 6.2
R721 net@576##0 net@576#1pin@205_polysilicon-1 6.2
R722 net@510#11pin@361_polysilicon-1 net@510#11pin@361_polysilicon-1##0 9.3
R723 net@510#11pin@361_polysilicon-1##0 net@510#11pin@361_polysilicon-1##1 9.3
R724 net@510#11pin@361_polysilicon-1##1 net@510#11pin@361_polysilicon-1##2 9.3
R725 net@510#11pin@361_polysilicon-1##2 net@510#11pin@361_polysilicon-1##3 9.3
R726 net@510#11pin@361_polysilicon-1##3 net@510#11pin@361_polysilicon-1##4 9.3
R727 net@510#11pin@361_polysilicon-1##4 net@510#11pin@361_polysilicon-1##5 9.3
R728 net@510#11pin@361_polysilicon-1##5 net@510#11pin@361_polysilicon-1##6 9.3
R729 net@510#11pin@361_polysilicon-1##6 net@510#4pin@362_polysilicon-1 9.3
R730 net@578 net@578##0 6.2
R731 net@578##0 net@578#1pin@228_polysilicon-1 6.2
R732 net@495#2pin@248_polysilicon-1 net@495#2pin@248_polysilicon-1##0 8.37
R733 net@495#2pin@248_polysilicon-1##0 net@495#2pin@248_polysilicon-1##1 8.37
R734 net@495#2pin@248_polysilicon-1##1 net@495#2pin@248_polysilicon-1##2 8.37
R735 net@495#2pin@248_polysilicon-1##2 net@495#2pin@248_polysilicon-1##3 8.37
R736 net@495#2pin@248_polysilicon-1##3 net@495#3pin@250_polysilicon-1 8.37
R737 S1#55nmos@22_poly-right S1#55nmos@22_poly-right##0 7.233
R738 S1#55nmos@22_poly-right##0 S1#55nmos@22_poly-right##1 7.233
R739 S1#55nmos@22_poly-right##1 S1#56pin@190_polysilicon-1 7.233
R740 S1#57nmos@23_poly-left S1#57nmos@23_poly-left##0 6.975
R741 S1#57nmos@23_poly-left##0 S1#58pin@199_polysilicon-1 6.975
R742 S1#58pin@199_polysilicon-1 S1#58pin@199_polysilicon-1##0 9.772
R743 S1#58pin@199_polysilicon-1##0 S1#58pin@199_polysilicon-1##1 9.772
R744 S1#58pin@199_polysilicon-1##1 S1#58pin@199_polysilicon-1##2 9.772
R745 S1#58pin@199_polysilicon-1##2 S1#58pin@199_polysilicon-1##3 9.772
R746 S1#58pin@199_polysilicon-1##3 S1#58pin@199_polysilicon-1##4 9.772
R747 S1#58pin@199_polysilicon-1##4 S1#58pin@199_polysilicon-1##5 9.772
R748 S1#58pin@199_polysilicon-1##5 S1#58pin@199_polysilicon-1##6 9.772
R749 S1#58pin@199_polysilicon-1##6 S1#58pin@199_polysilicon-1##7 9.772
R750 S1#58pin@199_polysilicon-1##7 S1#58pin@199_polysilicon-1##8 9.772
R751 S1#58pin@199_polysilicon-1##8 S1#58pin@199_polysilicon-1##9 9.772
R752 S1#58pin@199_polysilicon-1##9 S1#58pin@199_polysilicon-1##10 9.772
R753 S1#58pin@199_polysilicon-1##10 S1#58pin@199_polysilicon-1##11 9.772
R754 S1#58pin@199_polysilicon-1##11 S1#58pin@199_polysilicon-1##12 9.772
R755 S1#58pin@199_polysilicon-1##12 S1#58pin@199_polysilicon-1##13 9.772
R756 S1#58pin@199_polysilicon-1##13 S1#58pin@199_polysilicon-1##14 9.772
R757 S1#58pin@199_polysilicon-1##14 S1#58pin@199_polysilicon-1##15 9.772
R758 S1#58pin@199_polysilicon-1##15 S1#58pin@199_polysilicon-1##16 9.772
R759 S1#58pin@199_polysilicon-1##16 S1#58pin@199_polysilicon-1##17 9.772
R760 S1#58pin@199_polysilicon-1##17 S1#58pin@199_polysilicon-1##18 9.772
R761 S1#58pin@199_polysilicon-1##18 S1#58pin@199_polysilicon-1##19 9.772
R762 S1#58pin@199_polysilicon-1##19 S1#58pin@199_polysilicon-1##20 9.772
R763 S1#58pin@199_polysilicon-1##20 S1#58pin@199_polysilicon-1##21 9.772
R764 S1#58pin@199_polysilicon-1##21 S1#59pin@200_polysilicon-1 9.772
R765 net@495#6nmos@27_poly-right net@495#6nmos@27_poly-right##0 6.2
R766 net@495#6nmos@27_poly-right##0 net@495#3pin@250_polysilicon-1 6.2
R767 S1#60pmos@21_poly-left S1#60pmos@21_poly-left##0 6.2
R768 S1#60pmos@21_poly-left##0 S1#61pin@193_polysilicon-1 6.2
R769 S2#29nmos@29_poly-left S2#29nmos@29_poly-left##0 6.975
R770 S2#29nmos@29_poly-left##0 S2#30pin@244_polysilicon-1 6.975
R771 S2#30pin@244_polysilicon-1 S2#30pin@244_polysilicon-1##0 9.772
R772 S2#30pin@244_polysilicon-1##0 S2#30pin@244_polysilicon-1##1 9.772
R773 S2#30pin@244_polysilicon-1##1 S2#30pin@244_polysilicon-1##2 9.772
R774 S2#30pin@244_polysilicon-1##2 S2#30pin@244_polysilicon-1##3 9.772
R775 S2#30pin@244_polysilicon-1##3 S2#30pin@244_polysilicon-1##4 9.772
R776 S2#30pin@244_polysilicon-1##4 S2#30pin@244_polysilicon-1##5 9.772
R777 S2#30pin@244_polysilicon-1##5 S2#30pin@244_polysilicon-1##6 9.772
R778 S2#30pin@244_polysilicon-1##6 S2#30pin@244_polysilicon-1##7 9.772
R779 S2#30pin@244_polysilicon-1##7 S2#30pin@244_polysilicon-1##8 9.772
R780 S2#30pin@244_polysilicon-1##8 S2#30pin@244_polysilicon-1##9 9.772
R781 S2#30pin@244_polysilicon-1##9 S2#30pin@244_polysilicon-1##10 9.772
R782 S2#30pin@244_polysilicon-1##10 S2#30pin@244_polysilicon-1##11 9.772
R783 S2#30pin@244_polysilicon-1##11 S2#30pin@244_polysilicon-1##12 9.772
R784 S2#30pin@244_polysilicon-1##12 S2#30pin@244_polysilicon-1##13 9.772
R785 S2#30pin@244_polysilicon-1##13 S2#30pin@244_polysilicon-1##14 9.772
R786 S2#30pin@244_polysilicon-1##14 S2#30pin@244_polysilicon-1##15 9.772
R787 S2#30pin@244_polysilicon-1##15 S2#30pin@244_polysilicon-1##16 9.772
R788 S2#30pin@244_polysilicon-1##16 S2#30pin@244_polysilicon-1##17 9.772
R789 S2#30pin@244_polysilicon-1##17 S2#30pin@244_polysilicon-1##18 9.772
R790 S2#30pin@244_polysilicon-1##18 S2#30pin@244_polysilicon-1##19 9.772
R791 S2#30pin@244_polysilicon-1##19 S2#30pin@244_polysilicon-1##20 9.772
R792 S2#30pin@244_polysilicon-1##20 S2#30pin@244_polysilicon-1##21 9.772
R793 S2#30pin@244_polysilicon-1##21 S2#31pin@245_polysilicon-1 9.772
R794 S2 S2##0 8.267
R795 S2##0 S2##1 8.267
R796 S2##1 S2#32pin@236_polysilicon-1 8.267
R797 net@495#7pmos@29_poly-left net@495#8pin@246_polysilicon-1 7.75
R798 S1#62nmos@26_poly-left S1#62nmos@26_poly-left##0 6.975
R799 S1#62nmos@26_poly-left##0 S1#63pin@222_polysilicon-1 6.975
R800 net@495#8pin@246_polysilicon-1 net@495#8pin@246_polysilicon-1##0 9.042
R801 net@495#8pin@246_polysilicon-1##0 net@495#8pin@246_polysilicon-1##1 9.042
R802 net@495#8pin@246_polysilicon-1##1 net@495#8pin@246_polysilicon-1##2 9.042
R803 net@495#8pin@246_polysilicon-1##2 net@495#8pin@246_polysilicon-1##3 9.042
R804 net@495#8pin@246_polysilicon-1##3 net@495#8pin@246_polysilicon-1##4 9.042
R805 net@495#8pin@246_polysilicon-1##4 net@495#9pin@247_polysilicon-1 9.042
R806 net@495#9pin@247_polysilicon-1 net@495#9pin@247_polysilicon-1##0 9.3
R807 net@495#9pin@247_polysilicon-1##0 net@495#9pin@247_polysilicon-1##1 9.3
R808 net@495#9pin@247_polysilicon-1##1 net@495#9pin@247_polysilicon-1##2 9.3
R809 net@495#9pin@247_polysilicon-1##2 net@495#9pin@247_polysilicon-1##3 9.3
R810 net@495#9pin@247_polysilicon-1##3 net@495#9pin@247_polysilicon-1##4 9.3
R811 net@495#9pin@247_polysilicon-1##4 net@495#9pin@247_polysilicon-1##5 9.3
R812 net@495#9pin@247_polysilicon-1##5 net@495#9pin@247_polysilicon-1##6 9.3
R813 net@495#9pin@247_polysilicon-1##6 net@495#2pin@248_polysilicon-1 9.3
R814 S1#64contact@192_metal-1-polysilicon-1 S1#64contact@192_metal-1-polysilicon-1##0 8.267
R815 S1#64contact@192_metal-1-polysilicon-1##0 S1#64contact@192_metal-1-polysilicon-1##1 8.267
R816 S1#64contact@192_metal-1-polysilicon-1##1 S1#56pin@190_polysilicon-1 8.267
R817 S1#61pin@193_polysilicon-1 S1#61pin@193_polysilicon-1##0 9.896
R818 S1#61pin@193_polysilicon-1##0 S1#61pin@193_polysilicon-1##1 9.896
R819 S1#61pin@193_polysilicon-1##1 S1#61pin@193_polysilicon-1##2 9.896
R820 S1#61pin@193_polysilicon-1##2 S1#61pin@193_polysilicon-1##3 9.896
R821 S1#61pin@193_polysilicon-1##3 S1#61pin@193_polysilicon-1##4 9.896
R822 S1#61pin@193_polysilicon-1##4 S1#61pin@193_polysilicon-1##5 9.896
R823 S1#61pin@193_polysilicon-1##5 S1#61pin@193_polysilicon-1##6 9.896
R824 S1#61pin@193_polysilicon-1##6 S1#61pin@193_polysilicon-1##7 9.896
R825 S1#61pin@193_polysilicon-1##7 S1#61pin@193_polysilicon-1##8 9.896
R826 S1#61pin@193_polysilicon-1##8 S1#61pin@193_polysilicon-1##9 9.896
R827 S1#61pin@193_polysilicon-1##9 S1#61pin@193_polysilicon-1##10 9.896
R828 S1#61pin@193_polysilicon-1##10 S1#61pin@193_polysilicon-1##11 9.896
R829 S1#61pin@193_polysilicon-1##11 S1#65pin@194_polysilicon-1 9.896
R830 S1#65pin@194_polysilicon-1 S1#65pin@194_polysilicon-1##0 9.521
R831 S1#65pin@194_polysilicon-1##0 S1#65pin@194_polysilicon-1##1 9.521
R832 S1#65pin@194_polysilicon-1##1 S1#65pin@194_polysilicon-1##2 9.521
R833 S1#65pin@194_polysilicon-1##2 S1#65pin@194_polysilicon-1##3 9.521
R834 S1#65pin@194_polysilicon-1##3 S1#65pin@194_polysilicon-1##4 9.521
R835 S1#65pin@194_polysilicon-1##4 S1#65pin@194_polysilicon-1##5 9.521
R836 S1#65pin@194_polysilicon-1##5 S1#64contact@192_metal-1-polysilicon-1 9.521
R837 S1#63pin@222_polysilicon-1 S1#63pin@222_polysilicon-1##0 9.772
R838 S1#63pin@222_polysilicon-1##0 S1#63pin@222_polysilicon-1##1 9.772
R839 S1#63pin@222_polysilicon-1##1 S1#63pin@222_polysilicon-1##2 9.772
R840 S1#63pin@222_polysilicon-1##2 S1#63pin@222_polysilicon-1##3 9.772
R841 S1#63pin@222_polysilicon-1##3 S1#63pin@222_polysilicon-1##4 9.772
R842 S1#63pin@222_polysilicon-1##4 S1#63pin@222_polysilicon-1##5 9.772
R843 S1#63pin@222_polysilicon-1##5 S1#63pin@222_polysilicon-1##6 9.772
R844 S1#63pin@222_polysilicon-1##6 S1#63pin@222_polysilicon-1##7 9.772
R845 S1#63pin@222_polysilicon-1##7 S1#63pin@222_polysilicon-1##8 9.772
R846 S1#63pin@222_polysilicon-1##8 S1#63pin@222_polysilicon-1##9 9.772
R847 S1#63pin@222_polysilicon-1##9 S1#63pin@222_polysilicon-1##10 9.772
R848 S1#63pin@222_polysilicon-1##10 S1#63pin@222_polysilicon-1##11 9.772
R849 S1#63pin@222_polysilicon-1##11 S1#63pin@222_polysilicon-1##12 9.772
R850 S1#63pin@222_polysilicon-1##12 S1#63pin@222_polysilicon-1##13 9.772
R851 S1#63pin@222_polysilicon-1##13 S1#63pin@222_polysilicon-1##14 9.772
R852 S1#63pin@222_polysilicon-1##14 S1#63pin@222_polysilicon-1##15 9.772
R853 S1#63pin@222_polysilicon-1##15 S1#63pin@222_polysilicon-1##16 9.772
R854 S1#63pin@222_polysilicon-1##16 S1#63pin@222_polysilicon-1##17 9.772
R855 S1#63pin@222_polysilicon-1##17 S1#63pin@222_polysilicon-1##18 9.772
R856 S1#63pin@222_polysilicon-1##18 S1#63pin@222_polysilicon-1##19 9.772
R857 S1#63pin@222_polysilicon-1##19 S1#63pin@222_polysilicon-1##20 9.772
R858 S1#63pin@222_polysilicon-1##20 S1#63pin@222_polysilicon-1##21 9.772
R859 S1#63pin@222_polysilicon-1##21 S1#67pin@223_polysilicon-1 9.772
R860 S1#56pin@190_polysilicon-1 S1#56pin@190_polysilicon-1##0 5.425
R861 S1#56pin@190_polysilicon-1##0 S1#68pmos@22_poly-right 5.425
R862 S1#64contact@192_metal-1-polysilicon-1 S1#64contact@192_metal-1-polysilicon-1##0 8.267
R863 S1#64contact@192_metal-1-polysilicon-1##0 S1#64contact@192_metal-1-polysilicon-1##1 8.267
R864 S1#64contact@192_metal-1-polysilicon-1##1 S1#70pin@213_polysilicon-1 8.267
R865 net@576#2pmos@23_poly-left net@576#3pin@201_polysilicon-1 7.75
R866 net@576#3pin@201_polysilicon-1 net@576#3pin@201_polysilicon-1##0 9.042
R867 net@576#3pin@201_polysilicon-1##0 net@576#3pin@201_polysilicon-1##1 9.042
R868 net@576#3pin@201_polysilicon-1##1 net@576#3pin@201_polysilicon-1##2 9.042
R869 net@576#3pin@201_polysilicon-1##2 net@576#3pin@201_polysilicon-1##3 9.042
R870 net@576#3pin@201_polysilicon-1##3 net@576#3pin@201_polysilicon-1##4 9.042
R871 net@576#3pin@201_polysilicon-1##4 net@576#6pin@202_polysilicon-1 9.042
R872 net@576#6pin@202_polysilicon-1 net@576#6pin@202_polysilicon-1##0 9.3
R873 net@576#6pin@202_polysilicon-1##0 net@576#6pin@202_polysilicon-1##1 9.3
R874 net@576#6pin@202_polysilicon-1##1 net@576#6pin@202_polysilicon-1##2 9.3
R875 net@576#6pin@202_polysilicon-1##2 net@576#6pin@202_polysilicon-1##3 9.3
R876 net@576#6pin@202_polysilicon-1##3 net@576#6pin@202_polysilicon-1##4 9.3
R877 net@576#6pin@202_polysilicon-1##4 net@576#6pin@202_polysilicon-1##5 9.3
R878 net@576#6pin@202_polysilicon-1##5 net@576#6pin@202_polysilicon-1##6 9.3
R879 net@576#6pin@202_polysilicon-1##6 net@576#7pin@203_polysilicon-1 9.3
R880 S1#64contact@192_metal-1-polysilicon-1 S1#64contact@192_metal-1-polysilicon-1##0 9.881
R881 S1#64contact@192_metal-1-polysilicon-1##0 S1#64contact@192_metal-1-polysilicon-1##1 9.881
R882 S1#64contact@192_metal-1-polysilicon-1##1 S1#64contact@192_metal-1-polysilicon-1##2 9.881
R883 S1#64contact@192_metal-1-polysilicon-1##2 S1#64contact@192_metal-1-polysilicon-1##3 9.881
R884 S1#64contact@192_metal-1-polysilicon-1##3 S1#64contact@192_metal-1-polysilicon-1##4 9.881
R885 S1#64contact@192_metal-1-polysilicon-1##4 S1#64contact@192_metal-1-polysilicon-1##5 9.881
R886 S1#64contact@192_metal-1-polysilicon-1##5 S1#64contact@192_metal-1-polysilicon-1##6 9.881
R887 S1#64contact@192_metal-1-polysilicon-1##6 S1#67pin@223_polysilicon-1 9.881
R888 net@578#1pin@228_polysilicon-1 net@578#1pin@228_polysilicon-1##0 9.042
R889 net@578#1pin@228_polysilicon-1##0 net@578#1pin@228_polysilicon-1##1 9.042
R890 net@578#1pin@228_polysilicon-1##1 net@578#1pin@228_polysilicon-1##2 9.042
R891 net@578#1pin@228_polysilicon-1##2 net@578#1pin@228_polysilicon-1##3 9.042
R892 net@578#1pin@228_polysilicon-1##3 net@578#1pin@228_polysilicon-1##4 9.042
R893 net@578#1pin@228_polysilicon-1##4 net@578#2contact@208_metal-1-n-act 9.042
R894 S1#64contact@192_metal-1-polysilicon-1 S1#64contact@192_metal-1-polysilicon-1##0 9.881
R895 S1#64contact@192_metal-1-polysilicon-1##0 S1#64contact@192_metal-1-polysilicon-1##1 9.881
R896 S1#64contact@192_metal-1-polysilicon-1##1 S1#64contact@192_metal-1-polysilicon-1##2 9.881
R897 S1#64contact@192_metal-1-polysilicon-1##2 S1#64contact@192_metal-1-polysilicon-1##3 9.881
R898 S1#64contact@192_metal-1-polysilicon-1##3 S1#64contact@192_metal-1-polysilicon-1##4 9.881
R899 S1#64contact@192_metal-1-polysilicon-1##4 S1#64contact@192_metal-1-polysilicon-1##5 9.881
R900 S1#64contact@192_metal-1-polysilicon-1##5 S1#64contact@192_metal-1-polysilicon-1##6 9.881
R901 S1#64contact@192_metal-1-polysilicon-1##6 S1#59pin@200_polysilicon-1 9.881
R902 S1#72nmos@25_poly-right S1#72nmos@25_poly-right##0 7.233
R903 S1#72nmos@25_poly-right##0 S1#72nmos@25_poly-right##1 7.233
R904 S1#72nmos@25_poly-right##1 S1#70pin@213_polysilicon-1 7.233
R905 S1#73pmos@24_poly-left S1#73pmos@24_poly-left##0 6.2
R906 S1#73pmos@24_poly-left##0 S1#74pin@216_polysilicon-1 6.2
R907 S1#74pin@216_polysilicon-1 S1#74pin@216_polysilicon-1##0 9.896
R908 S1#74pin@216_polysilicon-1##0 S1#74pin@216_polysilicon-1##1 9.896
R909 S1#74pin@216_polysilicon-1##1 S1#74pin@216_polysilicon-1##2 9.896
R910 S1#74pin@216_polysilicon-1##2 S1#74pin@216_polysilicon-1##3 9.896
R911 S1#74pin@216_polysilicon-1##3 S1#74pin@216_polysilicon-1##4 9.896
R912 S1#74pin@216_polysilicon-1##4 S1#74pin@216_polysilicon-1##5 9.896
R913 S1#74pin@216_polysilicon-1##5 S1#74pin@216_polysilicon-1##6 9.896
R914 S1#74pin@216_polysilicon-1##6 S1#74pin@216_polysilicon-1##7 9.896
R915 S1#74pin@216_polysilicon-1##7 S1#74pin@216_polysilicon-1##8 9.896
R916 S1#74pin@216_polysilicon-1##8 S1#74pin@216_polysilicon-1##9 9.896
R917 S1#74pin@216_polysilicon-1##9 S1#74pin@216_polysilicon-1##10 9.896
R918 S1#74pin@216_polysilicon-1##10 S1#74pin@216_polysilicon-1##11 9.896
R919 S1#74pin@216_polysilicon-1##11 S1#75pin@217_polysilicon-1 9.896
R920 S1#75pin@217_polysilicon-1 S1#75pin@217_polysilicon-1##0 9.521
R921 S1#75pin@217_polysilicon-1##0 S1#75pin@217_polysilicon-1##1 9.521
R922 S1#75pin@217_polysilicon-1##1 S1#75pin@217_polysilicon-1##2 9.521
R923 S1#75pin@217_polysilicon-1##2 S1#75pin@217_polysilicon-1##3 9.521
R924 S1#75pin@217_polysilicon-1##3 S1#75pin@217_polysilicon-1##4 9.521
R925 S1#75pin@217_polysilicon-1##4 S1#75pin@217_polysilicon-1##5 9.521
R926 S1#75pin@217_polysilicon-1##5 S1#64contact@192_metal-1-polysilicon-1 9.521
R927 S1#70pin@213_polysilicon-1 S1#70pin@213_polysilicon-1##0 5.425
R928 S1#70pin@213_polysilicon-1##0 S1#76pmos@25_poly-right 5.425
R929 net@576#1pin@205_polysilicon-1 net@576#1pin@205_polysilicon-1##0 9.042
R930 net@576#1pin@205_polysilicon-1##0 net@576#1pin@205_polysilicon-1##1 9.042
R931 net@576#1pin@205_polysilicon-1##1 net@576#1pin@205_polysilicon-1##2 9.042
R932 net@576#1pin@205_polysilicon-1##2 net@576#1pin@205_polysilicon-1##3 9.042
R933 net@576#1pin@205_polysilicon-1##3 net@576#1pin@205_polysilicon-1##4 9.042
R934 net@576#1pin@205_polysilicon-1##4 net@576#4pin@204_metal-1 9.042
R935 net@578#7pin@226_polysilicon-1 net@578#7pin@226_polysilicon-1##0 8.37
R936 net@578#7pin@226_polysilicon-1##0 net@578#7pin@226_polysilicon-1##1 8.37
R937 net@578#7pin@226_polysilicon-1##1 net@578#7pin@226_polysilicon-1##2 8.37
R938 net@578#7pin@226_polysilicon-1##2 net@578#7pin@226_polysilicon-1##3 8.37
R939 net@578#7pin@226_polysilicon-1##3 net@578#1pin@228_polysilicon-1 8.37
R940 net@728 net@728#1pin@299_polysilicon-1 7.75
R941 net@728#1pin@299_polysilicon-1 net@728#1pin@299_polysilicon-1##0 9.042
R942 net@728#1pin@299_polysilicon-1##0 net@728#1pin@299_polysilicon-1##1 9.042
R943 net@728#1pin@299_polysilicon-1##1 net@728#1pin@299_polysilicon-1##2 9.042
R944 net@728#1pin@299_polysilicon-1##2 net@728#1pin@299_polysilicon-1##3 9.042
R945 net@728#1pin@299_polysilicon-1##3 net@728#1pin@299_polysilicon-1##4 9.042
R946 net@728#1pin@299_polysilicon-1##4 net@728#2pin@300_polysilicon-1 9.042
R947 net@578#9pin@224_polysilicon-1 net@578#9pin@224_polysilicon-1##0 9.042
R948 net@578#9pin@224_polysilicon-1##0 net@578#9pin@224_polysilicon-1##1 9.042
R949 net@578#9pin@224_polysilicon-1##1 net@578#9pin@224_polysilicon-1##2 9.042
R950 net@578#9pin@224_polysilicon-1##2 net@578#9pin@224_polysilicon-1##3 9.042
R951 net@578#9pin@224_polysilicon-1##3 net@578#9pin@224_polysilicon-1##4 9.042
R952 net@578#9pin@224_polysilicon-1##4 net@578#10pin@225_polysilicon-1 9.042
R953 net@728#2pin@300_polysilicon-1 net@728#2pin@300_polysilicon-1##0 9.3
R954 net@728#2pin@300_polysilicon-1##0 net@728#2pin@300_polysilicon-1##1 9.3
R955 net@728#2pin@300_polysilicon-1##1 net@728#2pin@300_polysilicon-1##2 9.3
R956 net@728#2pin@300_polysilicon-1##2 net@728#2pin@300_polysilicon-1##3 9.3
R957 net@728#2pin@300_polysilicon-1##3 net@728#2pin@300_polysilicon-1##4 9.3
R958 net@728#2pin@300_polysilicon-1##4 net@728#2pin@300_polysilicon-1##5 9.3
R959 net@728#2pin@300_polysilicon-1##5 net@728#2pin@300_polysilicon-1##6 9.3
R960 net@728#2pin@300_polysilicon-1##6 net@728#3pin@301_polysilicon-1 9.3
R961 net@727#3pin@278_polysilicon-1 net@727#3pin@278_polysilicon-1##0 8.37
R962 net@727#3pin@278_polysilicon-1##0 net@727#3pin@278_polysilicon-1##1 8.37
R963 net@727#3pin@278_polysilicon-1##1 net@727#3pin@278_polysilicon-1##2 8.37
R964 net@727#3pin@278_polysilicon-1##2 net@727#3pin@278_polysilicon-1##3 8.37
R965 net@727#3pin@278_polysilicon-1##3 net@727#4pin@280_polysilicon-1 8.37
R966 net@727#7nmos@30_poly-right net@727#7nmos@30_poly-right##0 6.2
R967 net@727#7nmos@30_poly-right##0 net@727#4pin@280_polysilicon-1 6.2
R968 S2 S2##0 9.881
R969 S2##0 S2##1 9.881
R970 S2##1 S2##2 9.881
R971 S2##2 S2##3 9.881
R972 S2##3 S2##4 9.881
R973 S2##4 S2##5 9.881
R974 S2##5 S2##6 9.881
R975 S2##6 S2#31pin@245_polysilicon-1 9.881
R976 S1#88nmos@32_poly-left S1#88nmos@32_poly-left##0 6.975
R977 S1#88nmos@32_poly-left##0 S1#89pin@274_polysilicon-1 6.975
R978 S1#89pin@274_polysilicon-1 S1#89pin@274_polysilicon-1##0 9.772
R979 S1#89pin@274_polysilicon-1##0 S1#89pin@274_polysilicon-1##1 9.772
R980 S1#89pin@274_polysilicon-1##1 S1#89pin@274_polysilicon-1##2 9.772
R981 S1#89pin@274_polysilicon-1##2 S1#89pin@274_polysilicon-1##3 9.772
R982 S1#89pin@274_polysilicon-1##3 S1#89pin@274_polysilicon-1##4 9.772
R983 S1#89pin@274_polysilicon-1##4 S1#89pin@274_polysilicon-1##5 9.772
R984 S1#89pin@274_polysilicon-1##5 S1#89pin@274_polysilicon-1##6 9.772
R985 S1#89pin@274_polysilicon-1##6 S1#89pin@274_polysilicon-1##7 9.772
R986 S1#89pin@274_polysilicon-1##7 S1#89pin@274_polysilicon-1##8 9.772
R987 S1#89pin@274_polysilicon-1##8 S1#89pin@274_polysilicon-1##9 9.772
R988 S1#89pin@274_polysilicon-1##9 S1#89pin@274_polysilicon-1##10 9.772
R989 S1#89pin@274_polysilicon-1##10 S1#89pin@274_polysilicon-1##11 9.772
R990 S1#89pin@274_polysilicon-1##11 S1#89pin@274_polysilicon-1##12 9.772
R991 S1#89pin@274_polysilicon-1##12 S1#89pin@274_polysilicon-1##13 9.772
R992 S1#89pin@274_polysilicon-1##13 S1#89pin@274_polysilicon-1##14 9.772
R993 S1#89pin@274_polysilicon-1##14 S1#89pin@274_polysilicon-1##15 9.772
R994 S1#89pin@274_polysilicon-1##15 S1#89pin@274_polysilicon-1##16 9.772
R995 S1#89pin@274_polysilicon-1##16 S1#89pin@274_polysilicon-1##17 9.772
R996 S1#89pin@274_polysilicon-1##17 S1#89pin@274_polysilicon-1##18 9.772
R997 S1#89pin@274_polysilicon-1##18 S1#89pin@274_polysilicon-1##19 9.772
R998 S1#89pin@274_polysilicon-1##19 S1#89pin@274_polysilicon-1##20 9.772
R999 S1#89pin@274_polysilicon-1##20 S1#89pin@274_polysilicon-1##21 9.772
R1000 S1#89pin@274_polysilicon-1##21 S1#90pin@275_polysilicon-1 9.772
R1001 S1#64contact@192_metal-1-polysilicon-1 S1#64contact@192_metal-1-polysilicon-1##0 8.267
R1002 S1#64contact@192_metal-1-polysilicon-1##0 S1#64contact@192_metal-1-polysilicon-1##1 8.267
R1003 S1#64contact@192_metal-1-polysilicon-1##1 S1#91pin@265_polysilicon-1 8.267
R1004 net@727#8pmos@32_poly-left net@727#9pin@276_polysilicon-1 7.75
R1005 net@727#9pin@276_polysilicon-1 net@727#9pin@276_polysilicon-1##0 9.042
R1006 net@727#9pin@276_polysilicon-1##0 net@727#9pin@276_polysilicon-1##1 9.042
R1007 net@727#9pin@276_polysilicon-1##1 net@727#9pin@276_polysilicon-1##2 9.042
R1008 net@727#9pin@276_polysilicon-1##2 net@727#9pin@276_polysilicon-1##3 9.042
R1009 net@727#9pin@276_polysilicon-1##3 net@727#9pin@276_polysilicon-1##4 9.042
R1010 net@727#9pin@276_polysilicon-1##4 net@727#10pin@277_polysilicon-1 9.042
R1011 net@727#10pin@277_polysilicon-1 net@727#10pin@277_polysilicon-1##0 9.3
R1012 net@727#10pin@277_polysilicon-1##0 net@727#10pin@277_polysilicon-1##1 9.3
R1013 net@727#10pin@277_polysilicon-1##1 net@727#10pin@277_polysilicon-1##2 9.3
R1014 net@727#10pin@277_polysilicon-1##2 net@727#10pin@277_polysilicon-1##3 9.3
R1015 net@727#10pin@277_polysilicon-1##3 net@727#10pin@277_polysilicon-1##4 9.3
R1016 net@727#10pin@277_polysilicon-1##4 net@727#10pin@277_polysilicon-1##5 9.3
R1017 net@727#10pin@277_polysilicon-1##5 net@727#10pin@277_polysilicon-1##6 9.3
R1018 net@727#10pin@277_polysilicon-1##6 net@727#3pin@278_polysilicon-1 9.3
R1019 net@495#3pin@250_polysilicon-1 net@495#3pin@250_polysilicon-1##0 9.042
R1020 net@495#3pin@250_polysilicon-1##0 net@495#3pin@250_polysilicon-1##1 9.042
R1021 net@495#3pin@250_polysilicon-1##1 net@495#3pin@250_polysilicon-1##2 9.042
R1022 net@495#3pin@250_polysilicon-1##2 net@495#3pin@250_polysilicon-1##3 9.042
R1023 net@495#3pin@250_polysilicon-1##3 net@495#3pin@250_polysilicon-1##4 9.042
R1024 net@495#3pin@250_polysilicon-1##4 net@495 9.042
R1025 S1#64contact@192_metal-1-polysilicon-1 S1#64contact@192_metal-1-polysilicon-1##0 9.881
R1026 S1#64contact@192_metal-1-polysilicon-1##0 S1#64contact@192_metal-1-polysilicon-1##1 9.881
R1027 S1#64contact@192_metal-1-polysilicon-1##1 S1#64contact@192_metal-1-polysilicon-1##2 9.881
R1028 S1#64contact@192_metal-1-polysilicon-1##2 S1#64contact@192_metal-1-polysilicon-1##3 9.881
R1029 S1#64contact@192_metal-1-polysilicon-1##3 S1#64contact@192_metal-1-polysilicon-1##4 9.881
R1030 S1#64contact@192_metal-1-polysilicon-1##4 S1#64contact@192_metal-1-polysilicon-1##5 9.881
R1031 S1#64contact@192_metal-1-polysilicon-1##5 S1#64contact@192_metal-1-polysilicon-1##6 9.881
R1032 S1#64contact@192_metal-1-polysilicon-1##6 S1#93pin@298_polysilicon-1 9.881
R1033 net@728#6pin@303_polysilicon-1 net@728#6pin@303_polysilicon-1##0 9.042
R1034 net@728#6pin@303_polysilicon-1##0 net@728#6pin@303_polysilicon-1##1 9.042
R1035 net@728#6pin@303_polysilicon-1##1 net@728#6pin@303_polysilicon-1##2 9.042
R1036 net@728#6pin@303_polysilicon-1##2 net@728#6pin@303_polysilicon-1##3 9.042
R1037 net@728#6pin@303_polysilicon-1##3 net@728#6pin@303_polysilicon-1##4 9.042
R1038 net@728#6pin@303_polysilicon-1##4 net@728#4contact@277_metal-1-n-act 9.042
R1039 S1#64contact@192_metal-1-polysilicon-1 S1#64contact@192_metal-1-polysilicon-1##0 9.881
R1040 S1#64contact@192_metal-1-polysilicon-1##0 S1#64contact@192_metal-1-polysilicon-1##1 9.881
R1041 S1#64contact@192_metal-1-polysilicon-1##1 S1#64contact@192_metal-1-polysilicon-1##2 9.881
R1042 S1#64contact@192_metal-1-polysilicon-1##2 S1#64contact@192_metal-1-polysilicon-1##3 9.881
R1043 S1#64contact@192_metal-1-polysilicon-1##3 S1#64contact@192_metal-1-polysilicon-1##4 9.881
R1044 S1#64contact@192_metal-1-polysilicon-1##4 S1#64contact@192_metal-1-polysilicon-1##5 9.881
R1045 S1#64contact@192_metal-1-polysilicon-1##5 S1#64contact@192_metal-1-polysilicon-1##6 9.881
R1046 S1#64contact@192_metal-1-polysilicon-1##6 S1#90pin@275_polysilicon-1 9.881
R1047 S1#95nmos@34_poly-right S1#95nmos@34_poly-right##0 7.233
R1048 S1#95nmos@34_poly-right##0 S1#95nmos@34_poly-right##1 7.233
R1049 S1#95nmos@34_poly-right##1 S1#96pin@288_polysilicon-1 7.233
R1050 S1#97pmos@33_poly-left S1#97pmos@33_poly-left##0 6.2
R1051 S1#97pmos@33_poly-left##0 S1#98pin@291_polysilicon-1 6.2
R1052 S1#98pin@291_polysilicon-1 S1#98pin@291_polysilicon-1##0 9.896
R1053 S1#98pin@291_polysilicon-1##0 S1#98pin@291_polysilicon-1##1 9.896
R1054 S1#98pin@291_polysilicon-1##1 S1#98pin@291_polysilicon-1##2 9.896
R1055 S1#98pin@291_polysilicon-1##2 S1#98pin@291_polysilicon-1##3 9.896
R1056 S1#98pin@291_polysilicon-1##3 S1#98pin@291_polysilicon-1##4 9.896
R1057 S1#98pin@291_polysilicon-1##4 S1#98pin@291_polysilicon-1##5 9.896
R1058 S1#98pin@291_polysilicon-1##5 S1#98pin@291_polysilicon-1##6 9.896
R1059 S1#98pin@291_polysilicon-1##6 S1#98pin@291_polysilicon-1##7 9.896
R1060 S1#98pin@291_polysilicon-1##7 S1#98pin@291_polysilicon-1##8 9.896
R1061 S1#98pin@291_polysilicon-1##8 S1#98pin@291_polysilicon-1##9 9.896
R1062 S1#98pin@291_polysilicon-1##9 S1#98pin@291_polysilicon-1##10 9.896
R1063 S1#98pin@291_polysilicon-1##10 S1#98pin@291_polysilicon-1##11 9.896
R1064 S1#98pin@291_polysilicon-1##11 S1#99pin@292_polysilicon-1 9.896
R1065 S1#99pin@292_polysilicon-1 S1#99pin@292_polysilicon-1##0 9.521
R1066 S1#99pin@292_polysilicon-1##0 S1#99pin@292_polysilicon-1##1 9.521
R1067 S1#99pin@292_polysilicon-1##1 S1#99pin@292_polysilicon-1##2 9.521
R1068 S1#99pin@292_polysilicon-1##2 S1#99pin@292_polysilicon-1##3 9.521
R1069 S1#99pin@292_polysilicon-1##3 S1#99pin@292_polysilicon-1##4 9.521
R1070 S1#99pin@292_polysilicon-1##4 S1#99pin@292_polysilicon-1##5 9.521
R1071 S1#99pin@292_polysilicon-1##5 S1#64contact@192_metal-1-polysilicon-1 9.521
R1072 S1#96pin@288_polysilicon-1 S1#96pin@288_polysilicon-1##0 5.425
R1073 S1#96pin@288_polysilicon-1##0 S1#101pmos@34_poly-right 5.425
R1074 net@578#11pmos@26_poly-left net@578#9pin@224_polysilicon-1 7.75
R1075 net@727#4pin@280_polysilicon-1 net@727#4pin@280_polysilicon-1##0 9.042
R1076 net@727#4pin@280_polysilicon-1##0 net@727#4pin@280_polysilicon-1##1 9.042
R1077 net@727#4pin@280_polysilicon-1##1 net@727#4pin@280_polysilicon-1##2 9.042
R1078 net@727#4pin@280_polysilicon-1##2 net@727#4pin@280_polysilicon-1##3 9.042
R1079 net@727#4pin@280_polysilicon-1##3 net@727#4pin@280_polysilicon-1##4 9.042
R1080 net@727#4pin@280_polysilicon-1##4 net@727 9.042
R1081 net@728#3pin@301_polysilicon-1 net@728#3pin@301_polysilicon-1##0 8.37
R1082 net@728#3pin@301_polysilicon-1##0 net@728#3pin@301_polysilicon-1##1 8.37
R1083 net@728#3pin@301_polysilicon-1##1 net@728#3pin@301_polysilicon-1##2 8.37
R1084 net@728#3pin@301_polysilicon-1##2 net@728#3pin@301_polysilicon-1##3 8.37
R1085 net@728#3pin@301_polysilicon-1##3 net@728#6pin@303_polysilicon-1 8.37
R1086 S2 S2##0 9.881
R1087 S2##0 S2##1 9.881
R1088 S2##1 S2##2 9.881
R1089 S2##2 S2##3 9.881
R1090 S2##3 S2##4 9.881
R1091 S2##4 S2##5 9.881
R1092 S2##5 S2##6 9.881
R1093 S2##6 S2#36pin@320_polysilicon-1 9.881
R1094 net@844#2pin@325_polysilicon-1 net@844#2pin@325_polysilicon-1##0 9.042
R1095 net@844#2pin@325_polysilicon-1##0 net@844#2pin@325_polysilicon-1##1 9.042
R1096 net@844#2pin@325_polysilicon-1##1 net@844#2pin@325_polysilicon-1##2 9.042
R1097 net@844#2pin@325_polysilicon-1##2 net@844#2pin@325_polysilicon-1##3 9.042
R1098 net@844#2pin@325_polysilicon-1##3 net@844#2pin@325_polysilicon-1##4 9.042
R1099 net@844#2pin@325_polysilicon-1##4 net@844 9.042
R1100 S2#37nmos@37_poly-right S2#37nmos@37_poly-right##0 7.233
R1101 S2#37nmos@37_poly-right##0 S2#37nmos@37_poly-right##1 7.233
R1102 S2#37nmos@37_poly-right##1 S2#38pin@311_polysilicon-1 7.233
R1103 S2#39nmos@28_poly-right S2#39nmos@28_poly-right##0 7.233
R1104 S2#39nmos@28_poly-right##0 S2#39nmos@28_poly-right##1 7.233
R1105 S2#39nmos@28_poly-right##1 S2#32pin@236_polysilicon-1 7.233
R1106 S2#40pmos@36_poly-left S2#40pmos@36_poly-left##0 6.2
R1107 S2#40pmos@36_poly-left##0 S2#41pin@314_polysilicon-1 6.2
R1108 S2#41pin@314_polysilicon-1 S2#41pin@314_polysilicon-1##0 9.896
R1109 S2#41pin@314_polysilicon-1##0 S2#41pin@314_polysilicon-1##1 9.896
R1110 S2#41pin@314_polysilicon-1##1 S2#41pin@314_polysilicon-1##2 9.896
R1111 S2#41pin@314_polysilicon-1##2 S2#41pin@314_polysilicon-1##3 9.896
R1112 S2#41pin@314_polysilicon-1##3 S2#41pin@314_polysilicon-1##4 9.896
R1113 S2#41pin@314_polysilicon-1##4 S2#41pin@314_polysilicon-1##5 9.896
R1114 S2#41pin@314_polysilicon-1##5 S2#41pin@314_polysilicon-1##6 9.896
R1115 S2#41pin@314_polysilicon-1##6 S2#41pin@314_polysilicon-1##7 9.896
R1116 S2#41pin@314_polysilicon-1##7 S2#41pin@314_polysilicon-1##8 9.896
R1117 S2#41pin@314_polysilicon-1##8 S2#41pin@314_polysilicon-1##9 9.896
R1118 S2#41pin@314_polysilicon-1##9 S2#41pin@314_polysilicon-1##10 9.896
R1119 S2#41pin@314_polysilicon-1##10 S2#41pin@314_polysilicon-1##11 9.896
R1120 S2#41pin@314_polysilicon-1##11 S2#42pin@315_polysilicon-1 9.896
R1121 net@578#10pin@225_polysilicon-1 net@578#10pin@225_polysilicon-1##0 9.3
R1122 net@578#10pin@225_polysilicon-1##0 net@578#10pin@225_polysilicon-1##1 9.3
R1123 net@578#10pin@225_polysilicon-1##1 net@578#10pin@225_polysilicon-1##2 9.3
R1124 net@578#10pin@225_polysilicon-1##2 net@578#10pin@225_polysilicon-1##3 9.3
R1125 net@578#10pin@225_polysilicon-1##3 net@578#10pin@225_polysilicon-1##4 9.3
R1126 net@578#10pin@225_polysilicon-1##4 net@578#10pin@225_polysilicon-1##5 9.3
R1127 net@578#10pin@225_polysilicon-1##5 net@578#10pin@225_polysilicon-1##6 9.3
R1128 net@578#10pin@225_polysilicon-1##6 net@578#7pin@226_polysilicon-1 9.3
R1129 S2#42pin@315_polysilicon-1 S2#42pin@315_polysilicon-1##0 9.521
R1130 S2#42pin@315_polysilicon-1##0 S2#42pin@315_polysilicon-1##1 9.521
R1131 S2#42pin@315_polysilicon-1##1 S2#42pin@315_polysilicon-1##2 9.521
R1132 S2#42pin@315_polysilicon-1##2 S2#42pin@315_polysilicon-1##3 9.521
R1133 S2#42pin@315_polysilicon-1##3 S2#42pin@315_polysilicon-1##4 9.521
R1134 S2#42pin@315_polysilicon-1##4 S2#42pin@315_polysilicon-1##5 9.521
R1135 S2#42pin@315_polysilicon-1##5 S2 9.521
R1136 S2#38pin@311_polysilicon-1 S2#38pin@311_polysilicon-1##0 5.425
R1137 S2#38pin@311_polysilicon-1##0 S2#44pmos@37_poly-right 5.425
R1138 net@728#11nmos@33_poly-right net@728#11nmos@33_poly-right##0 6.2
R1139 net@728#11nmos@33_poly-right##0 net@728#6pin@303_polysilicon-1 6.2
R1140 net@844#6pin@323_polysilicon-1 net@844#6pin@323_polysilicon-1##0 8.37
R1141 net@844#6pin@323_polysilicon-1##0 net@844#6pin@323_polysilicon-1##1 8.37
R1142 net@844#6pin@323_polysilicon-1##1 net@844#6pin@323_polysilicon-1##2 8.37
R1143 net@844#6pin@323_polysilicon-1##2 net@844#6pin@323_polysilicon-1##3 8.37
R1144 net@844#6pin@323_polysilicon-1##3 net@844#2pin@325_polysilicon-1 8.37
R1145 S2#46pmos@27_poly-left S2#46pmos@27_poly-left##0 6.2
R1146 S2#46pmos@27_poly-left##0 S2#47pin@239_polysilicon-1 6.2
R1147 S1#102nmos@31_poly-right S1#102nmos@31_poly-right##0 7.233
R1148 S1#102nmos@31_poly-right##0 S1#102nmos@31_poly-right##1 7.233
R1149 S1#102nmos@31_poly-right##1 S1#91pin@265_polysilicon-1 7.233
R1150 net@844#8nmos@36_poly-right net@844#8nmos@36_poly-right##0 6.2
R1151 net@844#8nmos@36_poly-right##0 net@844#2pin@325_polysilicon-1 6.2
R1152 S1#103pmos@30_poly-left S1#103pmos@30_poly-left##0 6.2
R1153 S1#103pmos@30_poly-left##0 S1#104pin@268_polysilicon-1 6.2
R1154 S2#48nmos@38_poly-left S2#48nmos@38_poly-left##0 6.975
R1155 S2#48nmos@38_poly-left##0 S2#49pin@319_polysilicon-1 6.975
R1156 S2#49pin@319_polysilicon-1 S2#49pin@319_polysilicon-1##0 9.772
R1157 S2#49pin@319_polysilicon-1##0 S2#49pin@319_polysilicon-1##1 9.772
R1158 S2#49pin@319_polysilicon-1##1 S2#49pin@319_polysilicon-1##2 9.772
R1159 S2#49pin@319_polysilicon-1##2 S2#49pin@319_polysilicon-1##3 9.772
R1160 S2#49pin@319_polysilicon-1##3 S2#49pin@319_polysilicon-1##4 9.772
R1161 S2#49pin@319_polysilicon-1##4 S2#49pin@319_polysilicon-1##5 9.772
R1162 S2#49pin@319_polysilicon-1##5 S2#49pin@319_polysilicon-1##6 9.772
R1163 S2#49pin@319_polysilicon-1##6 S2#49pin@319_polysilicon-1##7 9.772
R1164 S2#49pin@319_polysilicon-1##7 S2#49pin@319_polysilicon-1##8 9.772
R1165 S2#49pin@319_polysilicon-1##8 S2#49pin@319_polysilicon-1##9 9.772
R1166 S2#49pin@319_polysilicon-1##9 S2#49pin@319_polysilicon-1##10 9.772
R1167 S2#49pin@319_polysilicon-1##10 S2#49pin@319_polysilicon-1##11 9.772
R1168 S2#49pin@319_polysilicon-1##11 S2#49pin@319_polysilicon-1##12 9.772
R1169 S2#49pin@319_polysilicon-1##12 S2#49pin@319_polysilicon-1##13 9.772
R1170 S2#49pin@319_polysilicon-1##13 S2#49pin@319_polysilicon-1##14 9.772
R1171 S2#49pin@319_polysilicon-1##14 S2#49pin@319_polysilicon-1##15 9.772
R1172 S2#49pin@319_polysilicon-1##15 S2#49pin@319_polysilicon-1##16 9.772
R1173 S2#49pin@319_polysilicon-1##16 S2#49pin@319_polysilicon-1##17 9.772
R1174 S2#49pin@319_polysilicon-1##17 S2#49pin@319_polysilicon-1##18 9.772
R1175 S2#49pin@319_polysilicon-1##18 S2#49pin@319_polysilicon-1##19 9.772
R1176 S2#49pin@319_polysilicon-1##19 S2#49pin@319_polysilicon-1##20 9.772
R1177 S2#49pin@319_polysilicon-1##20 S2#49pin@319_polysilicon-1##21 9.772
R1178 S2#49pin@319_polysilicon-1##21 S2#36pin@320_polysilicon-1 9.772
R1179 S2 S2##0 8.267
R1180 S2##0 S2##1 8.267
R1181 S2##1 S2#38pin@311_polysilicon-1 8.267
R1182 net@844#9pmos@38_poly-left net@844#10pin@321_polysilicon-1 7.75
R1183 S1#105nmos@35_poly-left S1#105nmos@35_poly-left##0 6.975
R1184 S1#105nmos@35_poly-left##0 S1#106pin@297_polysilicon-1 6.975
R1185 net@576#7pin@203_polysilicon-1 net@576#7pin@203_polysilicon-1##0 8.37
R1186 net@576#7pin@203_polysilicon-1##0 net@576#7pin@203_polysilicon-1##1 8.37
R1187 net@576#7pin@203_polysilicon-1##1 net@576#7pin@203_polysilicon-1##2 8.37
R1188 net@576#7pin@203_polysilicon-1##2 net@576#7pin@203_polysilicon-1##3 8.37
R1189 net@576#7pin@203_polysilicon-1##3 net@576#1pin@205_polysilicon-1 8.37
R1190 S2#47pin@239_polysilicon-1 S2#47pin@239_polysilicon-1##0 9.896
R1191 S2#47pin@239_polysilicon-1##0 S2#47pin@239_polysilicon-1##1 9.896
R1192 S2#47pin@239_polysilicon-1##1 S2#47pin@239_polysilicon-1##2 9.896
R1193 S2#47pin@239_polysilicon-1##2 S2#47pin@239_polysilicon-1##3 9.896
R1194 S2#47pin@239_polysilicon-1##3 S2#47pin@239_polysilicon-1##4 9.896
R1195 S2#47pin@239_polysilicon-1##4 S2#47pin@239_polysilicon-1##5 9.896
R1196 S2#47pin@239_polysilicon-1##5 S2#47pin@239_polysilicon-1##6 9.896
R1197 S2#47pin@239_polysilicon-1##6 S2#47pin@239_polysilicon-1##7 9.896
R1198 S2#47pin@239_polysilicon-1##7 S2#47pin@239_polysilicon-1##8 9.896
R1199 S2#47pin@239_polysilicon-1##8 S2#47pin@239_polysilicon-1##9 9.896
R1200 S2#47pin@239_polysilicon-1##9 S2#47pin@239_polysilicon-1##10 9.896
R1201 S2#47pin@239_polysilicon-1##10 S2#47pin@239_polysilicon-1##11 9.896
R1202 S2#47pin@239_polysilicon-1##11 S2#50pin@240_polysilicon-1 9.896
R1203 net@844#10pin@321_polysilicon-1 net@844#10pin@321_polysilicon-1##0 9.042
R1204 net@844#10pin@321_polysilicon-1##0 net@844#10pin@321_polysilicon-1##1 9.042
R1205 net@844#10pin@321_polysilicon-1##1 net@844#10pin@321_polysilicon-1##2 9.042
R1206 net@844#10pin@321_polysilicon-1##2 net@844#10pin@321_polysilicon-1##3 9.042
R1207 net@844#10pin@321_polysilicon-1##3 net@844#10pin@321_polysilicon-1##4 9.042
R1208 net@844#10pin@321_polysilicon-1##4 net@844#11pin@322_polysilicon-1 9.042
R1209 net@844#11pin@322_polysilicon-1 net@844#11pin@322_polysilicon-1##0 9.3
R1210 net@844#11pin@322_polysilicon-1##0 net@844#11pin@322_polysilicon-1##1 9.3
R1211 net@844#11pin@322_polysilicon-1##1 net@844#11pin@322_polysilicon-1##2 9.3
R1212 net@844#11pin@322_polysilicon-1##2 net@844#11pin@322_polysilicon-1##3 9.3
R1213 net@844#11pin@322_polysilicon-1##3 net@844#11pin@322_polysilicon-1##4 9.3
R1214 net@844#11pin@322_polysilicon-1##4 net@844#11pin@322_polysilicon-1##5 9.3
R1215 net@844#11pin@322_polysilicon-1##5 net@844#11pin@322_polysilicon-1##6 9.3
R1216 net@844#11pin@322_polysilicon-1##6 net@844#6pin@323_polysilicon-1 9.3
R1217 S1#104pin@268_polysilicon-1 S1#104pin@268_polysilicon-1##0 9.896
R1218 S1#104pin@268_polysilicon-1##0 S1#104pin@268_polysilicon-1##1 9.896
R1219 S1#104pin@268_polysilicon-1##1 S1#104pin@268_polysilicon-1##2 9.896
R1220 S1#104pin@268_polysilicon-1##2 S1#104pin@268_polysilicon-1##3 9.896
R1221 S1#104pin@268_polysilicon-1##3 S1#104pin@268_polysilicon-1##4 9.896
R1222 S1#104pin@268_polysilicon-1##4 S1#104pin@268_polysilicon-1##5 9.896
R1223 S1#104pin@268_polysilicon-1##5 S1#104pin@268_polysilicon-1##6 9.896
R1224 S1#104pin@268_polysilicon-1##6 S1#104pin@268_polysilicon-1##7 9.896
R1225 S1#104pin@268_polysilicon-1##7 S1#104pin@268_polysilicon-1##8 9.896
R1226 S1#104pin@268_polysilicon-1##8 S1#104pin@268_polysilicon-1##9 9.896
R1227 S1#104pin@268_polysilicon-1##9 S1#104pin@268_polysilicon-1##10 9.896
R1228 S1#104pin@268_polysilicon-1##10 S1#104pin@268_polysilicon-1##11 9.896
R1229 S1#104pin@268_polysilicon-1##11 S1#107pin@269_polysilicon-1 9.896
R1230 S1#107pin@269_polysilicon-1 S1#107pin@269_polysilicon-1##0 9.521
R1231 S1#107pin@269_polysilicon-1##0 S1#107pin@269_polysilicon-1##1 9.521
R1232 S1#107pin@269_polysilicon-1##1 S1#107pin@269_polysilicon-1##2 9.521
R1233 S1#107pin@269_polysilicon-1##2 S1#107pin@269_polysilicon-1##3 9.521
R1234 S1#107pin@269_polysilicon-1##3 S1#107pin@269_polysilicon-1##4 9.521
R1235 S1#107pin@269_polysilicon-1##4 S1#107pin@269_polysilicon-1##5 9.521
R1236 S1#107pin@269_polysilicon-1##5 S1#64contact@192_metal-1-polysilicon-1 9.521
R1237 S2#50pin@240_polysilicon-1 S2#50pin@240_polysilicon-1##0 9.521
R1238 S2#50pin@240_polysilicon-1##0 S2#50pin@240_polysilicon-1##1 9.521
R1239 S2#50pin@240_polysilicon-1##1 S2#50pin@240_polysilicon-1##2 9.521
R1240 S2#50pin@240_polysilicon-1##2 S2#50pin@240_polysilicon-1##3 9.521
R1241 S2#50pin@240_polysilicon-1##3 S2#50pin@240_polysilicon-1##4 9.521
R1242 S2#50pin@240_polysilicon-1##4 S2#50pin@240_polysilicon-1##5 9.521
R1243 S2#50pin@240_polysilicon-1##5 S2 9.521
R1244 S1#106pin@297_polysilicon-1 S1#106pin@297_polysilicon-1##0 9.772
R1245 S1#106pin@297_polysilicon-1##0 S1#106pin@297_polysilicon-1##1 9.772
R1246 S1#106pin@297_polysilicon-1##1 S1#106pin@297_polysilicon-1##2 9.772
R1247 S1#106pin@297_polysilicon-1##2 S1#106pin@297_polysilicon-1##3 9.772
R1248 S1#106pin@297_polysilicon-1##3 S1#106pin@297_polysilicon-1##4 9.772
R1249 S1#106pin@297_polysilicon-1##4 S1#106pin@297_polysilicon-1##5 9.772
R1250 S1#106pin@297_polysilicon-1##5 S1#106pin@297_polysilicon-1##6 9.772
R1251 S1#106pin@297_polysilicon-1##6 S1#106pin@297_polysilicon-1##7 9.772
R1252 S1#106pin@297_polysilicon-1##7 S1#106pin@297_polysilicon-1##8 9.772
R1253 S1#106pin@297_polysilicon-1##8 S1#106pin@297_polysilicon-1##9 9.772
R1254 S1#106pin@297_polysilicon-1##9 S1#106pin@297_polysilicon-1##10 9.772
R1255 S1#106pin@297_polysilicon-1##10 S1#106pin@297_polysilicon-1##11 9.772
R1256 S1#106pin@297_polysilicon-1##11 S1#106pin@297_polysilicon-1##12 9.772
R1257 S1#106pin@297_polysilicon-1##12 S1#106pin@297_polysilicon-1##13 9.772
R1258 S1#106pin@297_polysilicon-1##13 S1#106pin@297_polysilicon-1##14 9.772
R1259 S1#106pin@297_polysilicon-1##14 S1#106pin@297_polysilicon-1##15 9.772
R1260 S1#106pin@297_polysilicon-1##15 S1#106pin@297_polysilicon-1##16 9.772
R1261 S1#106pin@297_polysilicon-1##16 S1#106pin@297_polysilicon-1##17 9.772
R1262 S1#106pin@297_polysilicon-1##17 S1#106pin@297_polysilicon-1##18 9.772
R1263 S1#106pin@297_polysilicon-1##18 S1#106pin@297_polysilicon-1##19 9.772
R1264 S1#106pin@297_polysilicon-1##19 S1#106pin@297_polysilicon-1##20 9.772
R1265 S1#106pin@297_polysilicon-1##20 S1#106pin@297_polysilicon-1##21 9.772
R1266 S1#106pin@297_polysilicon-1##21 S1#93pin@298_polysilicon-1 9.772
R1267 S1#91pin@265_polysilicon-1 S1#91pin@265_polysilicon-1##0 5.425
R1268 S1#91pin@265_polysilicon-1##0 S1#108pmos@31_poly-right 5.425
R1269 S1#64contact@192_metal-1-polysilicon-1 S1#64contact@192_metal-1-polysilicon-1##0 8.267
R1270 S1#64contact@192_metal-1-polysilicon-1##0 S1#64contact@192_metal-1-polysilicon-1##1 8.267
R1271 S1#64contact@192_metal-1-polysilicon-1##1 S1#96pin@288_polysilicon-1 8.267
R1272 S2#32pin@236_polysilicon-1 S2#32pin@236_polysilicon-1##0 5.425
R1273 S2#32pin@236_polysilicon-1##0 S2#51pmos@28_poly-right 5.425
R1274 S1 S1#64contact@192_metal-1-polysilicon-1 4.69
R1275 net@1014#4pin@406_polysilicon-1 net@1014#4pin@406_polysilicon-1##0 8.37
R1276 net@1014#4pin@406_polysilicon-1##0 net@1014#4pin@406_polysilicon-1##1 8.37
R1277 net@1014#4pin@406_polysilicon-1##1 net@1014#4pin@406_polysilicon-1##2 8.37
R1278 net@1014#4pin@406_polysilicon-1##2 net@1014#4pin@406_polysilicon-1##3 8.37
R1279 net@1014#4pin@406_polysilicon-1##3 net@1014#5pin@408_polysilicon-1 8.37
R1280 net@1014#6nmos@42_poly-right net@1014#6nmos@42_poly-right##0 6.2
R1281 net@1014#6nmos@42_poly-right##0 net@1014#5pin@408_polysilicon-1 6.2
R1282 S3 S3##0 9.881
R1283 S3##0 S3##1 9.881
R1284 S3##1 S3##2 9.881
R1285 S3##2 S3##3 9.881
R1286 S3##3 S3##4 9.881
R1287 S3##4 S3##5 9.881
R1288 S3##5 S3##6 9.881
R1289 S3##6 S3#1pin@403_polysilicon-1 9.881
R1290 net@1014#5pin@408_polysilicon-1 net@1014#5pin@408_polysilicon-1##0 9.042
R1291 net@1014#5pin@408_polysilicon-1##0 net@1014#5pin@408_polysilicon-1##1 9.042
R1292 net@1014#5pin@408_polysilicon-1##1 net@1014#5pin@408_polysilicon-1##2 9.042
R1293 net@1014#5pin@408_polysilicon-1##2 net@1014#5pin@408_polysilicon-1##3 9.042
R1294 net@1014#5pin@408_polysilicon-1##3 net@1014#5pin@408_polysilicon-1##4 9.042
R1295 net@1014#5pin@408_polysilicon-1##4 net@1014 9.042
R1296 S3#2nmos@43_poly-right S3#2nmos@43_poly-right##0 7.233
R1297 S3#2nmos@43_poly-right##0 S3#2nmos@43_poly-right##1 7.233
R1298 S3#2nmos@43_poly-right##1 S3#3pin@393_polysilicon-1 7.233
R1299 S3#4pmos@42_poly-left S3#4pmos@42_poly-left##0 6.2
R1300 S3#4pmos@42_poly-left##0 S3#5pin@396_polysilicon-1 6.2
R1301 S3#5pin@396_polysilicon-1 S3#5pin@396_polysilicon-1##0 9.896
R1302 S3#5pin@396_polysilicon-1##0 S3#5pin@396_polysilicon-1##1 9.896
R1303 S3#5pin@396_polysilicon-1##1 S3#5pin@396_polysilicon-1##2 9.896
R1304 S3#5pin@396_polysilicon-1##2 S3#5pin@396_polysilicon-1##3 9.896
R1305 S3#5pin@396_polysilicon-1##3 S3#5pin@396_polysilicon-1##4 9.896
R1306 S3#5pin@396_polysilicon-1##4 S3#5pin@396_polysilicon-1##5 9.896
R1307 S3#5pin@396_polysilicon-1##5 S3#5pin@396_polysilicon-1##6 9.896
R1308 S3#5pin@396_polysilicon-1##6 S3#5pin@396_polysilicon-1##7 9.896
R1309 S3#5pin@396_polysilicon-1##7 S3#5pin@396_polysilicon-1##8 9.896
R1310 S3#5pin@396_polysilicon-1##8 S3#5pin@396_polysilicon-1##9 9.896
R1311 S3#5pin@396_polysilicon-1##9 S3#5pin@396_polysilicon-1##10 9.896
R1312 S3#5pin@396_polysilicon-1##10 S3#5pin@396_polysilicon-1##11 9.896
R1313 S3#5pin@396_polysilicon-1##11 S3#6pin@397_polysilicon-1 9.896
R1314 S3#6pin@397_polysilicon-1 S3#6pin@397_polysilicon-1##0 9.521
R1315 S3#6pin@397_polysilicon-1##0 S3#6pin@397_polysilicon-1##1 9.521
R1316 S3#6pin@397_polysilicon-1##1 S3#6pin@397_polysilicon-1##2 9.521
R1317 S3#6pin@397_polysilicon-1##2 S3#6pin@397_polysilicon-1##3 9.521
R1318 S3#6pin@397_polysilicon-1##3 S3#6pin@397_polysilicon-1##4 9.521
R1319 S3#6pin@397_polysilicon-1##4 S3#6pin@397_polysilicon-1##5 9.521
R1320 S3#6pin@397_polysilicon-1##5 S3 9.521
R1321 S3#3pin@393_polysilicon-1 S3#3pin@393_polysilicon-1##0 5.425
R1322 S3#3pin@393_polysilicon-1##0 S3#8pmos@43_poly-right 5.425
R1323 S3#10nmos@44_poly-left S3#10nmos@44_poly-left##0 6.975
R1324 S3#10nmos@44_poly-left##0 S3#11pin@402_polysilicon-1 6.975
R1325 S3#11pin@402_polysilicon-1 S3#11pin@402_polysilicon-1##0 9.772
R1326 S3#11pin@402_polysilicon-1##0 S3#11pin@402_polysilicon-1##1 9.772
R1327 S3#11pin@402_polysilicon-1##1 S3#11pin@402_polysilicon-1##2 9.772
R1328 S3#11pin@402_polysilicon-1##2 S3#11pin@402_polysilicon-1##3 9.772
R1329 S3#11pin@402_polysilicon-1##3 S3#11pin@402_polysilicon-1##4 9.772
R1330 S3#11pin@402_polysilicon-1##4 S3#11pin@402_polysilicon-1##5 9.772
R1331 S3#11pin@402_polysilicon-1##5 S3#11pin@402_polysilicon-1##6 9.772
R1332 S3#11pin@402_polysilicon-1##6 S3#11pin@402_polysilicon-1##7 9.772
R1333 S3#11pin@402_polysilicon-1##7 S3#11pin@402_polysilicon-1##8 9.772
R1334 S3#11pin@402_polysilicon-1##8 S3#11pin@402_polysilicon-1##9 9.772
R1335 S3#11pin@402_polysilicon-1##9 S3#11pin@402_polysilicon-1##10 9.772
R1336 S3#11pin@402_polysilicon-1##10 S3#11pin@402_polysilicon-1##11 9.772
R1337 S3#11pin@402_polysilicon-1##11 S3#11pin@402_polysilicon-1##12 9.772
R1338 S3#11pin@402_polysilicon-1##12 S3#11pin@402_polysilicon-1##13 9.772
R1339 S3#11pin@402_polysilicon-1##13 S3#11pin@402_polysilicon-1##14 9.772
R1340 S3#11pin@402_polysilicon-1##14 S3#11pin@402_polysilicon-1##15 9.772
R1341 S3#11pin@402_polysilicon-1##15 S3#11pin@402_polysilicon-1##16 9.772
R1342 S3#11pin@402_polysilicon-1##16 S3#11pin@402_polysilicon-1##17 9.772
R1343 S3#11pin@402_polysilicon-1##17 S3#11pin@402_polysilicon-1##18 9.772
R1344 S3#11pin@402_polysilicon-1##18 S3#11pin@402_polysilicon-1##19 9.772
R1345 S3#11pin@402_polysilicon-1##19 S3#11pin@402_polysilicon-1##20 9.772
R1346 S3#11pin@402_polysilicon-1##20 S3#11pin@402_polysilicon-1##21 9.772
R1347 S3#11pin@402_polysilicon-1##21 S3#1pin@403_polysilicon-1 9.772
R1348 S3 S3##0 8.267
R1349 S3##0 S3##1 8.267
R1350 S3##1 S3#3pin@393_polysilicon-1 8.267
R1351 net@1014#9pmos@44_poly-left net@1014#10pin@404_polysilicon-1 7.75
R1352 net@1014#10pin@404_polysilicon-1 net@1014#10pin@404_polysilicon-1##0 9.042
R1353 net@1014#10pin@404_polysilicon-1##0 net@1014#10pin@404_polysilicon-1##1 9.042
R1354 net@1014#10pin@404_polysilicon-1##1 net@1014#10pin@404_polysilicon-1##2 9.042
R1355 net@1014#10pin@404_polysilicon-1##2 net@1014#10pin@404_polysilicon-1##3 9.042
R1356 net@1014#10pin@404_polysilicon-1##3 net@1014#10pin@404_polysilicon-1##4 9.042
R1357 net@1014#10pin@404_polysilicon-1##4 net@1014#11pin@405_polysilicon-1 9.042
R1358 net@1014#11pin@405_polysilicon-1 net@1014#11pin@405_polysilicon-1##0 9.3
R1359 net@1014#11pin@405_polysilicon-1##0 net@1014#11pin@405_polysilicon-1##1 9.3
R1360 net@1014#11pin@405_polysilicon-1##1 net@1014#11pin@405_polysilicon-1##2 9.3
R1361 net@1014#11pin@405_polysilicon-1##2 net@1014#11pin@405_polysilicon-1##3 9.3
R1362 net@1014#11pin@405_polysilicon-1##3 net@1014#11pin@405_polysilicon-1##4 9.3
R1363 net@1014#11pin@405_polysilicon-1##4 net@1014#11pin@405_polysilicon-1##5 9.3
R1364 net@1014#11pin@405_polysilicon-1##5 net@1014#11pin@405_polysilicon-1##6 9.3
R1365 net@1014#11pin@405_polysilicon-1##6 net@1014#4pin@406_polysilicon-1 9.3

* Spice Code nodes in cell cell 'MUX_16_1:MUX_16_1_TG{lay}'
VDD VDD 0 DC 3.3
VGND GND 0 DC 0
Vin0 S3 0 PULSE  3.3 0 0 1u 1u 400u 800u
Vin1 S2 0 PULSE  3.3 0 0 1u 1u 800u 1600u
Vin2 S1 0 PULSE  3.3 0 0 1u 1u 1600u 3200u
Vin3 S0 0 PULSE  3.3 0 0 1u 1u 3200u 6400u
Vin4  I0  0 pulse 0 3.3 0u   1u 1u 100u 6400u
Vin5  I1  0 pulse 0 3.3 400u 1u 1u 100u 6400u
Vin6  I2  0 pulse 0 3.3 800u 1u 1u 100u 6400u
Vin7  I3  0 pulse 0 3.3 1200u 1u 1u 100u 6400u
Vin8  I4  0 pulse 0 3.3 1600u 1u 1u 100u 6400u
Vin9  I5  0 pulse 0 3.3 2000u 1u 1u 100u 6400u
Vin10 I6  0 pulse 0 3.3 2400u 1u 1u 100u 6400u
Vin11 I7  0 pulse 0 3.3 2800u 1u 1u 100u 6400u
Vin12 I8  0 pulse 0 3.3 3200u   1u 1u 100u 6400u
Vin13 I9  0 pulse 0 3.3 3600u 1u 1u 100u 6400u
Vin14 I10  0 pulse 0 3.3 4000u 1u 1u 100u 6400u
Vin15 I11  0 pulse 0 3.3 4400u 1u 1u 100u 6400u
Vin16 I12  0 pulse 0 3.3 4800u 1u 1u 100u 6400u
Vin17 I13 0 pulse 0 3.3 5200u 1u 1u 100u 6400u
Vin18 I14  0 pulse 0 3.3 5600u 1u 1u 100u 6400u
Vin19 I15  0 pulse 0 3.3 6000u 1u 1u 100u 6400u
cload out 0 250fF
.TRAN 0 6400u
.include C:\Electric\C5_models.txt
.END
