*** SPICE deck for cell MUX_16_1_TG_2{lay} from library MUX_16_1
*** Created on Sun May 10, 2020 23:48:47
*** Last revised on Wed May 13, 2020 21:25:33
*** Written on Wed May 13, 2020 21:35:46 by Electric VLSI Design System, version 9.07
*** Layout tech: mocmos, foundry MOSIS
*** UC SPICE *** , MIN_RESIST 4.0, MIN_CAPAC 0.1FF
***    P-Active:	areacap=0.9FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    N-Active:	areacap=0.9FF/um^2,	edgecap=0.0FF/um,	res=3.0ohms/sq
***    Polysilicon-1:	areacap=0.1467FF/um^2,	edgecap=0.0608FF/um,	res=6.2ohms/sq
***    Polysilicon-2:	areacap=1.0FF/um^2,	edgecap=0.0FF/um,	res=50.0ohms/sq
***    Transistor-Poly:	areacap=0.09FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    Poly-Cut:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=2.2ohms/sq
***    Active-Cut:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    Metal-1:	areacap=0.1209FF/um^2,	edgecap=0.1104FF/um,	res=0.078ohms/sq
***    Via1:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=1.0ohms/sq
***    Metal-2:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via2:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.9ohms/sq
***    Metal-3:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via3:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-4:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via4:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-5:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via5:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-6:	areacap=0.0423FF/um^2,	edgecap=0.1273FF/um,	res=0.036ohms/sq
***    Hi-Res:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=1.0ohms/sq

*** TOP LEVEL CELL: MUX_16_1_TG_2{lay}
Mnmos@0 net@25 net@26#7nmos@0_poly-right I4 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@1 net@26 S1#49nmos@1_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@2 net@25 S1#6nmos@2_poly-left I6 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@3 net@43 net@27#11nmos@3_poly-right I5 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@4 net@27#4contact@26_metal-1-n-act S1#13nmos@4_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@5 net@43 S1#52nmos@5_poly-left I7 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@6 net@39 net@122#8nmos@6_poly-right net@25 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@7 net@122 S2#8nmos@7_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@8 net@39 S2#25nmos@8_poly-left net@43 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@9 net@129 net@130#7nmos@9_poly-right I0 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@10 net@130 S1#40nmos@10_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@11 net@129 S1#26nmos@11_poly-left I2 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@12 net@148 net@131#11nmos@12_poly-right I1 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@13 net@131#4contact@95_metal-1-n-act S1#33nmos@13_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@14 net@148 S1#43nmos@14_poly-left I3 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@15 net@224 net@235#8nmos@15_poly-right net@129 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@16 net@235 S2#6nmos@16_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@17 net@224 S2#18nmos@17_poly-left net@148 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@18 net@374 net@375#6nmos@18_poly-right net@224 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@19 net@375 S0#2nmos@19_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@20 net@374 S0#10nmos@20_poly-left net@39 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@21 net@525 net@556#8nmos@21_poly-right I12 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@22 net@556 S1#92nmos@22_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@23 net@525 S1#104nmos@23_poly-left I13 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@24 net@516 net@517#5nmos@24_poly-right I14 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@25 net@517 S1#108nmos@25_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@26 net@516 S1#96nmos@26_poly-left I15 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@27 net@526 net@514#8nmos@27_poly-right net@525 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@28 net@514 S2#33nmos@28_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@29 net@526 S2#53nmos@29_poly-left net@516 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@30 net@521 net@522#7nmos@30_poly-right I8 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@31 net@522 S1#76nmos@31_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@32 net@521 S1#62nmos@32_poly-left I10 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@33 net@540 net@523#11nmos@33_poly-right I9 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@34 net@523#4contact@277_metal-1-n-act S1#69nmos@34_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@35 net@540 S1#79nmos@35_poly-left I11 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@36 net@616 net@627#8nmos@36_poly-right net@521 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@37 net@627 S2#31nmos@37_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@38 net@616 S2#43nmos@38_poly-left net@540 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@39 net@779 net@780#6nmos@39_poly-right net@616 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@40 net@780 S0#18nmos@40_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@41 net@779 S0#26nmos@41_poly-left net@526 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@42 out net@1031#6nmos@42_poly-right net@374 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@43 net@1031 S3#2nmos@43_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@44 out S3#10nmos@44_poly-left net@779 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@0 I4 S1#50pmos@0_poly-left net@25 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@1 vdd S1#55pmos@1_poly-right net@26 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=56.107P PS=5.425U PD=78.832U
Mpmos@2 I6 net@26#8pmos@2_poly-left net@25 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@3 I5 S1#15pmos@3_poly-left net@43 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@4 vdd S1#19pmos@4_poly-right net@27#4contact@26_metal-1-n-act vdd PMOS L=0.35U W=1.75U AS=1.684P AD=56.107P PS=5.425U PD=78.832U
Mpmos@5 I7 net@27 net@43 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@6 net@25 S2#16pmos@6_poly-left net@39 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@7 vdd S2#22pmos@7_poly-right net@122 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=56.107P PS=5.425U PD=78.832U
Mpmos@8 net@43 net@122#9pmos@8_poly-left net@39 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@9 I0 S1#41pmos@9_poly-left net@129 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@10 vdd S1#46pmos@10_poly-right net@130 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=56.107P PS=5.425U PD=78.832U
Mpmos@11 I2 net@130#8pmos@11_poly-left net@129 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@12 I1 S1#35pmos@12_poly-left net@148 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@13 vdd S1#39pmos@13_poly-right net@131#4contact@95_metal-1-n-act vdd PMOS L=0.35U W=1.75U AS=1.684P AD=56.107P PS=5.425U PD=78.832U
Mpmos@14 I3 net@131 net@148 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@15 net@129 S2#10pmos@15_poly-left net@224 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@16 vdd S2#14pmos@16_poly-right net@235 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=56.107P PS=5.425U PD=78.832U
Mpmos@17 net@148 net@235#9pmos@17_poly-left net@224 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@18 net@224 S0#4pmos@18_poly-left net@374 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@19 vdd S0#8pmos@19_poly-right net@375 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=56.107P PS=5.425U PD=78.832U
Mpmos@20 net@39 net@375#9pmos@20_poly-left net@374 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@21 I12 S1#94pmos@21_poly-left net@525 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@22 vdd S1#101pmos@22_poly-right net@556 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=56.107P PS=5.425U PD=78.832U
Mpmos@23 I13 net@556#9pmos@23_poly-left net@525 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@24 I14 S1#109pmos@24_poly-left net@516 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@25 vdd S1#112pmos@25_poly-right net@517 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=56.107P PS=5.425U PD=78.832U
Mpmos@26 I15 net@517#2pmos@26_poly-left net@516 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@27 net@525 S2#41pmos@27_poly-left net@526 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@28 vdd S2#49pmos@28_poly-right net@514 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=56.107P PS=5.425U PD=78.832U
Mpmos@29 net@516 net@514#9pmos@29_poly-left net@526 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@30 I8 S1#77pmos@30_poly-left net@521 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@31 vdd S1#82pmos@31_poly-right net@522 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=56.107P PS=5.425U PD=78.832U
Mpmos@32 I10 net@522#8pmos@32_poly-left net@521 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@33 I9 S1#71pmos@33_poly-left net@540 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@34 vdd S1#75pmos@34_poly-right net@523#4contact@277_metal-1-n-act vdd PMOS L=0.35U W=1.75U AS=1.684P AD=56.107P PS=5.425U PD=78.832U
Mpmos@35 I11 net@523 net@540 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@36 net@521 S2#35pmos@36_poly-left net@616 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@37 vdd S2#39pmos@37_poly-right net@627 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=56.107P PS=5.425U PD=78.832U
Mpmos@38 net@540 net@627#9pmos@38_poly-left net@616 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@39 net@616 S0#20pmos@39_poly-left net@779 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@40 vdd S0#24pmos@40_poly-right net@780 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=56.107P PS=5.425U PD=78.832U
Mpmos@41 net@526 net@780#9pmos@41_poly-left net@779 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@42 net@374 S3#4pmos@42_poly-left out vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@43 vdd S3#8pmos@43_poly-right net@1031 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=56.107P PS=5.425U PD=78.832U
Mpmos@44 net@779 net@1031#9pmos@44_poly-left out vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
** Extracted Parasitic Capacitors ***
C0 I4 0 4.78fF
C1 net@25 0 16.814fF
C2 net@26 0 1.643fF
C3 S1 0 29.405fF
C4 I6 0 5.909fF
C5 I5 0 4.78fF
C6 net@43 0 13.451fF
C7 net@27#4contact@26_metal-1-n-act 0 1.643fF
C8 I7 0 5.909fF
C9 net@39 0 25.138fF
C10 net@122 0 1.643fF
C11 S2 0 16.948fF
C12 I0 0 12.603fF
C13 net@129 0 16.814fF
C14 net@130 0 1.643fF
C15 I2 0 13.799fF
C16 I1 0 12.638fF
C17 net@148 0 13.451fF
C18 net@131#4contact@95_metal-1-n-act 0 1.643fF
C19 I3 0 13.795fF
C20 net@224 0 12.136fF
C21 net@235 0 1.643fF
C22 net@374 0 20.707fF
C23 net@375 0 1.643fF
C24 S0#0pin@187_polysilicon-1 0 12.022fF
C25 S0 0 30.864fF
C26 I12 0 4.78fF
C27 net@525 0 16.814fF
C28 net@556 0 1.643fF
C29 S1#56contact@262_metal-1-metal-2 0 30.334fF
C30 I13 0 5.909fF
C31 I14 0 4.78fF
C32 net@516 0 13.451fF
C33 net@517 0 1.643fF
C34 I15 0 5.909fF
C35 net@526 0 25.138fF
C36 net@514 0 1.643fF
C37 S2#27pin@263_polysilicon-1 0 17.075fF
C38 I8 0 12.603fF
C39 net@521 0 16.814fF
C40 net@522 0 1.643fF
C41 I10 0 13.799fF
C42 I9 0 12.638fF
C43 net@540 0 13.451fF
C44 net@523#4contact@277_metal-1-n-act 0 1.643fF
C45 I11 0 13.795fF
C46 net@616 0 12.136fF
C47 net@627 0 1.643fF
C48 net@779 0 14.344fF
C49 net@780 0 1.643fF
C50 S0#16pin@376_polysilicon-1 0 12.022fF
C51 out 0 5.7fF
C52 net@1031 0 1.643fF
C53 S3 0 2.537fF
C54 S1#9pin@23_polysilicon-1 0 0.149fF
C55 S1#51pin@26_polysilicon-1 0 0.13fF
C56 S1#54pin@27_polysilicon-1 0 0.171fF
C57 S1#7pin@32_polysilicon-1 0 0.137fF
C58 S1#8pin@33_polysilicon-1 0 0.177fF
C59 net@26#9pin@34_polysilicon-1 0 0.113fF
C60 net@26#10pin@35_polysilicon-1 0 0.156fF
C61 net@26#3pin@36_polysilicon-1 0 0.149fF
C62 net@26#4pin@38_polysilicon-1 0 0.184fF
C63 S1#14pin@46_polysilicon-1 0 0.149fF
C64 S1#16pin@49_polysilicon-1 0 0.13fF
C65 S1#17pin@50_polysilicon-1 0 0.171fF
C66 S1#53pin@55_polysilicon-1 0 0.137fF
C67 S1#11pin@56_polysilicon-1 0 0.177fF
C68 net@27#1pin@57_polysilicon-1 0 0.113fF
C69 net@27#2pin@58_polysilicon-1 0 0.156fF
C70 net@27#3pin@59_polysilicon-1 0 0.149fF
C71 net@27#6pin@61_polysilicon-1 0 0.184fF
C72 S2#9pin@69_polysilicon-1 0 0.149fF
C73 S2#17pin@72_polysilicon-1 0 0.13fF
C74 S2#20pin@73_polysilicon-1 0 0.171fF
C75 S2#26pin@77_polysilicon-1 0 0.137fF
C76 S2#3pin@78_polysilicon-1 0 0.177fF
C77 net@122#10pin@79_polysilicon-1 0 0.113fF
C78 net@122#11pin@80_polysilicon-1 0 0.156fF
C79 net@122#6pin@81_polysilicon-1 0 0.149fF
C80 net@122#2pin@83_polysilicon-1 0 0.184fF
C81 S1#29pin@98_polysilicon-1 0 0.149fF
C82 S1#42pin@101_polysilicon-1 0 0.13fF
C83 S1#45pin@102_polysilicon-1 0 0.171fF
C84 S1#27pin@107_polysilicon-1 0 0.137fF
C85 S1#28pin@108_polysilicon-1 0 0.177fF
C86 net@130#9pin@109_polysilicon-1 0 0.113fF
C87 net@130#10pin@110_polysilicon-1 0 0.156fF
C88 net@130#3pin@111_polysilicon-1 0 0.149fF
C89 net@130#4pin@113_polysilicon-1 0 0.184fF
C90 S1#34pin@121_polysilicon-1 0 0.149fF
C91 S1#36pin@124_polysilicon-1 0 0.13fF
C92 S1#37pin@125_polysilicon-1 0 0.171fF
C93 S1#44pin@130_polysilicon-1 0 0.137fF
C94 S1#31pin@131_polysilicon-1 0 0.177fF
C95 net@131#1pin@132_polysilicon-1 0 0.113fF
C96 net@131#2pin@133_polysilicon-1 0 0.156fF
C97 net@131#3pin@134_polysilicon-1 0 0.149fF
C98 net@131#6pin@136_polysilicon-1 0 0.184fF
C99 S2#7pin@144_polysilicon-1 0 0.149fF
C100 S2#11pin@147_polysilicon-1 0 0.13fF
C101 S2#12pin@148_polysilicon-1 0 0.171fF
C102 S2#19pin@152_polysilicon-1 0 0.137fF
C103 S2#5pin@153_polysilicon-1 0 0.177fF
C104 net@235#10pin@154_polysilicon-1 0 0.113fF
C105 net@235#11pin@155_polysilicon-1 0 0.156fF
C106 net@235#6pin@156_polysilicon-1 0 0.149fF
C107 net@235#2pin@158_polysilicon-1 0 0.184fF
C108 S0#3pin@182_polysilicon-1 0 0.149fF
C109 S0#5pin@185_polysilicon-1 0 0.13fF
C110 S0#6pin@186_polysilicon-1 0 0.171fF
C111 S0#11pin@191_polysilicon-1 0 0.137fF
C112 S0#1pin@192_polysilicon-1 0 0.177fF
C113 net@375#10pin@193_polysilicon-1 0 0.113fF
C114 net@375#11pin@194_polysilicon-1 0 0.156fF
C115 net@375#4pin@195_polysilicon-1 0 0.149fF
C116 net@375#5pin@197_polysilicon-1 0 0.184fF
C117 S1#93pin@212_polysilicon-1 0 0.149fF
C118 S1#95pin@215_polysilicon-1 0 0.13fF
C119 S1#98pin@216_polysilicon-1 0 0.171fF
C120 S1#105pin@221_polysilicon-1 0 0.137fF
C121 S1#106pin@222_polysilicon-1 0 0.177fF
C122 net@556#10pin@223_polysilicon-1 0 0.113fF
C123 net@556#11pin@224_polysilicon-1 0 0.156fF
C124 net@556#5pin@225_polysilicon-1 0 0.149fF
C125 net@556#6pin@227_polysilicon-1 0 0.184fF
C126 S1#103pin@235_polysilicon-1 0 0.149fF
C127 S1#110pin@238_polysilicon-1 0 0.13fF
C128 S1#111pin@239_polysilicon-1 0 0.171fF
C129 S1#97pin@244_polysilicon-1 0 0.137fF
C130 S1#100pin@245_polysilicon-1 0 0.177fF
C131 net@517#3pin@246_polysilicon-1 0 0.113fF
C132 net@517#4pin@247_polysilicon-1 0 0.156fF
C133 net@517#7pin@248_polysilicon-1 0 0.149fF
C134 net@517#6pin@250_polysilicon-1 0 0.184fF
C135 S2#34pin@258_polysilicon-1 0 0.149fF
C136 S2#42pin@261_polysilicon-1 0 0.13fF
C137 S2#45pin@262_polysilicon-1 0 0.171fF
C138 S2#54pin@266_polysilicon-1 0 0.137fF
C139 S2#28pin@267_polysilicon-1 0 0.177fF
C140 net@514#10pin@268_polysilicon-1 0 0.113fF
C141 net@514#11pin@269_polysilicon-1 0 0.156fF
C142 net@514#6pin@270_polysilicon-1 0 0.149fF
C143 net@514#2pin@272_polysilicon-1 0 0.184fF
C144 S1#65pin@287_polysilicon-1 0 0.149fF
C145 S1#78pin@290_polysilicon-1 0 0.13fF
C146 S1#81pin@291_polysilicon-1 0 0.171fF
C147 S1#63pin@296_polysilicon-1 0 0.137fF
C148 S1#64pin@297_polysilicon-1 0 0.177fF
C149 net@522#9pin@298_polysilicon-1 0 0.113fF
C150 net@522#10pin@299_polysilicon-1 0 0.156fF
C151 net@522#3pin@300_polysilicon-1 0 0.149fF
C152 net@522#4pin@302_polysilicon-1 0 0.184fF
C153 S1#70pin@310_polysilicon-1 0 0.149fF
C154 S1#72pin@313_polysilicon-1 0 0.13fF
C155 S1#73pin@314_polysilicon-1 0 0.171fF
C156 S1#80pin@319_polysilicon-1 0 0.137fF
C157 S1#67pin@320_polysilicon-1 0 0.177fF
C158 net@523#1pin@321_polysilicon-1 0 0.113fF
C159 net@523#2pin@322_polysilicon-1 0 0.156fF
C160 net@523#3pin@323_polysilicon-1 0 0.149fF
C161 net@523#6pin@325_polysilicon-1 0 0.184fF
C162 S2#32pin@333_polysilicon-1 0 0.149fF
C163 S2#36pin@336_polysilicon-1 0 0.13fF
C164 S2#37pin@337_polysilicon-1 0 0.171fF
C165 S2#44pin@341_polysilicon-1 0 0.137fF
C166 S2#30pin@342_polysilicon-1 0 0.177fF
C167 net@627#10pin@343_polysilicon-1 0 0.113fF
C168 net@627#11pin@344_polysilicon-1 0 0.156fF
C169 net@627#6pin@345_polysilicon-1 0 0.149fF
C170 net@627#2pin@347_polysilicon-1 0 0.184fF
C171 S0#19pin@371_polysilicon-1 0 0.149fF
C172 S0#21pin@374_polysilicon-1 0 0.13fF
C173 S0#22pin@375_polysilicon-1 0 0.171fF
C174 S0#27pin@380_polysilicon-1 0 0.137fF
C175 S0#17pin@381_polysilicon-1 0 0.177fF
C176 net@780#10pin@382_polysilicon-1 0 0.113fF
C177 net@780#11pin@383_polysilicon-1 0 0.156fF
C178 net@780#4pin@384_polysilicon-1 0 0.149fF
C179 net@780#5pin@386_polysilicon-1 0 0.184fF
C180 S3#3pin@415_polysilicon-1 0 0.149fF
C181 S3#5pin@418_polysilicon-1 0 0.13fF
C182 S3#6pin@419_polysilicon-1 0 0.171fF
C183 S3#11pin@424_polysilicon-1 0 0.137fF
C184 S3#1pin@425_polysilicon-1 0 0.177fF
C185 net@1031#10pin@426_polysilicon-1 0 0.113fF
C186 net@1031#11pin@427_polysilicon-1 0 0.156fF
C187 net@1031#4pin@428_polysilicon-1 0 0.149fF
C188 net@1031#5pin@430_polysilicon-1 0 0.184fF
** Extracted Parasitic Resistors ***
R0 net@27 net@27#1pin@57_polysilicon-1 7.75
R1 net@27#1pin@57_polysilicon-1 net@27#1pin@57_polysilicon-1##0 9.042
R2 net@27#1pin@57_polysilicon-1##0 net@27#1pin@57_polysilicon-1##1 9.042
R3 net@27#1pin@57_polysilicon-1##1 net@27#1pin@57_polysilicon-1##2 9.042
R4 net@27#1pin@57_polysilicon-1##2 net@27#1pin@57_polysilicon-1##3 9.042
R5 net@27#1pin@57_polysilicon-1##3 net@27#1pin@57_polysilicon-1##4 9.042
R6 net@27#1pin@57_polysilicon-1##4 net@27#2pin@58_polysilicon-1 9.042
R7 net@27#2pin@58_polysilicon-1 net@27#2pin@58_polysilicon-1##0 9.3
R8 net@27#2pin@58_polysilicon-1##0 net@27#2pin@58_polysilicon-1##1 9.3
R9 net@27#2pin@58_polysilicon-1##1 net@27#2pin@58_polysilicon-1##2 9.3
R10 net@27#2pin@58_polysilicon-1##2 net@27#2pin@58_polysilicon-1##3 9.3
R11 net@27#2pin@58_polysilicon-1##3 net@27#2pin@58_polysilicon-1##4 9.3
R12 net@27#2pin@58_polysilicon-1##4 net@27#2pin@58_polysilicon-1##5 9.3
R13 net@27#2pin@58_polysilicon-1##5 net@27#2pin@58_polysilicon-1##6 9.3
R14 net@27#2pin@58_polysilicon-1##6 net@27#3pin@59_polysilicon-1 9.3
R15 net@26#3pin@36_polysilicon-1 net@26#3pin@36_polysilicon-1##0 8.37
R16 net@26#3pin@36_polysilicon-1##0 net@26#3pin@36_polysilicon-1##1 8.37
R17 net@26#3pin@36_polysilicon-1##1 net@26#3pin@36_polysilicon-1##2 8.37
R18 net@26#3pin@36_polysilicon-1##2 net@26#3pin@36_polysilicon-1##3 8.37
R19 net@26#3pin@36_polysilicon-1##3 net@26#4pin@38_polysilicon-1 8.37
R20 net@26#7nmos@0_poly-right net@26#7nmos@0_poly-right##0 6.2
R21 net@26#7nmos@0_poly-right##0 net@26#4pin@38_polysilicon-1 6.2
R22 S1#6nmos@2_poly-left S1#6nmos@2_poly-left##0 6.975
R23 S1#6nmos@2_poly-left##0 S1#7pin@32_polysilicon-1 6.975
R24 S1#7pin@32_polysilicon-1 S1#7pin@32_polysilicon-1##0 9.772
R25 S1#7pin@32_polysilicon-1##0 S1#7pin@32_polysilicon-1##1 9.772
R26 S1#7pin@32_polysilicon-1##1 S1#7pin@32_polysilicon-1##2 9.772
R27 S1#7pin@32_polysilicon-1##2 S1#7pin@32_polysilicon-1##3 9.772
R28 S1#7pin@32_polysilicon-1##3 S1#7pin@32_polysilicon-1##4 9.772
R29 S1#7pin@32_polysilicon-1##4 S1#7pin@32_polysilicon-1##5 9.772
R30 S1#7pin@32_polysilicon-1##5 S1#7pin@32_polysilicon-1##6 9.772
R31 S1#7pin@32_polysilicon-1##6 S1#7pin@32_polysilicon-1##7 9.772
R32 S1#7pin@32_polysilicon-1##7 S1#7pin@32_polysilicon-1##8 9.772
R33 S1#7pin@32_polysilicon-1##8 S1#7pin@32_polysilicon-1##9 9.772
R34 S1#7pin@32_polysilicon-1##9 S1#7pin@32_polysilicon-1##10 9.772
R35 S1#7pin@32_polysilicon-1##10 S1#7pin@32_polysilicon-1##11 9.772
R36 S1#7pin@32_polysilicon-1##11 S1#7pin@32_polysilicon-1##12 9.772
R37 S1#7pin@32_polysilicon-1##12 S1#7pin@32_polysilicon-1##13 9.772
R38 S1#7pin@32_polysilicon-1##13 S1#7pin@32_polysilicon-1##14 9.772
R39 S1#7pin@32_polysilicon-1##14 S1#7pin@32_polysilicon-1##15 9.772
R40 S1#7pin@32_polysilicon-1##15 S1#7pin@32_polysilicon-1##16 9.772
R41 S1#7pin@32_polysilicon-1##16 S1#7pin@32_polysilicon-1##17 9.772
R42 S1#7pin@32_polysilicon-1##17 S1#7pin@32_polysilicon-1##18 9.772
R43 S1#7pin@32_polysilicon-1##18 S1#7pin@32_polysilicon-1##19 9.772
R44 S1#7pin@32_polysilicon-1##19 S1#7pin@32_polysilicon-1##20 9.772
R45 S1#7pin@32_polysilicon-1##20 S1#7pin@32_polysilicon-1##21 9.772
R46 S1#7pin@32_polysilicon-1##21 S1#8pin@33_polysilicon-1 9.772
R47 S1 S1##0 8.267
R48 S1##0 S1##1 8.267
R49 S1##1 S1#9pin@23_polysilicon-1 8.267
R50 net@26#8pmos@2_poly-left net@26#9pin@34_polysilicon-1 7.75
R51 net@26#9pin@34_polysilicon-1 net@26#9pin@34_polysilicon-1##0 9.042
R52 net@26#9pin@34_polysilicon-1##0 net@26#9pin@34_polysilicon-1##1 9.042
R53 net@26#9pin@34_polysilicon-1##1 net@26#9pin@34_polysilicon-1##2 9.042
R54 net@26#9pin@34_polysilicon-1##2 net@26#9pin@34_polysilicon-1##3 9.042
R55 net@26#9pin@34_polysilicon-1##3 net@26#9pin@34_polysilicon-1##4 9.042
R56 net@26#9pin@34_polysilicon-1##4 net@26#10pin@35_polysilicon-1 9.042
R57 net@26#10pin@35_polysilicon-1 net@26#10pin@35_polysilicon-1##0 9.3
R58 net@26#10pin@35_polysilicon-1##0 net@26#10pin@35_polysilicon-1##1 9.3
R59 net@26#10pin@35_polysilicon-1##1 net@26#10pin@35_polysilicon-1##2 9.3
R60 net@26#10pin@35_polysilicon-1##2 net@26#10pin@35_polysilicon-1##3 9.3
R61 net@26#10pin@35_polysilicon-1##3 net@26#10pin@35_polysilicon-1##4 9.3
R62 net@26#10pin@35_polysilicon-1##4 net@26#10pin@35_polysilicon-1##5 9.3
R63 net@26#10pin@35_polysilicon-1##5 net@26#10pin@35_polysilicon-1##6 9.3
R64 net@26#10pin@35_polysilicon-1##6 net@26#3pin@36_polysilicon-1 9.3
R65 S1 S1##0 9.881
R66 S1##0 S1##1 9.881
R67 S1##1 S1##2 9.881
R68 S1##2 S1##3 9.881
R69 S1##3 S1##4 9.881
R70 S1##4 S1##5 9.881
R71 S1##5 S1##6 9.881
R72 S1##6 S1#11pin@56_polysilicon-1 9.881
R73 net@27#6pin@61_polysilicon-1 net@27#6pin@61_polysilicon-1##0 9.042
R74 net@27#6pin@61_polysilicon-1##0 net@27#6pin@61_polysilicon-1##1 9.042
R75 net@27#6pin@61_polysilicon-1##1 net@27#6pin@61_polysilicon-1##2 9.042
R76 net@27#6pin@61_polysilicon-1##2 net@27#6pin@61_polysilicon-1##3 9.042
R77 net@27#6pin@61_polysilicon-1##3 net@27#6pin@61_polysilicon-1##4 9.042
R78 net@27#6pin@61_polysilicon-1##4 net@27#4contact@26_metal-1-n-act 9.042
R79 S1 S1##0 9.881
R80 S1##0 S1##1 9.881
R81 S1##1 S1##2 9.881
R82 S1##2 S1##3 9.881
R83 S1##3 S1##4 9.881
R84 S1##4 S1##5 9.881
R85 S1##5 S1##6 9.881
R86 S1##6 S1#8pin@33_polysilicon-1 9.881
R87 S1#13nmos@4_poly-right S1#13nmos@4_poly-right##0 7.233
R88 S1#13nmos@4_poly-right##0 S1#13nmos@4_poly-right##1 7.233
R89 S1#13nmos@4_poly-right##1 S1#14pin@46_polysilicon-1 7.233
R90 S1#15pmos@3_poly-left S1#15pmos@3_poly-left##0 6.2
R91 S1#15pmos@3_poly-left##0 S1#16pin@49_polysilicon-1 6.2
R92 S1#16pin@49_polysilicon-1 S1#16pin@49_polysilicon-1##0 9.896
R93 S1#16pin@49_polysilicon-1##0 S1#16pin@49_polysilicon-1##1 9.896
R94 S1#16pin@49_polysilicon-1##1 S1#16pin@49_polysilicon-1##2 9.896
R95 S1#16pin@49_polysilicon-1##2 S1#16pin@49_polysilicon-1##3 9.896
R96 S1#16pin@49_polysilicon-1##3 S1#16pin@49_polysilicon-1##4 9.896
R97 S1#16pin@49_polysilicon-1##4 S1#16pin@49_polysilicon-1##5 9.896
R98 S1#16pin@49_polysilicon-1##5 S1#16pin@49_polysilicon-1##6 9.896
R99 S1#16pin@49_polysilicon-1##6 S1#16pin@49_polysilicon-1##7 9.896
R100 S1#16pin@49_polysilicon-1##7 S1#16pin@49_polysilicon-1##8 9.896
R101 S1#16pin@49_polysilicon-1##8 S1#16pin@49_polysilicon-1##9 9.896
R102 S1#16pin@49_polysilicon-1##9 S1#16pin@49_polysilicon-1##10 9.896
R103 S1#16pin@49_polysilicon-1##10 S1#16pin@49_polysilicon-1##11 9.896
R104 S1#16pin@49_polysilicon-1##11 S1#17pin@50_polysilicon-1 9.896
R105 S1#17pin@50_polysilicon-1 S1#17pin@50_polysilicon-1##0 9.521
R106 S1#17pin@50_polysilicon-1##0 S1#17pin@50_polysilicon-1##1 9.521
R107 S1#17pin@50_polysilicon-1##1 S1#17pin@50_polysilicon-1##2 9.521
R108 S1#17pin@50_polysilicon-1##2 S1#17pin@50_polysilicon-1##3 9.521
R109 S1#17pin@50_polysilicon-1##3 S1#17pin@50_polysilicon-1##4 9.521
R110 S1#17pin@50_polysilicon-1##4 S1#17pin@50_polysilicon-1##5 9.521
R111 S1#17pin@50_polysilicon-1##5 S1 9.521
R112 S1#14pin@46_polysilicon-1 S1#14pin@46_polysilicon-1##0 5.425
R113 S1#14pin@46_polysilicon-1##0 S1#19pmos@4_poly-right 5.425
R114 net@26#4pin@38_polysilicon-1 net@26#4pin@38_polysilicon-1##0 9.042
R115 net@26#4pin@38_polysilicon-1##0 net@26#4pin@38_polysilicon-1##1 9.042
R116 net@26#4pin@38_polysilicon-1##1 net@26#4pin@38_polysilicon-1##2 9.042
R117 net@26#4pin@38_polysilicon-1##2 net@26#4pin@38_polysilicon-1##3 9.042
R118 net@26#4pin@38_polysilicon-1##3 net@26#4pin@38_polysilicon-1##4 9.042
R119 net@26#4pin@38_polysilicon-1##4 net@26 9.042
R120 net@27#3pin@59_polysilicon-1 net@27#3pin@59_polysilicon-1##0 8.37
R121 net@27#3pin@59_polysilicon-1##0 net@27#3pin@59_polysilicon-1##1 8.37
R122 net@27#3pin@59_polysilicon-1##1 net@27#3pin@59_polysilicon-1##2 8.37
R123 net@27#3pin@59_polysilicon-1##2 net@27#3pin@59_polysilicon-1##3 8.37
R124 net@27#3pin@59_polysilicon-1##3 net@27#6pin@61_polysilicon-1 8.37
R125 net@131 net@131#1pin@132_polysilicon-1 7.75
R126 net@131#1pin@132_polysilicon-1 net@131#1pin@132_polysilicon-1##0 9.042
R127 net@131#1pin@132_polysilicon-1##0 net@131#1pin@132_polysilicon-1##1 9.042
R128 net@131#1pin@132_polysilicon-1##1 net@131#1pin@132_polysilicon-1##2 9.042
R129 net@131#1pin@132_polysilicon-1##2 net@131#1pin@132_polysilicon-1##3 9.042
R130 net@131#1pin@132_polysilicon-1##3 net@131#1pin@132_polysilicon-1##4 9.042
R131 net@131#1pin@132_polysilicon-1##4 net@131#2pin@133_polysilicon-1 9.042
R132 net@131#2pin@133_polysilicon-1 net@131#2pin@133_polysilicon-1##0 9.3
R133 net@131#2pin@133_polysilicon-1##0 net@131#2pin@133_polysilicon-1##1 9.3
R134 net@131#2pin@133_polysilicon-1##1 net@131#2pin@133_polysilicon-1##2 9.3
R135 net@131#2pin@133_polysilicon-1##2 net@131#2pin@133_polysilicon-1##3 9.3
R136 net@131#2pin@133_polysilicon-1##3 net@131#2pin@133_polysilicon-1##4 9.3
R137 net@131#2pin@133_polysilicon-1##4 net@131#2pin@133_polysilicon-1##5 9.3
R138 net@131#2pin@133_polysilicon-1##5 net@131#2pin@133_polysilicon-1##6 9.3
R139 net@131#2pin@133_polysilicon-1##6 net@131#3pin@134_polysilicon-1 9.3
R140 net@130#3pin@111_polysilicon-1 net@130#3pin@111_polysilicon-1##0 8.37
R141 net@130#3pin@111_polysilicon-1##0 net@130#3pin@111_polysilicon-1##1 8.37
R142 net@130#3pin@111_polysilicon-1##1 net@130#3pin@111_polysilicon-1##2 8.37
R143 net@130#3pin@111_polysilicon-1##2 net@130#3pin@111_polysilicon-1##3 8.37
R144 net@130#3pin@111_polysilicon-1##3 net@130#4pin@113_polysilicon-1 8.37
R145 net@130#7nmos@9_poly-right net@130#7nmos@9_poly-right##0 6.2
R146 net@130#7nmos@9_poly-right##0 net@130#4pin@113_polysilicon-1 6.2
R147 S2 S2##0 9.881
R148 S2##0 S2##1 9.881
R149 S2##1 S2##2 9.881
R150 S2##2 S2##3 9.881
R151 S2##3 S2##4 9.881
R152 S2##4 S2##5 9.881
R153 S2##5 S2##6 9.881
R154 S2##6 S2#3pin@78_polysilicon-1 9.881
R155 S1#26nmos@11_poly-left S1#26nmos@11_poly-left##0 6.975
R156 S1#26nmos@11_poly-left##0 S1#27pin@107_polysilicon-1 6.975
R157 S1#27pin@107_polysilicon-1 S1#27pin@107_polysilicon-1##0 9.772
R158 S1#27pin@107_polysilicon-1##0 S1#27pin@107_polysilicon-1##1 9.772
R159 S1#27pin@107_polysilicon-1##1 S1#27pin@107_polysilicon-1##2 9.772
R160 S1#27pin@107_polysilicon-1##2 S1#27pin@107_polysilicon-1##3 9.772
R161 S1#27pin@107_polysilicon-1##3 S1#27pin@107_polysilicon-1##4 9.772
R162 S1#27pin@107_polysilicon-1##4 S1#27pin@107_polysilicon-1##5 9.772
R163 S1#27pin@107_polysilicon-1##5 S1#27pin@107_polysilicon-1##6 9.772
R164 S1#27pin@107_polysilicon-1##6 S1#27pin@107_polysilicon-1##7 9.772
R165 S1#27pin@107_polysilicon-1##7 S1#27pin@107_polysilicon-1##8 9.772
R166 S1#27pin@107_polysilicon-1##8 S1#27pin@107_polysilicon-1##9 9.772
R167 S1#27pin@107_polysilicon-1##9 S1#27pin@107_polysilicon-1##10 9.772
R168 S1#27pin@107_polysilicon-1##10 S1#27pin@107_polysilicon-1##11 9.772
R169 S1#27pin@107_polysilicon-1##11 S1#27pin@107_polysilicon-1##12 9.772
R170 S1#27pin@107_polysilicon-1##12 S1#27pin@107_polysilicon-1##13 9.772
R171 S1#27pin@107_polysilicon-1##13 S1#27pin@107_polysilicon-1##14 9.772
R172 S1#27pin@107_polysilicon-1##14 S1#27pin@107_polysilicon-1##15 9.772
R173 S1#27pin@107_polysilicon-1##15 S1#27pin@107_polysilicon-1##16 9.772
R174 S1#27pin@107_polysilicon-1##16 S1#27pin@107_polysilicon-1##17 9.772
R175 S1#27pin@107_polysilicon-1##17 S1#27pin@107_polysilicon-1##18 9.772
R176 S1#27pin@107_polysilicon-1##18 S1#27pin@107_polysilicon-1##19 9.772
R177 S1#27pin@107_polysilicon-1##19 S1#27pin@107_polysilicon-1##20 9.772
R178 S1#27pin@107_polysilicon-1##20 S1#27pin@107_polysilicon-1##21 9.772
R179 S1#27pin@107_polysilicon-1##21 S1#28pin@108_polysilicon-1 9.772
R180 S1 S1##0 8.267
R181 S1##0 S1##1 8.267
R182 S1##1 S1#29pin@98_polysilicon-1 8.267
R183 net@130#8pmos@11_poly-left net@130#9pin@109_polysilicon-1 7.75
R184 net@130#9pin@109_polysilicon-1 net@130#9pin@109_polysilicon-1##0 9.042
R185 net@130#9pin@109_polysilicon-1##0 net@130#9pin@109_polysilicon-1##1 9.042
R186 net@130#9pin@109_polysilicon-1##1 net@130#9pin@109_polysilicon-1##2 9.042
R187 net@130#9pin@109_polysilicon-1##2 net@130#9pin@109_polysilicon-1##3 9.042
R188 net@130#9pin@109_polysilicon-1##3 net@130#9pin@109_polysilicon-1##4 9.042
R189 net@130#9pin@109_polysilicon-1##4 net@130#10pin@110_polysilicon-1 9.042
R190 net@130#10pin@110_polysilicon-1 net@130#10pin@110_polysilicon-1##0 9.3
R191 net@130#10pin@110_polysilicon-1##0 net@130#10pin@110_polysilicon-1##1 9.3
R192 net@130#10pin@110_polysilicon-1##1 net@130#10pin@110_polysilicon-1##2 9.3
R193 net@130#10pin@110_polysilicon-1##2 net@130#10pin@110_polysilicon-1##3 9.3
R194 net@130#10pin@110_polysilicon-1##3 net@130#10pin@110_polysilicon-1##4 9.3
R195 net@130#10pin@110_polysilicon-1##4 net@130#10pin@110_polysilicon-1##5 9.3
R196 net@130#10pin@110_polysilicon-1##5 net@130#10pin@110_polysilicon-1##6 9.3
R197 net@130#10pin@110_polysilicon-1##6 net@130#3pin@111_polysilicon-1 9.3
R198 net@122#2pin@83_polysilicon-1 net@122#2pin@83_polysilicon-1##0 9.042
R199 net@122#2pin@83_polysilicon-1##0 net@122#2pin@83_polysilicon-1##1 9.042
R200 net@122#2pin@83_polysilicon-1##1 net@122#2pin@83_polysilicon-1##2 9.042
R201 net@122#2pin@83_polysilicon-1##2 net@122#2pin@83_polysilicon-1##3 9.042
R202 net@122#2pin@83_polysilicon-1##3 net@122#2pin@83_polysilicon-1##4 9.042
R203 net@122#2pin@83_polysilicon-1##4 net@122 9.042
R204 S1 S1##0 9.881
R205 S1##0 S1##1 9.881
R206 S1##1 S1##2 9.881
R207 S1##2 S1##3 9.881
R208 S1##3 S1##4 9.881
R209 S1##4 S1##5 9.881
R210 S1##5 S1##6 9.881
R211 S1##6 S1#31pin@131_polysilicon-1 9.881
R212 net@131#6pin@136_polysilicon-1 net@131#6pin@136_polysilicon-1##0 9.042
R213 net@131#6pin@136_polysilicon-1##0 net@131#6pin@136_polysilicon-1##1 9.042
R214 net@131#6pin@136_polysilicon-1##1 net@131#6pin@136_polysilicon-1##2 9.042
R215 net@131#6pin@136_polysilicon-1##2 net@131#6pin@136_polysilicon-1##3 9.042
R216 net@131#6pin@136_polysilicon-1##3 net@131#6pin@136_polysilicon-1##4 9.042
R217 net@131#6pin@136_polysilicon-1##4 net@131#4contact@95_metal-1-n-act 9.042
R218 S1 S1##0 9.881
R219 S1##0 S1##1 9.881
R220 S1##1 S1##2 9.881
R221 S1##2 S1##3 9.881
R222 S1##3 S1##4 9.881
R223 S1##4 S1##5 9.881
R224 S1##5 S1##6 9.881
R225 S1##6 S1#28pin@108_polysilicon-1 9.881
R226 S1#33nmos@13_poly-right S1#33nmos@13_poly-right##0 7.233
R227 S1#33nmos@13_poly-right##0 S1#33nmos@13_poly-right##1 7.233
R228 S1#33nmos@13_poly-right##1 S1#34pin@121_polysilicon-1 7.233
R229 S1#35pmos@12_poly-left S1#35pmos@12_poly-left##0 6.2
R230 S1#35pmos@12_poly-left##0 S1#36pin@124_polysilicon-1 6.2
R231 S1#36pin@124_polysilicon-1 S1#36pin@124_polysilicon-1##0 9.896
R232 S1#36pin@124_polysilicon-1##0 S1#36pin@124_polysilicon-1##1 9.896
R233 S1#36pin@124_polysilicon-1##1 S1#36pin@124_polysilicon-1##2 9.896
R234 S1#36pin@124_polysilicon-1##2 S1#36pin@124_polysilicon-1##3 9.896
R235 S1#36pin@124_polysilicon-1##3 S1#36pin@124_polysilicon-1##4 9.896
R236 S1#36pin@124_polysilicon-1##4 S1#36pin@124_polysilicon-1##5 9.896
R237 S1#36pin@124_polysilicon-1##5 S1#36pin@124_polysilicon-1##6 9.896
R238 S1#36pin@124_polysilicon-1##6 S1#36pin@124_polysilicon-1##7 9.896
R239 S1#36pin@124_polysilicon-1##7 S1#36pin@124_polysilicon-1##8 9.896
R240 S1#36pin@124_polysilicon-1##8 S1#36pin@124_polysilicon-1##9 9.896
R241 S1#36pin@124_polysilicon-1##9 S1#36pin@124_polysilicon-1##10 9.896
R242 S1#36pin@124_polysilicon-1##10 S1#36pin@124_polysilicon-1##11 9.896
R243 S1#36pin@124_polysilicon-1##11 S1#37pin@125_polysilicon-1 9.896
R244 S1#37pin@125_polysilicon-1 S1#37pin@125_polysilicon-1##0 9.521
R245 S1#37pin@125_polysilicon-1##0 S1#37pin@125_polysilicon-1##1 9.521
R246 S1#37pin@125_polysilicon-1##1 S1#37pin@125_polysilicon-1##2 9.521
R247 S1#37pin@125_polysilicon-1##2 S1#37pin@125_polysilicon-1##3 9.521
R248 S1#37pin@125_polysilicon-1##3 S1#37pin@125_polysilicon-1##4 9.521
R249 S1#37pin@125_polysilicon-1##4 S1#37pin@125_polysilicon-1##5 9.521
R250 S1#37pin@125_polysilicon-1##5 S1 9.521
R251 S1#34pin@121_polysilicon-1 S1#34pin@121_polysilicon-1##0 5.425
R252 S1#34pin@121_polysilicon-1##0 S1#39pmos@13_poly-right 5.425
R253 net@130#4pin@113_polysilicon-1 net@130#4pin@113_polysilicon-1##0 9.042
R254 net@130#4pin@113_polysilicon-1##0 net@130#4pin@113_polysilicon-1##1 9.042
R255 net@130#4pin@113_polysilicon-1##1 net@130#4pin@113_polysilicon-1##2 9.042
R256 net@130#4pin@113_polysilicon-1##2 net@130#4pin@113_polysilicon-1##3 9.042
R257 net@130#4pin@113_polysilicon-1##3 net@130#4pin@113_polysilicon-1##4 9.042
R258 net@130#4pin@113_polysilicon-1##4 net@130 9.042
R259 net@131#3pin@134_polysilicon-1 net@131#3pin@134_polysilicon-1##0 8.37
R260 net@131#3pin@134_polysilicon-1##0 net@131#3pin@134_polysilicon-1##1 8.37
R261 net@131#3pin@134_polysilicon-1##1 net@131#3pin@134_polysilicon-1##2 8.37
R262 net@131#3pin@134_polysilicon-1##2 net@131#3pin@134_polysilicon-1##3 8.37
R263 net@131#3pin@134_polysilicon-1##3 net@131#6pin@136_polysilicon-1 8.37
R264 S2 S2##0 9.881
R265 S2##0 S2##1 9.881
R266 S2##1 S2##2 9.881
R267 S2##2 S2##3 9.881
R268 S2##3 S2##4 9.881
R269 S2##4 S2##5 9.881
R270 S2##5 S2##6 9.881
R271 S2##6 S2#5pin@153_polysilicon-1 9.881
R272 net@235#2pin@158_polysilicon-1 net@235#2pin@158_polysilicon-1##0 9.042
R273 net@235#2pin@158_polysilicon-1##0 net@235#2pin@158_polysilicon-1##1 9.042
R274 net@235#2pin@158_polysilicon-1##1 net@235#2pin@158_polysilicon-1##2 9.042
R275 net@235#2pin@158_polysilicon-1##2 net@235#2pin@158_polysilicon-1##3 9.042
R276 net@235#2pin@158_polysilicon-1##3 net@235#2pin@158_polysilicon-1##4 9.042
R277 net@235#2pin@158_polysilicon-1##4 net@235 9.042
R278 S2#6nmos@16_poly-right S2#6nmos@16_poly-right##0 7.233
R279 S2#6nmos@16_poly-right##0 S2#6nmos@16_poly-right##1 7.233
R280 S2#6nmos@16_poly-right##1 S2#7pin@144_polysilicon-1 7.233
R281 S2#8nmos@7_poly-right S2#8nmos@7_poly-right##0 7.233
R282 S2#8nmos@7_poly-right##0 S2#8nmos@7_poly-right##1 7.233
R283 S2#8nmos@7_poly-right##1 S2#9pin@69_polysilicon-1 7.233
R284 S2#10pmos@15_poly-left S2#10pmos@15_poly-left##0 6.2
R285 S2#10pmos@15_poly-left##0 S2#11pin@147_polysilicon-1 6.2
R286 S2#11pin@147_polysilicon-1 S2#11pin@147_polysilicon-1##0 9.896
R287 S2#11pin@147_polysilicon-1##0 S2#11pin@147_polysilicon-1##1 9.896
R288 S2#11pin@147_polysilicon-1##1 S2#11pin@147_polysilicon-1##2 9.896
R289 S2#11pin@147_polysilicon-1##2 S2#11pin@147_polysilicon-1##3 9.896
R290 S2#11pin@147_polysilicon-1##3 S2#11pin@147_polysilicon-1##4 9.896
R291 S2#11pin@147_polysilicon-1##4 S2#11pin@147_polysilicon-1##5 9.896
R292 S2#11pin@147_polysilicon-1##5 S2#11pin@147_polysilicon-1##6 9.896
R293 S2#11pin@147_polysilicon-1##6 S2#11pin@147_polysilicon-1##7 9.896
R294 S2#11pin@147_polysilicon-1##7 S2#11pin@147_polysilicon-1##8 9.896
R295 S2#11pin@147_polysilicon-1##8 S2#11pin@147_polysilicon-1##9 9.896
R296 S2#11pin@147_polysilicon-1##9 S2#11pin@147_polysilicon-1##10 9.896
R297 S2#11pin@147_polysilicon-1##10 S2#11pin@147_polysilicon-1##11 9.896
R298 S2#11pin@147_polysilicon-1##11 S2#12pin@148_polysilicon-1 9.896
R299 S2#12pin@148_polysilicon-1 S2#12pin@148_polysilicon-1##0 9.521
R300 S2#12pin@148_polysilicon-1##0 S2#12pin@148_polysilicon-1##1 9.521
R301 S2#12pin@148_polysilicon-1##1 S2#12pin@148_polysilicon-1##2 9.521
R302 S2#12pin@148_polysilicon-1##2 S2#12pin@148_polysilicon-1##3 9.521
R303 S2#12pin@148_polysilicon-1##3 S2#12pin@148_polysilicon-1##4 9.521
R304 S2#12pin@148_polysilicon-1##4 S2#12pin@148_polysilicon-1##5 9.521
R305 S2#12pin@148_polysilicon-1##5 S2 9.521
R306 S2#7pin@144_polysilicon-1 S2#7pin@144_polysilicon-1##0 5.425
R307 S2#7pin@144_polysilicon-1##0 S2#14pmos@16_poly-right 5.425
R308 net@131#11nmos@12_poly-right net@131#11nmos@12_poly-right##0 6.2
R309 net@131#11nmos@12_poly-right##0 net@131#6pin@136_polysilicon-1 6.2
R310 net@235#6pin@156_polysilicon-1 net@235#6pin@156_polysilicon-1##0 8.37
R311 net@235#6pin@156_polysilicon-1##0 net@235#6pin@156_polysilicon-1##1 8.37
R312 net@235#6pin@156_polysilicon-1##1 net@235#6pin@156_polysilicon-1##2 8.37
R313 net@235#6pin@156_polysilicon-1##2 net@235#6pin@156_polysilicon-1##3 8.37
R314 net@235#6pin@156_polysilicon-1##3 net@235#2pin@158_polysilicon-1 8.37
R315 S2#16pmos@6_poly-left S2#16pmos@6_poly-left##0 6.2
R316 S2#16pmos@6_poly-left##0 S2#17pin@72_polysilicon-1 6.2
R317 S1#40nmos@10_poly-right S1#40nmos@10_poly-right##0 7.233
R318 S1#40nmos@10_poly-right##0 S1#40nmos@10_poly-right##1 7.233
R319 S1#40nmos@10_poly-right##1 S1#29pin@98_polysilicon-1 7.233
R320 net@235#8nmos@15_poly-right net@235#8nmos@15_poly-right##0 6.2
R321 net@235#8nmos@15_poly-right##0 net@235#2pin@158_polysilicon-1 6.2
R322 S1#41pmos@9_poly-left S1#41pmos@9_poly-left##0 6.2
R323 S1#41pmos@9_poly-left##0 S1#42pin@101_polysilicon-1 6.2
R324 S2#18nmos@17_poly-left S2#18nmos@17_poly-left##0 6.975
R325 S2#18nmos@17_poly-left##0 S2#19pin@152_polysilicon-1 6.975
R326 S2#19pin@152_polysilicon-1 S2#19pin@152_polysilicon-1##0 9.772
R327 S2#19pin@152_polysilicon-1##0 S2#19pin@152_polysilicon-1##1 9.772
R328 S2#19pin@152_polysilicon-1##1 S2#19pin@152_polysilicon-1##2 9.772
R329 S2#19pin@152_polysilicon-1##2 S2#19pin@152_polysilicon-1##3 9.772
R330 S2#19pin@152_polysilicon-1##3 S2#19pin@152_polysilicon-1##4 9.772
R331 S2#19pin@152_polysilicon-1##4 S2#19pin@152_polysilicon-1##5 9.772
R332 S2#19pin@152_polysilicon-1##5 S2#19pin@152_polysilicon-1##6 9.772
R333 S2#19pin@152_polysilicon-1##6 S2#19pin@152_polysilicon-1##7 9.772
R334 S2#19pin@152_polysilicon-1##7 S2#19pin@152_polysilicon-1##8 9.772
R335 S2#19pin@152_polysilicon-1##8 S2#19pin@152_polysilicon-1##9 9.772
R336 S2#19pin@152_polysilicon-1##9 S2#19pin@152_polysilicon-1##10 9.772
R337 S2#19pin@152_polysilicon-1##10 S2#19pin@152_polysilicon-1##11 9.772
R338 S2#19pin@152_polysilicon-1##11 S2#19pin@152_polysilicon-1##12 9.772
R339 S2#19pin@152_polysilicon-1##12 S2#19pin@152_polysilicon-1##13 9.772
R340 S2#19pin@152_polysilicon-1##13 S2#19pin@152_polysilicon-1##14 9.772
R341 S2#19pin@152_polysilicon-1##14 S2#19pin@152_polysilicon-1##15 9.772
R342 S2#19pin@152_polysilicon-1##15 S2#19pin@152_polysilicon-1##16 9.772
R343 S2#19pin@152_polysilicon-1##16 S2#19pin@152_polysilicon-1##17 9.772
R344 S2#19pin@152_polysilicon-1##17 S2#19pin@152_polysilicon-1##18 9.772
R345 S2#19pin@152_polysilicon-1##18 S2#19pin@152_polysilicon-1##19 9.772
R346 S2#19pin@152_polysilicon-1##19 S2#19pin@152_polysilicon-1##20 9.772
R347 S2#19pin@152_polysilicon-1##20 S2#19pin@152_polysilicon-1##21 9.772
R348 S2#19pin@152_polysilicon-1##21 S2#5pin@153_polysilicon-1 9.772
R349 S2 S2##0 8.267
R350 S2##0 S2##1 8.267
R351 S2##1 S2#7pin@144_polysilicon-1 8.267
R352 net@235#9pmos@17_poly-left net@235#10pin@154_polysilicon-1 7.75
R353 S1#43nmos@14_poly-left S1#43nmos@14_poly-left##0 6.975
R354 S1#43nmos@14_poly-left##0 S1#44pin@130_polysilicon-1 6.975
R355 S2#17pin@72_polysilicon-1 S2#17pin@72_polysilicon-1##0 9.896
R356 S2#17pin@72_polysilicon-1##0 S2#17pin@72_polysilicon-1##1 9.896
R357 S2#17pin@72_polysilicon-1##1 S2#17pin@72_polysilicon-1##2 9.896
R358 S2#17pin@72_polysilicon-1##2 S2#17pin@72_polysilicon-1##3 9.896
R359 S2#17pin@72_polysilicon-1##3 S2#17pin@72_polysilicon-1##4 9.896
R360 S2#17pin@72_polysilicon-1##4 S2#17pin@72_polysilicon-1##5 9.896
R361 S2#17pin@72_polysilicon-1##5 S2#17pin@72_polysilicon-1##6 9.896
R362 S2#17pin@72_polysilicon-1##6 S2#17pin@72_polysilicon-1##7 9.896
R363 S2#17pin@72_polysilicon-1##7 S2#17pin@72_polysilicon-1##8 9.896
R364 S2#17pin@72_polysilicon-1##8 S2#17pin@72_polysilicon-1##9 9.896
R365 S2#17pin@72_polysilicon-1##9 S2#17pin@72_polysilicon-1##10 9.896
R366 S2#17pin@72_polysilicon-1##10 S2#17pin@72_polysilicon-1##11 9.896
R367 S2#17pin@72_polysilicon-1##11 S2#20pin@73_polysilicon-1 9.896
R368 net@235#10pin@154_polysilicon-1 net@235#10pin@154_polysilicon-1##0 9.042
R369 net@235#10pin@154_polysilicon-1##0 net@235#10pin@154_polysilicon-1##1 9.042
R370 net@235#10pin@154_polysilicon-1##1 net@235#10pin@154_polysilicon-1##2 9.042
R371 net@235#10pin@154_polysilicon-1##2 net@235#10pin@154_polysilicon-1##3 9.042
R372 net@235#10pin@154_polysilicon-1##3 net@235#10pin@154_polysilicon-1##4 9.042
R373 net@235#10pin@154_polysilicon-1##4 net@235#11pin@155_polysilicon-1 9.042
R374 net@235#11pin@155_polysilicon-1 net@235#11pin@155_polysilicon-1##0 9.3
R375 net@235#11pin@155_polysilicon-1##0 net@235#11pin@155_polysilicon-1##1 9.3
R376 net@235#11pin@155_polysilicon-1##1 net@235#11pin@155_polysilicon-1##2 9.3
R377 net@235#11pin@155_polysilicon-1##2 net@235#11pin@155_polysilicon-1##3 9.3
R378 net@235#11pin@155_polysilicon-1##3 net@235#11pin@155_polysilicon-1##4 9.3
R379 net@235#11pin@155_polysilicon-1##4 net@235#11pin@155_polysilicon-1##5 9.3
R380 net@235#11pin@155_polysilicon-1##5 net@235#11pin@155_polysilicon-1##6 9.3
R381 net@235#11pin@155_polysilicon-1##6 net@235#6pin@156_polysilicon-1 9.3
R382 S1#42pin@101_polysilicon-1 S1#42pin@101_polysilicon-1##0 9.896
R383 S1#42pin@101_polysilicon-1##0 S1#42pin@101_polysilicon-1##1 9.896
R384 S1#42pin@101_polysilicon-1##1 S1#42pin@101_polysilicon-1##2 9.896
R385 S1#42pin@101_polysilicon-1##2 S1#42pin@101_polysilicon-1##3 9.896
R386 S1#42pin@101_polysilicon-1##3 S1#42pin@101_polysilicon-1##4 9.896
R387 S1#42pin@101_polysilicon-1##4 S1#42pin@101_polysilicon-1##5 9.896
R388 S1#42pin@101_polysilicon-1##5 S1#42pin@101_polysilicon-1##6 9.896
R389 S1#42pin@101_polysilicon-1##6 S1#42pin@101_polysilicon-1##7 9.896
R390 S1#42pin@101_polysilicon-1##7 S1#42pin@101_polysilicon-1##8 9.896
R391 S1#42pin@101_polysilicon-1##8 S1#42pin@101_polysilicon-1##9 9.896
R392 S1#42pin@101_polysilicon-1##9 S1#42pin@101_polysilicon-1##10 9.896
R393 S1#42pin@101_polysilicon-1##10 S1#42pin@101_polysilicon-1##11 9.896
R394 S1#42pin@101_polysilicon-1##11 S1#45pin@102_polysilicon-1 9.896
R395 S1#45pin@102_polysilicon-1 S1#45pin@102_polysilicon-1##0 9.521
R396 S1#45pin@102_polysilicon-1##0 S1#45pin@102_polysilicon-1##1 9.521
R397 S1#45pin@102_polysilicon-1##1 S1#45pin@102_polysilicon-1##2 9.521
R398 S1#45pin@102_polysilicon-1##2 S1#45pin@102_polysilicon-1##3 9.521
R399 S1#45pin@102_polysilicon-1##3 S1#45pin@102_polysilicon-1##4 9.521
R400 S1#45pin@102_polysilicon-1##4 S1#45pin@102_polysilicon-1##5 9.521
R401 S1#45pin@102_polysilicon-1##5 S1 9.521
R402 S2#20pin@73_polysilicon-1 S2#20pin@73_polysilicon-1##0 9.521
R403 S2#20pin@73_polysilicon-1##0 S2#20pin@73_polysilicon-1##1 9.521
R404 S2#20pin@73_polysilicon-1##1 S2#20pin@73_polysilicon-1##2 9.521
R405 S2#20pin@73_polysilicon-1##2 S2#20pin@73_polysilicon-1##3 9.521
R406 S2#20pin@73_polysilicon-1##3 S2#20pin@73_polysilicon-1##4 9.521
R407 S2#20pin@73_polysilicon-1##4 S2#20pin@73_polysilicon-1##5 9.521
R408 S2#20pin@73_polysilicon-1##5 S2 9.521
R409 S1#44pin@130_polysilicon-1 S1#44pin@130_polysilicon-1##0 9.772
R410 S1#44pin@130_polysilicon-1##0 S1#44pin@130_polysilicon-1##1 9.772
R411 S1#44pin@130_polysilicon-1##1 S1#44pin@130_polysilicon-1##2 9.772
R412 S1#44pin@130_polysilicon-1##2 S1#44pin@130_polysilicon-1##3 9.772
R413 S1#44pin@130_polysilicon-1##3 S1#44pin@130_polysilicon-1##4 9.772
R414 S1#44pin@130_polysilicon-1##4 S1#44pin@130_polysilicon-1##5 9.772
R415 S1#44pin@130_polysilicon-1##5 S1#44pin@130_polysilicon-1##6 9.772
R416 S1#44pin@130_polysilicon-1##6 S1#44pin@130_polysilicon-1##7 9.772
R417 S1#44pin@130_polysilicon-1##7 S1#44pin@130_polysilicon-1##8 9.772
R418 S1#44pin@130_polysilicon-1##8 S1#44pin@130_polysilicon-1##9 9.772
R419 S1#44pin@130_polysilicon-1##9 S1#44pin@130_polysilicon-1##10 9.772
R420 S1#44pin@130_polysilicon-1##10 S1#44pin@130_polysilicon-1##11 9.772
R421 S1#44pin@130_polysilicon-1##11 S1#44pin@130_polysilicon-1##12 9.772
R422 S1#44pin@130_polysilicon-1##12 S1#44pin@130_polysilicon-1##13 9.772
R423 S1#44pin@130_polysilicon-1##13 S1#44pin@130_polysilicon-1##14 9.772
R424 S1#44pin@130_polysilicon-1##14 S1#44pin@130_polysilicon-1##15 9.772
R425 S1#44pin@130_polysilicon-1##15 S1#44pin@130_polysilicon-1##16 9.772
R426 S1#44pin@130_polysilicon-1##16 S1#44pin@130_polysilicon-1##17 9.772
R427 S1#44pin@130_polysilicon-1##17 S1#44pin@130_polysilicon-1##18 9.772
R428 S1#44pin@130_polysilicon-1##18 S1#44pin@130_polysilicon-1##19 9.772
R429 S1#44pin@130_polysilicon-1##19 S1#44pin@130_polysilicon-1##20 9.772
R430 S1#44pin@130_polysilicon-1##20 S1#44pin@130_polysilicon-1##21 9.772
R431 S1#44pin@130_polysilicon-1##21 S1#31pin@131_polysilicon-1 9.772
R432 S1#29pin@98_polysilicon-1 S1#29pin@98_polysilicon-1##0 5.425
R433 S1#29pin@98_polysilicon-1##0 S1#46pmos@10_poly-right 5.425
R434 S1 S1##0 8.267
R435 S1##0 S1##1 8.267
R436 S1##1 S1#34pin@121_polysilicon-1 8.267
R437 S2#9pin@69_polysilicon-1 S2#9pin@69_polysilicon-1##0 5.425
R438 S2#9pin@69_polysilicon-1##0 S2#22pmos@7_poly-right 5.425
R439 net@375#4pin@195_polysilicon-1 net@375#4pin@195_polysilicon-1##0 8.37
R440 net@375#4pin@195_polysilicon-1##0 net@375#4pin@195_polysilicon-1##1 8.37
R441 net@375#4pin@195_polysilicon-1##1 net@375#4pin@195_polysilicon-1##2 8.37
R442 net@375#4pin@195_polysilicon-1##2 net@375#4pin@195_polysilicon-1##3 8.37
R443 net@375#4pin@195_polysilicon-1##3 net@375#5pin@197_polysilicon-1 8.37
R444 net@375#6nmos@18_poly-right net@375#6nmos@18_poly-right##0 6.2
R445 net@375#6nmos@18_poly-right##0 net@375#5pin@197_polysilicon-1 6.2
R446 S0#0pin@187_polysilicon-1 S0#0pin@187_polysilicon-1##0 9.881
R447 S0#0pin@187_polysilicon-1##0 S0#0pin@187_polysilicon-1##1 9.881
R448 S0#0pin@187_polysilicon-1##1 S0#0pin@187_polysilicon-1##2 9.881
R449 S0#0pin@187_polysilicon-1##2 S0#0pin@187_polysilicon-1##3 9.881
R450 S0#0pin@187_polysilicon-1##3 S0#0pin@187_polysilicon-1##4 9.881
R451 S0#0pin@187_polysilicon-1##4 S0#0pin@187_polysilicon-1##5 9.881
R452 S0#0pin@187_polysilicon-1##5 S0#0pin@187_polysilicon-1##6 9.881
R453 S0#0pin@187_polysilicon-1##6 S0#1pin@192_polysilicon-1 9.881
R454 net@375#5pin@197_polysilicon-1 net@375#5pin@197_polysilicon-1##0 9.042
R455 net@375#5pin@197_polysilicon-1##0 net@375#5pin@197_polysilicon-1##1 9.042
R456 net@375#5pin@197_polysilicon-1##1 net@375#5pin@197_polysilicon-1##2 9.042
R457 net@375#5pin@197_polysilicon-1##2 net@375#5pin@197_polysilicon-1##3 9.042
R458 net@375#5pin@197_polysilicon-1##3 net@375#5pin@197_polysilicon-1##4 9.042
R459 net@375#5pin@197_polysilicon-1##4 net@375 9.042
R460 S0#2nmos@19_poly-right S0#2nmos@19_poly-right##0 7.233
R461 S0#2nmos@19_poly-right##0 S0#2nmos@19_poly-right##1 7.233
R462 S0#2nmos@19_poly-right##1 S0#3pin@182_polysilicon-1 7.233
R463 S0#4pmos@18_poly-left S0#4pmos@18_poly-left##0 6.2
R464 S0#4pmos@18_poly-left##0 S0#5pin@185_polysilicon-1 6.2
R465 S0#5pin@185_polysilicon-1 S0#5pin@185_polysilicon-1##0 9.896
R466 S0#5pin@185_polysilicon-1##0 S0#5pin@185_polysilicon-1##1 9.896
R467 S0#5pin@185_polysilicon-1##1 S0#5pin@185_polysilicon-1##2 9.896
R468 S0#5pin@185_polysilicon-1##2 S0#5pin@185_polysilicon-1##3 9.896
R469 S0#5pin@185_polysilicon-1##3 S0#5pin@185_polysilicon-1##4 9.896
R470 S0#5pin@185_polysilicon-1##4 S0#5pin@185_polysilicon-1##5 9.896
R471 S0#5pin@185_polysilicon-1##5 S0#5pin@185_polysilicon-1##6 9.896
R472 S0#5pin@185_polysilicon-1##6 S0#5pin@185_polysilicon-1##7 9.896
R473 S0#5pin@185_polysilicon-1##7 S0#5pin@185_polysilicon-1##8 9.896
R474 S0#5pin@185_polysilicon-1##8 S0#5pin@185_polysilicon-1##9 9.896
R475 S0#5pin@185_polysilicon-1##9 S0#5pin@185_polysilicon-1##10 9.896
R476 S0#5pin@185_polysilicon-1##10 S0#5pin@185_polysilicon-1##11 9.896
R477 S0#5pin@185_polysilicon-1##11 S0#6pin@186_polysilicon-1 9.896
R478 S0#6pin@186_polysilicon-1 S0#6pin@186_polysilicon-1##0 9.521
R479 S0#6pin@186_polysilicon-1##0 S0#6pin@186_polysilicon-1##1 9.521
R480 S0#6pin@186_polysilicon-1##1 S0#6pin@186_polysilicon-1##2 9.521
R481 S0#6pin@186_polysilicon-1##2 S0#6pin@186_polysilicon-1##3 9.521
R482 S0#6pin@186_polysilicon-1##3 S0#6pin@186_polysilicon-1##4 9.521
R483 S0#6pin@186_polysilicon-1##4 S0#6pin@186_polysilicon-1##5 9.521
R484 S0#6pin@186_polysilicon-1##5 S0#0pin@187_polysilicon-1 9.521
R485 S0#3pin@182_polysilicon-1 S0#3pin@182_polysilicon-1##0 5.425
R486 S0#3pin@182_polysilicon-1##0 S0#8pmos@19_poly-right 5.425
R487 S0#10nmos@20_poly-left S0#10nmos@20_poly-left##0 6.975
R488 S0#10nmos@20_poly-left##0 S0#11pin@191_polysilicon-1 6.975
R489 S0#11pin@191_polysilicon-1 S0#11pin@191_polysilicon-1##0 9.772
R490 S0#11pin@191_polysilicon-1##0 S0#11pin@191_polysilicon-1##1 9.772
R491 S0#11pin@191_polysilicon-1##1 S0#11pin@191_polysilicon-1##2 9.772
R492 S0#11pin@191_polysilicon-1##2 S0#11pin@191_polysilicon-1##3 9.772
R493 S0#11pin@191_polysilicon-1##3 S0#11pin@191_polysilicon-1##4 9.772
R494 S0#11pin@191_polysilicon-1##4 S0#11pin@191_polysilicon-1##5 9.772
R495 S0#11pin@191_polysilicon-1##5 S0#11pin@191_polysilicon-1##6 9.772
R496 S0#11pin@191_polysilicon-1##6 S0#11pin@191_polysilicon-1##7 9.772
R497 S0#11pin@191_polysilicon-1##7 S0#11pin@191_polysilicon-1##8 9.772
R498 S0#11pin@191_polysilicon-1##8 S0#11pin@191_polysilicon-1##9 9.772
R499 S0#11pin@191_polysilicon-1##9 S0#11pin@191_polysilicon-1##10 9.772
R500 S0#11pin@191_polysilicon-1##10 S0#11pin@191_polysilicon-1##11 9.772
R501 S0#11pin@191_polysilicon-1##11 S0#11pin@191_polysilicon-1##12 9.772
R502 S0#11pin@191_polysilicon-1##12 S0#11pin@191_polysilicon-1##13 9.772
R503 S0#11pin@191_polysilicon-1##13 S0#11pin@191_polysilicon-1##14 9.772
R504 S0#11pin@191_polysilicon-1##14 S0#11pin@191_polysilicon-1##15 9.772
R505 S0#11pin@191_polysilicon-1##15 S0#11pin@191_polysilicon-1##16 9.772
R506 S0#11pin@191_polysilicon-1##16 S0#11pin@191_polysilicon-1##17 9.772
R507 S0#11pin@191_polysilicon-1##17 S0#11pin@191_polysilicon-1##18 9.772
R508 S0#11pin@191_polysilicon-1##18 S0#11pin@191_polysilicon-1##19 9.772
R509 S0#11pin@191_polysilicon-1##19 S0#11pin@191_polysilicon-1##20 9.772
R510 S0#11pin@191_polysilicon-1##20 S0#11pin@191_polysilicon-1##21 9.772
R511 S0#11pin@191_polysilicon-1##21 S0#1pin@192_polysilicon-1 9.772
R512 S0#0pin@187_polysilicon-1 S0#0pin@187_polysilicon-1##0 8.267
R513 S0#0pin@187_polysilicon-1##0 S0#0pin@187_polysilicon-1##1 8.267
R514 S0#0pin@187_polysilicon-1##1 S0#3pin@182_polysilicon-1 8.267
R515 net@375#9pmos@20_poly-left net@375#10pin@193_polysilicon-1 7.75
R516 net@375#10pin@193_polysilicon-1 net@375#10pin@193_polysilicon-1##0 9.042
R517 net@375#10pin@193_polysilicon-1##0 net@375#10pin@193_polysilicon-1##1 9.042
R518 net@375#10pin@193_polysilicon-1##1 net@375#10pin@193_polysilicon-1##2 9.042
R519 net@375#10pin@193_polysilicon-1##2 net@375#10pin@193_polysilicon-1##3 9.042
R520 net@375#10pin@193_polysilicon-1##3 net@375#10pin@193_polysilicon-1##4 9.042
R521 net@375#10pin@193_polysilicon-1##4 net@375#11pin@194_polysilicon-1 9.042
R522 net@375#11pin@194_polysilicon-1 net@375#11pin@194_polysilicon-1##0 9.3
R523 net@375#11pin@194_polysilicon-1##0 net@375#11pin@194_polysilicon-1##1 9.3
R524 net@375#11pin@194_polysilicon-1##1 net@375#11pin@194_polysilicon-1##2 9.3
R525 net@375#11pin@194_polysilicon-1##2 net@375#11pin@194_polysilicon-1##3 9.3
R526 net@375#11pin@194_polysilicon-1##3 net@375#11pin@194_polysilicon-1##4 9.3
R527 net@375#11pin@194_polysilicon-1##4 net@375#11pin@194_polysilicon-1##5 9.3
R528 net@375#11pin@194_polysilicon-1##5 net@375#11pin@194_polysilicon-1##6 9.3
R529 net@375#11pin@194_polysilicon-1##6 net@375#4pin@195_polysilicon-1 9.3
R530 net@27#11nmos@3_poly-right net@27#11nmos@3_poly-right##0 6.2
R531 net@27#11nmos@3_poly-right##0 net@27#6pin@61_polysilicon-1 6.2
R532 net@122#6pin@81_polysilicon-1 net@122#6pin@81_polysilicon-1##0 8.37
R533 net@122#6pin@81_polysilicon-1##0 net@122#6pin@81_polysilicon-1##1 8.37
R534 net@122#6pin@81_polysilicon-1##1 net@122#6pin@81_polysilicon-1##2 8.37
R535 net@122#6pin@81_polysilicon-1##2 net@122#6pin@81_polysilicon-1##3 8.37
R536 net@122#6pin@81_polysilicon-1##3 net@122#2pin@83_polysilicon-1 8.37
R537 S0#0pin@187_polysilicon-1 S0 4.238
R538 S1#49nmos@1_poly-right S1#49nmos@1_poly-right##0 7.233
R539 S1#49nmos@1_poly-right##0 S1#49nmos@1_poly-right##1 7.233
R540 S1#49nmos@1_poly-right##1 S1#9pin@23_polysilicon-1 7.233
R541 net@122#8nmos@6_poly-right net@122#8nmos@6_poly-right##0 6.2
R542 net@122#8nmos@6_poly-right##0 net@122#2pin@83_polysilicon-1 6.2
R543 S1#50pmos@0_poly-left S1#50pmos@0_poly-left##0 6.2
R544 S1#50pmos@0_poly-left##0 S1#51pin@26_polysilicon-1 6.2
R545 S2#25nmos@8_poly-left S2#25nmos@8_poly-left##0 6.975
R546 S2#25nmos@8_poly-left##0 S2#26pin@77_polysilicon-1 6.975
R547 S2#26pin@77_polysilicon-1 S2#26pin@77_polysilicon-1##0 9.772
R548 S2#26pin@77_polysilicon-1##0 S2#26pin@77_polysilicon-1##1 9.772
R549 S2#26pin@77_polysilicon-1##1 S2#26pin@77_polysilicon-1##2 9.772
R550 S2#26pin@77_polysilicon-1##2 S2#26pin@77_polysilicon-1##3 9.772
R551 S2#26pin@77_polysilicon-1##3 S2#26pin@77_polysilicon-1##4 9.772
R552 S2#26pin@77_polysilicon-1##4 S2#26pin@77_polysilicon-1##5 9.772
R553 S2#26pin@77_polysilicon-1##5 S2#26pin@77_polysilicon-1##6 9.772
R554 S2#26pin@77_polysilicon-1##6 S2#26pin@77_polysilicon-1##7 9.772
R555 S2#26pin@77_polysilicon-1##7 S2#26pin@77_polysilicon-1##8 9.772
R556 S2#26pin@77_polysilicon-1##8 S2#26pin@77_polysilicon-1##9 9.772
R557 S2#26pin@77_polysilicon-1##9 S2#26pin@77_polysilicon-1##10 9.772
R558 S2#26pin@77_polysilicon-1##10 S2#26pin@77_polysilicon-1##11 9.772
R559 S2#26pin@77_polysilicon-1##11 S2#26pin@77_polysilicon-1##12 9.772
R560 S2#26pin@77_polysilicon-1##12 S2#26pin@77_polysilicon-1##13 9.772
R561 S2#26pin@77_polysilicon-1##13 S2#26pin@77_polysilicon-1##14 9.772
R562 S2#26pin@77_polysilicon-1##14 S2#26pin@77_polysilicon-1##15 9.772
R563 S2#26pin@77_polysilicon-1##15 S2#26pin@77_polysilicon-1##16 9.772
R564 S2#26pin@77_polysilicon-1##16 S2#26pin@77_polysilicon-1##17 9.772
R565 S2#26pin@77_polysilicon-1##17 S2#26pin@77_polysilicon-1##18 9.772
R566 S2#26pin@77_polysilicon-1##18 S2#26pin@77_polysilicon-1##19 9.772
R567 S2#26pin@77_polysilicon-1##19 S2#26pin@77_polysilicon-1##20 9.772
R568 S2#26pin@77_polysilicon-1##20 S2#26pin@77_polysilicon-1##21 9.772
R569 S2#26pin@77_polysilicon-1##21 S2#3pin@78_polysilicon-1 9.772
R570 S2 S2##0 8.267
R571 S2##0 S2##1 8.267
R572 S2##1 S2#9pin@69_polysilicon-1 8.267
R573 net@122#9pmos@8_poly-left net@122#10pin@79_polysilicon-1 7.75
R574 S1#52nmos@5_poly-left S1#52nmos@5_poly-left##0 6.975
R575 S1#52nmos@5_poly-left##0 S1#53pin@55_polysilicon-1 6.975
R576 net@122#10pin@79_polysilicon-1 net@122#10pin@79_polysilicon-1##0 9.042
R577 net@122#10pin@79_polysilicon-1##0 net@122#10pin@79_polysilicon-1##1 9.042
R578 net@122#10pin@79_polysilicon-1##1 net@122#10pin@79_polysilicon-1##2 9.042
R579 net@122#10pin@79_polysilicon-1##2 net@122#10pin@79_polysilicon-1##3 9.042
R580 net@122#10pin@79_polysilicon-1##3 net@122#10pin@79_polysilicon-1##4 9.042
R581 net@122#10pin@79_polysilicon-1##4 net@122#11pin@80_polysilicon-1 9.042
R582 net@122#11pin@80_polysilicon-1 net@122#11pin@80_polysilicon-1##0 9.3
R583 net@122#11pin@80_polysilicon-1##0 net@122#11pin@80_polysilicon-1##1 9.3
R584 net@122#11pin@80_polysilicon-1##1 net@122#11pin@80_polysilicon-1##2 9.3
R585 net@122#11pin@80_polysilicon-1##2 net@122#11pin@80_polysilicon-1##3 9.3
R586 net@122#11pin@80_polysilicon-1##3 net@122#11pin@80_polysilicon-1##4 9.3
R587 net@122#11pin@80_polysilicon-1##4 net@122#11pin@80_polysilicon-1##5 9.3
R588 net@122#11pin@80_polysilicon-1##5 net@122#11pin@80_polysilicon-1##6 9.3
R589 net@122#11pin@80_polysilicon-1##6 net@122#6pin@81_polysilicon-1 9.3
R590 S1#51pin@26_polysilicon-1 S1#51pin@26_polysilicon-1##0 9.896
R591 S1#51pin@26_polysilicon-1##0 S1#51pin@26_polysilicon-1##1 9.896
R592 S1#51pin@26_polysilicon-1##1 S1#51pin@26_polysilicon-1##2 9.896
R593 S1#51pin@26_polysilicon-1##2 S1#51pin@26_polysilicon-1##3 9.896
R594 S1#51pin@26_polysilicon-1##3 S1#51pin@26_polysilicon-1##4 9.896
R595 S1#51pin@26_polysilicon-1##4 S1#51pin@26_polysilicon-1##5 9.896
R596 S1#51pin@26_polysilicon-1##5 S1#51pin@26_polysilicon-1##6 9.896
R597 S1#51pin@26_polysilicon-1##6 S1#51pin@26_polysilicon-1##7 9.896
R598 S1#51pin@26_polysilicon-1##7 S1#51pin@26_polysilicon-1##8 9.896
R599 S1#51pin@26_polysilicon-1##8 S1#51pin@26_polysilicon-1##9 9.896
R600 S1#51pin@26_polysilicon-1##9 S1#51pin@26_polysilicon-1##10 9.896
R601 S1#51pin@26_polysilicon-1##10 S1#51pin@26_polysilicon-1##11 9.896
R602 S1#51pin@26_polysilicon-1##11 S1#54pin@27_polysilicon-1 9.896
R603 S1#54pin@27_polysilicon-1 S1#54pin@27_polysilicon-1##0 9.521
R604 S1#54pin@27_polysilicon-1##0 S1#54pin@27_polysilicon-1##1 9.521
R605 S1#54pin@27_polysilicon-1##1 S1#54pin@27_polysilicon-1##2 9.521
R606 S1#54pin@27_polysilicon-1##2 S1#54pin@27_polysilicon-1##3 9.521
R607 S1#54pin@27_polysilicon-1##3 S1#54pin@27_polysilicon-1##4 9.521
R608 S1#54pin@27_polysilicon-1##4 S1#54pin@27_polysilicon-1##5 9.521
R609 S1#54pin@27_polysilicon-1##5 S1 9.521
R610 S1#53pin@55_polysilicon-1 S1#53pin@55_polysilicon-1##0 9.772
R611 S1#53pin@55_polysilicon-1##0 S1#53pin@55_polysilicon-1##1 9.772
R612 S1#53pin@55_polysilicon-1##1 S1#53pin@55_polysilicon-1##2 9.772
R613 S1#53pin@55_polysilicon-1##2 S1#53pin@55_polysilicon-1##3 9.772
R614 S1#53pin@55_polysilicon-1##3 S1#53pin@55_polysilicon-1##4 9.772
R615 S1#53pin@55_polysilicon-1##4 S1#53pin@55_polysilicon-1##5 9.772
R616 S1#53pin@55_polysilicon-1##5 S1#53pin@55_polysilicon-1##6 9.772
R617 S1#53pin@55_polysilicon-1##6 S1#53pin@55_polysilicon-1##7 9.772
R618 S1#53pin@55_polysilicon-1##7 S1#53pin@55_polysilicon-1##8 9.772
R619 S1#53pin@55_polysilicon-1##8 S1#53pin@55_polysilicon-1##9 9.772
R620 S1#53pin@55_polysilicon-1##9 S1#53pin@55_polysilicon-1##10 9.772
R621 S1#53pin@55_polysilicon-1##10 S1#53pin@55_polysilicon-1##11 9.772
R622 S1#53pin@55_polysilicon-1##11 S1#53pin@55_polysilicon-1##12 9.772
R623 S1#53pin@55_polysilicon-1##12 S1#53pin@55_polysilicon-1##13 9.772
R624 S1#53pin@55_polysilicon-1##13 S1#53pin@55_polysilicon-1##14 9.772
R625 S1#53pin@55_polysilicon-1##14 S1#53pin@55_polysilicon-1##15 9.772
R626 S1#53pin@55_polysilicon-1##15 S1#53pin@55_polysilicon-1##16 9.772
R627 S1#53pin@55_polysilicon-1##16 S1#53pin@55_polysilicon-1##17 9.772
R628 S1#53pin@55_polysilicon-1##17 S1#53pin@55_polysilicon-1##18 9.772
R629 S1#53pin@55_polysilicon-1##18 S1#53pin@55_polysilicon-1##19 9.772
R630 S1#53pin@55_polysilicon-1##19 S1#53pin@55_polysilicon-1##20 9.772
R631 S1#53pin@55_polysilicon-1##20 S1#53pin@55_polysilicon-1##21 9.772
R632 S1#53pin@55_polysilicon-1##21 S1#11pin@56_polysilicon-1 9.772
R633 S1#9pin@23_polysilicon-1 S1#9pin@23_polysilicon-1##0 5.425
R634 S1#9pin@23_polysilicon-1##0 S1#55pmos@1_poly-right 5.425
R635 S1 S1##0 8.267
R636 S1##0 S1##1 8.267
R637 S1##1 S1#14pin@46_polysilicon-1 8.267
R638 net@523 net@523#1pin@321_polysilicon-1 7.75
R639 net@523#1pin@321_polysilicon-1 net@523#1pin@321_polysilicon-1##0 9.042
R640 net@523#1pin@321_polysilicon-1##0 net@523#1pin@321_polysilicon-1##1 9.042
R641 net@523#1pin@321_polysilicon-1##1 net@523#1pin@321_polysilicon-1##2 9.042
R642 net@523#1pin@321_polysilicon-1##2 net@523#1pin@321_polysilicon-1##3 9.042
R643 net@523#1pin@321_polysilicon-1##3 net@523#1pin@321_polysilicon-1##4 9.042
R644 net@523#1pin@321_polysilicon-1##4 net@523#2pin@322_polysilicon-1 9.042
R645 net@523#2pin@322_polysilicon-1 net@523#2pin@322_polysilicon-1##0 9.3
R646 net@523#2pin@322_polysilicon-1##0 net@523#2pin@322_polysilicon-1##1 9.3
R647 net@523#2pin@322_polysilicon-1##1 net@523#2pin@322_polysilicon-1##2 9.3
R648 net@523#2pin@322_polysilicon-1##2 net@523#2pin@322_polysilicon-1##3 9.3
R649 net@523#2pin@322_polysilicon-1##3 net@523#2pin@322_polysilicon-1##4 9.3
R650 net@523#2pin@322_polysilicon-1##4 net@523#2pin@322_polysilicon-1##5 9.3
R651 net@523#2pin@322_polysilicon-1##5 net@523#2pin@322_polysilicon-1##6 9.3
R652 net@523#2pin@322_polysilicon-1##6 net@523#3pin@323_polysilicon-1 9.3
R653 net@522#3pin@300_polysilicon-1 net@522#3pin@300_polysilicon-1##0 8.37
R654 net@522#3pin@300_polysilicon-1##0 net@522#3pin@300_polysilicon-1##1 8.37
R655 net@522#3pin@300_polysilicon-1##1 net@522#3pin@300_polysilicon-1##2 8.37
R656 net@522#3pin@300_polysilicon-1##2 net@522#3pin@300_polysilicon-1##3 8.37
R657 net@522#3pin@300_polysilicon-1##3 net@522#4pin@302_polysilicon-1 8.37
R658 net@522#7nmos@30_poly-right net@522#7nmos@30_poly-right##0 6.2
R659 net@522#7nmos@30_poly-right##0 net@522#4pin@302_polysilicon-1 6.2
R660 S2#27pin@263_polysilicon-1 S2#27pin@263_polysilicon-1##0 9.881
R661 S2#27pin@263_polysilicon-1##0 S2#27pin@263_polysilicon-1##1 9.881
R662 S2#27pin@263_polysilicon-1##1 S2#27pin@263_polysilicon-1##2 9.881
R663 S2#27pin@263_polysilicon-1##2 S2#27pin@263_polysilicon-1##3 9.881
R664 S2#27pin@263_polysilicon-1##3 S2#27pin@263_polysilicon-1##4 9.881
R665 S2#27pin@263_polysilicon-1##4 S2#27pin@263_polysilicon-1##5 9.881
R666 S2#27pin@263_polysilicon-1##5 S2#27pin@263_polysilicon-1##6 9.881
R667 S2#27pin@263_polysilicon-1##6 S2#28pin@267_polysilicon-1 9.881
R668 S1#62nmos@32_poly-left S1#62nmos@32_poly-left##0 6.975
R669 S1#62nmos@32_poly-left##0 S1#63pin@296_polysilicon-1 6.975
R670 S1#63pin@296_polysilicon-1 S1#63pin@296_polysilicon-1##0 9.772
R671 S1#63pin@296_polysilicon-1##0 S1#63pin@296_polysilicon-1##1 9.772
R672 S1#63pin@296_polysilicon-1##1 S1#63pin@296_polysilicon-1##2 9.772
R673 S1#63pin@296_polysilicon-1##2 S1#63pin@296_polysilicon-1##3 9.772
R674 S1#63pin@296_polysilicon-1##3 S1#63pin@296_polysilicon-1##4 9.772
R675 S1#63pin@296_polysilicon-1##4 S1#63pin@296_polysilicon-1##5 9.772
R676 S1#63pin@296_polysilicon-1##5 S1#63pin@296_polysilicon-1##6 9.772
R677 S1#63pin@296_polysilicon-1##6 S1#63pin@296_polysilicon-1##7 9.772
R678 S1#63pin@296_polysilicon-1##7 S1#63pin@296_polysilicon-1##8 9.772
R679 S1#63pin@296_polysilicon-1##8 S1#63pin@296_polysilicon-1##9 9.772
R680 S1#63pin@296_polysilicon-1##9 S1#63pin@296_polysilicon-1##10 9.772
R681 S1#63pin@296_polysilicon-1##10 S1#63pin@296_polysilicon-1##11 9.772
R682 S1#63pin@296_polysilicon-1##11 S1#63pin@296_polysilicon-1##12 9.772
R683 S1#63pin@296_polysilicon-1##12 S1#63pin@296_polysilicon-1##13 9.772
R684 S1#63pin@296_polysilicon-1##13 S1#63pin@296_polysilicon-1##14 9.772
R685 S1#63pin@296_polysilicon-1##14 S1#63pin@296_polysilicon-1##15 9.772
R686 S1#63pin@296_polysilicon-1##15 S1#63pin@296_polysilicon-1##16 9.772
R687 S1#63pin@296_polysilicon-1##16 S1#63pin@296_polysilicon-1##17 9.772
R688 S1#63pin@296_polysilicon-1##17 S1#63pin@296_polysilicon-1##18 9.772
R689 S1#63pin@296_polysilicon-1##18 S1#63pin@296_polysilicon-1##19 9.772
R690 S1#63pin@296_polysilicon-1##19 S1#63pin@296_polysilicon-1##20 9.772
R691 S1#63pin@296_polysilicon-1##20 S1#63pin@296_polysilicon-1##21 9.772
R692 S1#63pin@296_polysilicon-1##21 S1#64pin@297_polysilicon-1 9.772
R693 S1#56contact@262_metal-1-metal-2 S1#56contact@262_metal-1-metal-2##0 8.267
R694 S1#56contact@262_metal-1-metal-2##0 S1#56contact@262_metal-1-metal-2##1 8.267
R695 S1#56contact@262_metal-1-metal-2##1 S1#65pin@287_polysilicon-1 8.267
R696 net@522#8pmos@32_poly-left net@522#9pin@298_polysilicon-1 7.75
R697 net@522#9pin@298_polysilicon-1 net@522#9pin@298_polysilicon-1##0 9.042
R698 net@522#9pin@298_polysilicon-1##0 net@522#9pin@298_polysilicon-1##1 9.042
R699 net@522#9pin@298_polysilicon-1##1 net@522#9pin@298_polysilicon-1##2 9.042
R700 net@522#9pin@298_polysilicon-1##2 net@522#9pin@298_polysilicon-1##3 9.042
R701 net@522#9pin@298_polysilicon-1##3 net@522#9pin@298_polysilicon-1##4 9.042
R702 net@522#9pin@298_polysilicon-1##4 net@522#10pin@299_polysilicon-1 9.042
R703 net@522#10pin@299_polysilicon-1 net@522#10pin@299_polysilicon-1##0 9.3
R704 net@522#10pin@299_polysilicon-1##0 net@522#10pin@299_polysilicon-1##1 9.3
R705 net@522#10pin@299_polysilicon-1##1 net@522#10pin@299_polysilicon-1##2 9.3
R706 net@522#10pin@299_polysilicon-1##2 net@522#10pin@299_polysilicon-1##3 9.3
R707 net@522#10pin@299_polysilicon-1##3 net@522#10pin@299_polysilicon-1##4 9.3
R708 net@522#10pin@299_polysilicon-1##4 net@522#10pin@299_polysilicon-1##5 9.3
R709 net@522#10pin@299_polysilicon-1##5 net@522#10pin@299_polysilicon-1##6 9.3
R710 net@522#10pin@299_polysilicon-1##6 net@522#3pin@300_polysilicon-1 9.3
R711 net@514#2pin@272_polysilicon-1 net@514#2pin@272_polysilicon-1##0 9.042
R712 net@514#2pin@272_polysilicon-1##0 net@514#2pin@272_polysilicon-1##1 9.042
R713 net@514#2pin@272_polysilicon-1##1 net@514#2pin@272_polysilicon-1##2 9.042
R714 net@514#2pin@272_polysilicon-1##2 net@514#2pin@272_polysilicon-1##3 9.042
R715 net@514#2pin@272_polysilicon-1##3 net@514#2pin@272_polysilicon-1##4 9.042
R716 net@514#2pin@272_polysilicon-1##4 net@514 9.042
R717 S1#56contact@262_metal-1-metal-2 S1#56contact@262_metal-1-metal-2##0 9.881
R718 S1#56contact@262_metal-1-metal-2##0 S1#56contact@262_metal-1-metal-2##1 9.881
R719 S1#56contact@262_metal-1-metal-2##1 S1#56contact@262_metal-1-metal-2##2 9.881
R720 S1#56contact@262_metal-1-metal-2##2 S1#56contact@262_metal-1-metal-2##3 9.881
R721 S1#56contact@262_metal-1-metal-2##3 S1#56contact@262_metal-1-metal-2##4 9.881
R722 S1#56contact@262_metal-1-metal-2##4 S1#56contact@262_metal-1-metal-2##5 9.881
R723 S1#56contact@262_metal-1-metal-2##5 S1#56contact@262_metal-1-metal-2##6 9.881
R724 S1#56contact@262_metal-1-metal-2##6 S1#67pin@320_polysilicon-1 9.881
R725 net@523#6pin@325_polysilicon-1 net@523#6pin@325_polysilicon-1##0 9.042
R726 net@523#6pin@325_polysilicon-1##0 net@523#6pin@325_polysilicon-1##1 9.042
R727 net@523#6pin@325_polysilicon-1##1 net@523#6pin@325_polysilicon-1##2 9.042
R728 net@523#6pin@325_polysilicon-1##2 net@523#6pin@325_polysilicon-1##3 9.042
R729 net@523#6pin@325_polysilicon-1##3 net@523#6pin@325_polysilicon-1##4 9.042
R730 net@523#6pin@325_polysilicon-1##4 net@523#4contact@277_metal-1-n-act 9.042
R731 S1#56contact@262_metal-1-metal-2 S1#56contact@262_metal-1-metal-2##0 9.881
R732 S1#56contact@262_metal-1-metal-2##0 S1#56contact@262_metal-1-metal-2##1 9.881
R733 S1#56contact@262_metal-1-metal-2##1 S1#56contact@262_metal-1-metal-2##2 9.881
R734 S1#56contact@262_metal-1-metal-2##2 S1#56contact@262_metal-1-metal-2##3 9.881
R735 S1#56contact@262_metal-1-metal-2##3 S1#56contact@262_metal-1-metal-2##4 9.881
R736 S1#56contact@262_metal-1-metal-2##4 S1#56contact@262_metal-1-metal-2##5 9.881
R737 S1#56contact@262_metal-1-metal-2##5 S1#56contact@262_metal-1-metal-2##6 9.881
R738 S1#56contact@262_metal-1-metal-2##6 S1#64pin@297_polysilicon-1 9.881
R739 S1#69nmos@34_poly-right S1#69nmos@34_poly-right##0 7.233
R740 S1#69nmos@34_poly-right##0 S1#69nmos@34_poly-right##1 7.233
R741 S1#69nmos@34_poly-right##1 S1#70pin@310_polysilicon-1 7.233
R742 S1#71pmos@33_poly-left S1#71pmos@33_poly-left##0 6.2
R743 S1#71pmos@33_poly-left##0 S1#72pin@313_polysilicon-1 6.2
R744 S1#72pin@313_polysilicon-1 S1#72pin@313_polysilicon-1##0 9.896
R745 S1#72pin@313_polysilicon-1##0 S1#72pin@313_polysilicon-1##1 9.896
R746 S1#72pin@313_polysilicon-1##1 S1#72pin@313_polysilicon-1##2 9.896
R747 S1#72pin@313_polysilicon-1##2 S1#72pin@313_polysilicon-1##3 9.896
R748 S1#72pin@313_polysilicon-1##3 S1#72pin@313_polysilicon-1##4 9.896
R749 S1#72pin@313_polysilicon-1##4 S1#72pin@313_polysilicon-1##5 9.896
R750 S1#72pin@313_polysilicon-1##5 S1#72pin@313_polysilicon-1##6 9.896
R751 S1#72pin@313_polysilicon-1##6 S1#72pin@313_polysilicon-1##7 9.896
R752 S1#72pin@313_polysilicon-1##7 S1#72pin@313_polysilicon-1##8 9.896
R753 S1#72pin@313_polysilicon-1##8 S1#72pin@313_polysilicon-1##9 9.896
R754 S1#72pin@313_polysilicon-1##9 S1#72pin@313_polysilicon-1##10 9.896
R755 S1#72pin@313_polysilicon-1##10 S1#72pin@313_polysilicon-1##11 9.896
R756 S1#72pin@313_polysilicon-1##11 S1#73pin@314_polysilicon-1 9.896
R757 S1#73pin@314_polysilicon-1 S1#73pin@314_polysilicon-1##0 9.521
R758 S1#73pin@314_polysilicon-1##0 S1#73pin@314_polysilicon-1##1 9.521
R759 S1#73pin@314_polysilicon-1##1 S1#73pin@314_polysilicon-1##2 9.521
R760 S1#73pin@314_polysilicon-1##2 S1#73pin@314_polysilicon-1##3 9.521
R761 S1#73pin@314_polysilicon-1##3 S1#73pin@314_polysilicon-1##4 9.521
R762 S1#73pin@314_polysilicon-1##4 S1#73pin@314_polysilicon-1##5 9.521
R763 S1#73pin@314_polysilicon-1##5 S1#56contact@262_metal-1-metal-2 9.521
R764 S1#70pin@310_polysilicon-1 S1#70pin@310_polysilicon-1##0 5.425
R765 S1#70pin@310_polysilicon-1##0 S1#75pmos@34_poly-right 5.425
R766 net@522#4pin@302_polysilicon-1 net@522#4pin@302_polysilicon-1##0 9.042
R767 net@522#4pin@302_polysilicon-1##0 net@522#4pin@302_polysilicon-1##1 9.042
R768 net@522#4pin@302_polysilicon-1##1 net@522#4pin@302_polysilicon-1##2 9.042
R769 net@522#4pin@302_polysilicon-1##2 net@522#4pin@302_polysilicon-1##3 9.042
R770 net@522#4pin@302_polysilicon-1##3 net@522#4pin@302_polysilicon-1##4 9.042
R771 net@522#4pin@302_polysilicon-1##4 net@522 9.042
R772 net@523#3pin@323_polysilicon-1 net@523#3pin@323_polysilicon-1##0 8.37
R773 net@523#3pin@323_polysilicon-1##0 net@523#3pin@323_polysilicon-1##1 8.37
R774 net@523#3pin@323_polysilicon-1##1 net@523#3pin@323_polysilicon-1##2 8.37
R775 net@523#3pin@323_polysilicon-1##2 net@523#3pin@323_polysilicon-1##3 8.37
R776 net@523#3pin@323_polysilicon-1##3 net@523#6pin@325_polysilicon-1 8.37
R777 S2#27pin@263_polysilicon-1 S2#27pin@263_polysilicon-1##0 9.881
R778 S2#27pin@263_polysilicon-1##0 S2#27pin@263_polysilicon-1##1 9.881
R779 S2#27pin@263_polysilicon-1##1 S2#27pin@263_polysilicon-1##2 9.881
R780 S2#27pin@263_polysilicon-1##2 S2#27pin@263_polysilicon-1##3 9.881
R781 S2#27pin@263_polysilicon-1##3 S2#27pin@263_polysilicon-1##4 9.881
R782 S2#27pin@263_polysilicon-1##4 S2#27pin@263_polysilicon-1##5 9.881
R783 S2#27pin@263_polysilicon-1##5 S2#27pin@263_polysilicon-1##6 9.881
R784 S2#27pin@263_polysilicon-1##6 S2#30pin@342_polysilicon-1 9.881
R785 net@627#2pin@347_polysilicon-1 net@627#2pin@347_polysilicon-1##0 9.042
R786 net@627#2pin@347_polysilicon-1##0 net@627#2pin@347_polysilicon-1##1 9.042
R787 net@627#2pin@347_polysilicon-1##1 net@627#2pin@347_polysilicon-1##2 9.042
R788 net@627#2pin@347_polysilicon-1##2 net@627#2pin@347_polysilicon-1##3 9.042
R789 net@627#2pin@347_polysilicon-1##3 net@627#2pin@347_polysilicon-1##4 9.042
R790 net@627#2pin@347_polysilicon-1##4 net@627 9.042
R791 S2#31nmos@37_poly-right S2#31nmos@37_poly-right##0 7.233
R792 S2#31nmos@37_poly-right##0 S2#31nmos@37_poly-right##1 7.233
R793 S2#31nmos@37_poly-right##1 S2#32pin@333_polysilicon-1 7.233
R794 S2#33nmos@28_poly-right S2#33nmos@28_poly-right##0 7.233
R795 S2#33nmos@28_poly-right##0 S2#33nmos@28_poly-right##1 7.233
R796 S2#33nmos@28_poly-right##1 S2#34pin@258_polysilicon-1 7.233
R797 S2#35pmos@36_poly-left S2#35pmos@36_poly-left##0 6.2
R798 S2#35pmos@36_poly-left##0 S2#36pin@336_polysilicon-1 6.2
R799 S2#36pin@336_polysilicon-1 S2#36pin@336_polysilicon-1##0 9.896
R800 S2#36pin@336_polysilicon-1##0 S2#36pin@336_polysilicon-1##1 9.896
R801 S2#36pin@336_polysilicon-1##1 S2#36pin@336_polysilicon-1##2 9.896
R802 S2#36pin@336_polysilicon-1##2 S2#36pin@336_polysilicon-1##3 9.896
R803 S2#36pin@336_polysilicon-1##3 S2#36pin@336_polysilicon-1##4 9.896
R804 S2#36pin@336_polysilicon-1##4 S2#36pin@336_polysilicon-1##5 9.896
R805 S2#36pin@336_polysilicon-1##5 S2#36pin@336_polysilicon-1##6 9.896
R806 S2#36pin@336_polysilicon-1##6 S2#36pin@336_polysilicon-1##7 9.896
R807 S2#36pin@336_polysilicon-1##7 S2#36pin@336_polysilicon-1##8 9.896
R808 S2#36pin@336_polysilicon-1##8 S2#36pin@336_polysilicon-1##9 9.896
R809 S2#36pin@336_polysilicon-1##9 S2#36pin@336_polysilicon-1##10 9.896
R810 S2#36pin@336_polysilicon-1##10 S2#36pin@336_polysilicon-1##11 9.896
R811 S2#36pin@336_polysilicon-1##11 S2#37pin@337_polysilicon-1 9.896
R812 S2#37pin@337_polysilicon-1 S2#37pin@337_polysilicon-1##0 9.521
R813 S2#37pin@337_polysilicon-1##0 S2#37pin@337_polysilicon-1##1 9.521
R814 S2#37pin@337_polysilicon-1##1 S2#37pin@337_polysilicon-1##2 9.521
R815 S2#37pin@337_polysilicon-1##2 S2#37pin@337_polysilicon-1##3 9.521
R816 S2#37pin@337_polysilicon-1##3 S2#37pin@337_polysilicon-1##4 9.521
R817 S2#37pin@337_polysilicon-1##4 S2#37pin@337_polysilicon-1##5 9.521
R818 S2#37pin@337_polysilicon-1##5 S2#27pin@263_polysilicon-1 9.521
R819 S2#32pin@333_polysilicon-1 S2#32pin@333_polysilicon-1##0 5.425
R820 S2#32pin@333_polysilicon-1##0 S2#39pmos@37_poly-right 5.425
R821 net@517#2pmos@26_poly-left net@517#3pin@246_polysilicon-1 7.75
R822 net@523#11nmos@33_poly-right net@523#11nmos@33_poly-right##0 6.2
R823 net@523#11nmos@33_poly-right##0 net@523#6pin@325_polysilicon-1 6.2
R824 net@627#6pin@345_polysilicon-1 net@627#6pin@345_polysilicon-1##0 8.37
R825 net@627#6pin@345_polysilicon-1##0 net@627#6pin@345_polysilicon-1##1 8.37
R826 net@627#6pin@345_polysilicon-1##1 net@627#6pin@345_polysilicon-1##2 8.37
R827 net@627#6pin@345_polysilicon-1##2 net@627#6pin@345_polysilicon-1##3 8.37
R828 net@627#6pin@345_polysilicon-1##3 net@627#2pin@347_polysilicon-1 8.37
R829 S2#41pmos@27_poly-left S2#41pmos@27_poly-left##0 6.2
R830 S2#41pmos@27_poly-left##0 S2#42pin@261_polysilicon-1 6.2
R831 S1#76nmos@31_poly-right S1#76nmos@31_poly-right##0 7.233
R832 S1#76nmos@31_poly-right##0 S1#76nmos@31_poly-right##1 7.233
R833 S1#76nmos@31_poly-right##1 S1#65pin@287_polysilicon-1 7.233
R834 net@627#8nmos@36_poly-right net@627#8nmos@36_poly-right##0 6.2
R835 net@627#8nmos@36_poly-right##0 net@627#2pin@347_polysilicon-1 6.2
R836 S1#77pmos@30_poly-left S1#77pmos@30_poly-left##0 6.2
R837 S1#77pmos@30_poly-left##0 S1#78pin@290_polysilicon-1 6.2
R838 S2#43nmos@38_poly-left S2#43nmos@38_poly-left##0 6.975
R839 S2#43nmos@38_poly-left##0 S2#44pin@341_polysilicon-1 6.975
R840 S2#44pin@341_polysilicon-1 S2#44pin@341_polysilicon-1##0 9.772
R841 S2#44pin@341_polysilicon-1##0 S2#44pin@341_polysilicon-1##1 9.772
R842 S2#44pin@341_polysilicon-1##1 S2#44pin@341_polysilicon-1##2 9.772
R843 S2#44pin@341_polysilicon-1##2 S2#44pin@341_polysilicon-1##3 9.772
R844 S2#44pin@341_polysilicon-1##3 S2#44pin@341_polysilicon-1##4 9.772
R845 S2#44pin@341_polysilicon-1##4 S2#44pin@341_polysilicon-1##5 9.772
R846 S2#44pin@341_polysilicon-1##5 S2#44pin@341_polysilicon-1##6 9.772
R847 S2#44pin@341_polysilicon-1##6 S2#44pin@341_polysilicon-1##7 9.772
R848 S2#44pin@341_polysilicon-1##7 S2#44pin@341_polysilicon-1##8 9.772
R849 S2#44pin@341_polysilicon-1##8 S2#44pin@341_polysilicon-1##9 9.772
R850 S2#44pin@341_polysilicon-1##9 S2#44pin@341_polysilicon-1##10 9.772
R851 S2#44pin@341_polysilicon-1##10 S2#44pin@341_polysilicon-1##11 9.772
R852 S2#44pin@341_polysilicon-1##11 S2#44pin@341_polysilicon-1##12 9.772
R853 S2#44pin@341_polysilicon-1##12 S2#44pin@341_polysilicon-1##13 9.772
R854 S2#44pin@341_polysilicon-1##13 S2#44pin@341_polysilicon-1##14 9.772
R855 S2#44pin@341_polysilicon-1##14 S2#44pin@341_polysilicon-1##15 9.772
R856 S2#44pin@341_polysilicon-1##15 S2#44pin@341_polysilicon-1##16 9.772
R857 S2#44pin@341_polysilicon-1##16 S2#44pin@341_polysilicon-1##17 9.772
R858 S2#44pin@341_polysilicon-1##17 S2#44pin@341_polysilicon-1##18 9.772
R859 S2#44pin@341_polysilicon-1##18 S2#44pin@341_polysilicon-1##19 9.772
R860 S2#44pin@341_polysilicon-1##19 S2#44pin@341_polysilicon-1##20 9.772
R861 S2#44pin@341_polysilicon-1##20 S2#44pin@341_polysilicon-1##21 9.772
R862 S2#44pin@341_polysilicon-1##21 S2#30pin@342_polysilicon-1 9.772
R863 S2#27pin@263_polysilicon-1 S2#27pin@263_polysilicon-1##0 8.267
R864 S2#27pin@263_polysilicon-1##0 S2#27pin@263_polysilicon-1##1 8.267
R865 S2#27pin@263_polysilicon-1##1 S2#32pin@333_polysilicon-1 8.267
R866 net@627#9pmos@38_poly-left net@627#10pin@343_polysilicon-1 7.75
R867 S1#79nmos@35_poly-left S1#79nmos@35_poly-left##0 6.975
R868 S1#79nmos@35_poly-left##0 S1#80pin@319_polysilicon-1 6.975
R869 S2#42pin@261_polysilicon-1 S2#42pin@261_polysilicon-1##0 9.896
R870 S2#42pin@261_polysilicon-1##0 S2#42pin@261_polysilicon-1##1 9.896
R871 S2#42pin@261_polysilicon-1##1 S2#42pin@261_polysilicon-1##2 9.896
R872 S2#42pin@261_polysilicon-1##2 S2#42pin@261_polysilicon-1##3 9.896
R873 S2#42pin@261_polysilicon-1##3 S2#42pin@261_polysilicon-1##4 9.896
R874 S2#42pin@261_polysilicon-1##4 S2#42pin@261_polysilicon-1##5 9.896
R875 S2#42pin@261_polysilicon-1##5 S2#42pin@261_polysilicon-1##6 9.896
R876 S2#42pin@261_polysilicon-1##6 S2#42pin@261_polysilicon-1##7 9.896
R877 S2#42pin@261_polysilicon-1##7 S2#42pin@261_polysilicon-1##8 9.896
R878 S2#42pin@261_polysilicon-1##8 S2#42pin@261_polysilicon-1##9 9.896
R879 S2#42pin@261_polysilicon-1##9 S2#42pin@261_polysilicon-1##10 9.896
R880 S2#42pin@261_polysilicon-1##10 S2#42pin@261_polysilicon-1##11 9.896
R881 S2#42pin@261_polysilicon-1##11 S2#45pin@262_polysilicon-1 9.896
R882 net@627#10pin@343_polysilicon-1 net@627#10pin@343_polysilicon-1##0 9.042
R883 net@627#10pin@343_polysilicon-1##0 net@627#10pin@343_polysilicon-1##1 9.042
R884 net@627#10pin@343_polysilicon-1##1 net@627#10pin@343_polysilicon-1##2 9.042
R885 net@627#10pin@343_polysilicon-1##2 net@627#10pin@343_polysilicon-1##3 9.042
R886 net@627#10pin@343_polysilicon-1##3 net@627#10pin@343_polysilicon-1##4 9.042
R887 net@627#10pin@343_polysilicon-1##4 net@627#11pin@344_polysilicon-1 9.042
R888 net@627#11pin@344_polysilicon-1 net@627#11pin@344_polysilicon-1##0 9.3
R889 net@627#11pin@344_polysilicon-1##0 net@627#11pin@344_polysilicon-1##1 9.3
R890 net@627#11pin@344_polysilicon-1##1 net@627#11pin@344_polysilicon-1##2 9.3
R891 net@627#11pin@344_polysilicon-1##2 net@627#11pin@344_polysilicon-1##3 9.3
R892 net@627#11pin@344_polysilicon-1##3 net@627#11pin@344_polysilicon-1##4 9.3
R893 net@627#11pin@344_polysilicon-1##4 net@627#11pin@344_polysilicon-1##5 9.3
R894 net@627#11pin@344_polysilicon-1##5 net@627#11pin@344_polysilicon-1##6 9.3
R895 net@627#11pin@344_polysilicon-1##6 net@627#6pin@345_polysilicon-1 9.3
R896 S1#78pin@290_polysilicon-1 S1#78pin@290_polysilicon-1##0 9.896
R897 S1#78pin@290_polysilicon-1##0 S1#78pin@290_polysilicon-1##1 9.896
R898 S1#78pin@290_polysilicon-1##1 S1#78pin@290_polysilicon-1##2 9.896
R899 S1#78pin@290_polysilicon-1##2 S1#78pin@290_polysilicon-1##3 9.896
R900 S1#78pin@290_polysilicon-1##3 S1#78pin@290_polysilicon-1##4 9.896
R901 S1#78pin@290_polysilicon-1##4 S1#78pin@290_polysilicon-1##5 9.896
R902 S1#78pin@290_polysilicon-1##5 S1#78pin@290_polysilicon-1##6 9.896
R903 S1#78pin@290_polysilicon-1##6 S1#78pin@290_polysilicon-1##7 9.896
R904 S1#78pin@290_polysilicon-1##7 S1#78pin@290_polysilicon-1##8 9.896
R905 S1#78pin@290_polysilicon-1##8 S1#78pin@290_polysilicon-1##9 9.896
R906 S1#78pin@290_polysilicon-1##9 S1#78pin@290_polysilicon-1##10 9.896
R907 S1#78pin@290_polysilicon-1##10 S1#78pin@290_polysilicon-1##11 9.896
R908 S1#78pin@290_polysilicon-1##11 S1#81pin@291_polysilicon-1 9.896
R909 S1#81pin@291_polysilicon-1 S1#81pin@291_polysilicon-1##0 9.521
R910 S1#81pin@291_polysilicon-1##0 S1#81pin@291_polysilicon-1##1 9.521
R911 S1#81pin@291_polysilicon-1##1 S1#81pin@291_polysilicon-1##2 9.521
R912 S1#81pin@291_polysilicon-1##2 S1#81pin@291_polysilicon-1##3 9.521
R913 S1#81pin@291_polysilicon-1##3 S1#81pin@291_polysilicon-1##4 9.521
R914 S1#81pin@291_polysilicon-1##4 S1#81pin@291_polysilicon-1##5 9.521
R915 S1#81pin@291_polysilicon-1##5 S1#56contact@262_metal-1-metal-2 9.521
R916 S2#45pin@262_polysilicon-1 S2#45pin@262_polysilicon-1##0 9.521
R917 S2#45pin@262_polysilicon-1##0 S2#45pin@262_polysilicon-1##1 9.521
R918 S2#45pin@262_polysilicon-1##1 S2#45pin@262_polysilicon-1##2 9.521
R919 S2#45pin@262_polysilicon-1##2 S2#45pin@262_polysilicon-1##3 9.521
R920 S2#45pin@262_polysilicon-1##3 S2#45pin@262_polysilicon-1##4 9.521
R921 S2#45pin@262_polysilicon-1##4 S2#45pin@262_polysilicon-1##5 9.521
R922 S2#45pin@262_polysilicon-1##5 S2#27pin@263_polysilicon-1 9.521
R923 S1#80pin@319_polysilicon-1 S1#80pin@319_polysilicon-1##0 9.772
R924 S1#80pin@319_polysilicon-1##0 S1#80pin@319_polysilicon-1##1 9.772
R925 S1#80pin@319_polysilicon-1##1 S1#80pin@319_polysilicon-1##2 9.772
R926 S1#80pin@319_polysilicon-1##2 S1#80pin@319_polysilicon-1##3 9.772
R927 S1#80pin@319_polysilicon-1##3 S1#80pin@319_polysilicon-1##4 9.772
R928 S1#80pin@319_polysilicon-1##4 S1#80pin@319_polysilicon-1##5 9.772
R929 S1#80pin@319_polysilicon-1##5 S1#80pin@319_polysilicon-1##6 9.772
R930 S1#80pin@319_polysilicon-1##6 S1#80pin@319_polysilicon-1##7 9.772
R931 S1#80pin@319_polysilicon-1##7 S1#80pin@319_polysilicon-1##8 9.772
R932 S1#80pin@319_polysilicon-1##8 S1#80pin@319_polysilicon-1##9 9.772
R933 S1#80pin@319_polysilicon-1##9 S1#80pin@319_polysilicon-1##10 9.772
R934 S1#80pin@319_polysilicon-1##10 S1#80pin@319_polysilicon-1##11 9.772
R935 S1#80pin@319_polysilicon-1##11 S1#80pin@319_polysilicon-1##12 9.772
R936 S1#80pin@319_polysilicon-1##12 S1#80pin@319_polysilicon-1##13 9.772
R937 S1#80pin@319_polysilicon-1##13 S1#80pin@319_polysilicon-1##14 9.772
R938 S1#80pin@319_polysilicon-1##14 S1#80pin@319_polysilicon-1##15 9.772
R939 S1#80pin@319_polysilicon-1##15 S1#80pin@319_polysilicon-1##16 9.772
R940 S1#80pin@319_polysilicon-1##16 S1#80pin@319_polysilicon-1##17 9.772
R941 S1#80pin@319_polysilicon-1##17 S1#80pin@319_polysilicon-1##18 9.772
R942 S1#80pin@319_polysilicon-1##18 S1#80pin@319_polysilicon-1##19 9.772
R943 S1#80pin@319_polysilicon-1##19 S1#80pin@319_polysilicon-1##20 9.772
R944 S1#80pin@319_polysilicon-1##20 S1#80pin@319_polysilicon-1##21 9.772
R945 S1#80pin@319_polysilicon-1##21 S1#67pin@320_polysilicon-1 9.772
R946 S1#65pin@287_polysilicon-1 S1#65pin@287_polysilicon-1##0 5.425
R947 S1#65pin@287_polysilicon-1##0 S1#82pmos@31_poly-right 5.425
R948 S1#56contact@262_metal-1-metal-2 S1#56contact@262_metal-1-metal-2##0 8.267
R949 S1#56contact@262_metal-1-metal-2##0 S1#56contact@262_metal-1-metal-2##1 8.267
R950 S1#56contact@262_metal-1-metal-2##1 S1#70pin@310_polysilicon-1 8.267
R951 S2#34pin@258_polysilicon-1 S2#34pin@258_polysilicon-1##0 5.425
R952 S2#34pin@258_polysilicon-1##0 S2#49pmos@28_poly-right 5.425
R953 net@780#4pin@384_polysilicon-1 net@780#4pin@384_polysilicon-1##0 8.37
R954 net@780#4pin@384_polysilicon-1##0 net@780#4pin@384_polysilicon-1##1 8.37
R955 net@780#4pin@384_polysilicon-1##1 net@780#4pin@384_polysilicon-1##2 8.37
R956 net@780#4pin@384_polysilicon-1##2 net@780#4pin@384_polysilicon-1##3 8.37
R957 net@780#4pin@384_polysilicon-1##3 net@780#5pin@386_polysilicon-1 8.37
R958 net@517#3pin@246_polysilicon-1 net@517#3pin@246_polysilicon-1##0 9.042
R959 net@517#3pin@246_polysilicon-1##0 net@517#3pin@246_polysilicon-1##1 9.042
R960 net@517#3pin@246_polysilicon-1##1 net@517#3pin@246_polysilicon-1##2 9.042
R961 net@517#3pin@246_polysilicon-1##2 net@517#3pin@246_polysilicon-1##3 9.042
R962 net@517#3pin@246_polysilicon-1##3 net@517#3pin@246_polysilicon-1##4 9.042
R963 net@517#3pin@246_polysilicon-1##4 net@517#4pin@247_polysilicon-1 9.042
R964 net@780#6nmos@39_poly-right net@780#6nmos@39_poly-right##0 6.2
R965 net@780#6nmos@39_poly-right##0 net@780#5pin@386_polysilicon-1 6.2
R966 S0#16pin@376_polysilicon-1 S0#16pin@376_polysilicon-1##0 9.881
R967 S0#16pin@376_polysilicon-1##0 S0#16pin@376_polysilicon-1##1 9.881
R968 S0#16pin@376_polysilicon-1##1 S0#16pin@376_polysilicon-1##2 9.881
R969 S0#16pin@376_polysilicon-1##2 S0#16pin@376_polysilicon-1##3 9.881
R970 S0#16pin@376_polysilicon-1##3 S0#16pin@376_polysilicon-1##4 9.881
R971 S0#16pin@376_polysilicon-1##4 S0#16pin@376_polysilicon-1##5 9.881
R972 S0#16pin@376_polysilicon-1##5 S0#16pin@376_polysilicon-1##6 9.881
R973 S0#16pin@376_polysilicon-1##6 S0#17pin@381_polysilicon-1 9.881
R974 net@780#5pin@386_polysilicon-1 net@780#5pin@386_polysilicon-1##0 9.042
R975 net@780#5pin@386_polysilicon-1##0 net@780#5pin@386_polysilicon-1##1 9.042
R976 net@780#5pin@386_polysilicon-1##1 net@780#5pin@386_polysilicon-1##2 9.042
R977 net@780#5pin@386_polysilicon-1##2 net@780#5pin@386_polysilicon-1##3 9.042
R978 net@780#5pin@386_polysilicon-1##3 net@780#5pin@386_polysilicon-1##4 9.042
R979 net@780#5pin@386_polysilicon-1##4 net@780 9.042
R980 S0#18nmos@40_poly-right S0#18nmos@40_poly-right##0 7.233
R981 S0#18nmos@40_poly-right##0 S0#18nmos@40_poly-right##1 7.233
R982 S0#18nmos@40_poly-right##1 S0#19pin@371_polysilicon-1 7.233
R983 S0#20pmos@39_poly-left S0#20pmos@39_poly-left##0 6.2
R984 S0#20pmos@39_poly-left##0 S0#21pin@374_polysilicon-1 6.2
R985 S0#21pin@374_polysilicon-1 S0#21pin@374_polysilicon-1##0 9.896
R986 S0#21pin@374_polysilicon-1##0 S0#21pin@374_polysilicon-1##1 9.896
R987 S0#21pin@374_polysilicon-1##1 S0#21pin@374_polysilicon-1##2 9.896
R988 S0#21pin@374_polysilicon-1##2 S0#21pin@374_polysilicon-1##3 9.896
R989 S0#21pin@374_polysilicon-1##3 S0#21pin@374_polysilicon-1##4 9.896
R990 S0#21pin@374_polysilicon-1##4 S0#21pin@374_polysilicon-1##5 9.896
R991 S0#21pin@374_polysilicon-1##5 S0#21pin@374_polysilicon-1##6 9.896
R992 S0#21pin@374_polysilicon-1##6 S0#21pin@374_polysilicon-1##7 9.896
R993 S0#21pin@374_polysilicon-1##7 S0#21pin@374_polysilicon-1##8 9.896
R994 S0#21pin@374_polysilicon-1##8 S0#21pin@374_polysilicon-1##9 9.896
R995 S0#21pin@374_polysilicon-1##9 S0#21pin@374_polysilicon-1##10 9.896
R996 S0#21pin@374_polysilicon-1##10 S0#21pin@374_polysilicon-1##11 9.896
R997 S0#21pin@374_polysilicon-1##11 S0#22pin@375_polysilicon-1 9.896
R998 S0#22pin@375_polysilicon-1 S0#22pin@375_polysilicon-1##0 9.521
R999 S0#22pin@375_polysilicon-1##0 S0#22pin@375_polysilicon-1##1 9.521
R1000 S0#22pin@375_polysilicon-1##1 S0#22pin@375_polysilicon-1##2 9.521
R1001 S0#22pin@375_polysilicon-1##2 S0#22pin@375_polysilicon-1##3 9.521
R1002 S0#22pin@375_polysilicon-1##3 S0#22pin@375_polysilicon-1##4 9.521
R1003 S0#22pin@375_polysilicon-1##4 S0#22pin@375_polysilicon-1##5 9.521
R1004 S0#22pin@375_polysilicon-1##5 S0#16pin@376_polysilicon-1 9.521
R1005 S0#19pin@371_polysilicon-1 S0#19pin@371_polysilicon-1##0 5.425
R1006 S0#19pin@371_polysilicon-1##0 S0#24pmos@40_poly-right 5.425
R1007 S0#26nmos@41_poly-left S0#26nmos@41_poly-left##0 6.975
R1008 S0#26nmos@41_poly-left##0 S0#27pin@380_polysilicon-1 6.975
R1009 S0#27pin@380_polysilicon-1 S0#27pin@380_polysilicon-1##0 9.772
R1010 S0#27pin@380_polysilicon-1##0 S0#27pin@380_polysilicon-1##1 9.772
R1011 S0#27pin@380_polysilicon-1##1 S0#27pin@380_polysilicon-1##2 9.772
R1012 S0#27pin@380_polysilicon-1##2 S0#27pin@380_polysilicon-1##3 9.772
R1013 S0#27pin@380_polysilicon-1##3 S0#27pin@380_polysilicon-1##4 9.772
R1014 S0#27pin@380_polysilicon-1##4 S0#27pin@380_polysilicon-1##5 9.772
R1015 S0#27pin@380_polysilicon-1##5 S0#27pin@380_polysilicon-1##6 9.772
R1016 S0#27pin@380_polysilicon-1##6 S0#27pin@380_polysilicon-1##7 9.772
R1017 S0#27pin@380_polysilicon-1##7 S0#27pin@380_polysilicon-1##8 9.772
R1018 S0#27pin@380_polysilicon-1##8 S0#27pin@380_polysilicon-1##9 9.772
R1019 S0#27pin@380_polysilicon-1##9 S0#27pin@380_polysilicon-1##10 9.772
R1020 S0#27pin@380_polysilicon-1##10 S0#27pin@380_polysilicon-1##11 9.772
R1021 S0#27pin@380_polysilicon-1##11 S0#27pin@380_polysilicon-1##12 9.772
R1022 S0#27pin@380_polysilicon-1##12 S0#27pin@380_polysilicon-1##13 9.772
R1023 S0#27pin@380_polysilicon-1##13 S0#27pin@380_polysilicon-1##14 9.772
R1024 S0#27pin@380_polysilicon-1##14 S0#27pin@380_polysilicon-1##15 9.772
R1025 S0#27pin@380_polysilicon-1##15 S0#27pin@380_polysilicon-1##16 9.772
R1026 S0#27pin@380_polysilicon-1##16 S0#27pin@380_polysilicon-1##17 9.772
R1027 S0#27pin@380_polysilicon-1##17 S0#27pin@380_polysilicon-1##18 9.772
R1028 S0#27pin@380_polysilicon-1##18 S0#27pin@380_polysilicon-1##19 9.772
R1029 S0#27pin@380_polysilicon-1##19 S0#27pin@380_polysilicon-1##20 9.772
R1030 S0#27pin@380_polysilicon-1##20 S0#27pin@380_polysilicon-1##21 9.772
R1031 S0#27pin@380_polysilicon-1##21 S0#17pin@381_polysilicon-1 9.772
R1032 S0#16pin@376_polysilicon-1 S0#16pin@376_polysilicon-1##0 8.267
R1033 S0#16pin@376_polysilicon-1##0 S0#16pin@376_polysilicon-1##1 8.267
R1034 S0#16pin@376_polysilicon-1##1 S0#19pin@371_polysilicon-1 8.267
R1035 net@780#9pmos@41_poly-left net@780#10pin@382_polysilicon-1 7.75
R1036 net@780#10pin@382_polysilicon-1 net@780#10pin@382_polysilicon-1##0 9.042
R1037 net@780#10pin@382_polysilicon-1##0 net@780#10pin@382_polysilicon-1##1 9.042
R1038 net@780#10pin@382_polysilicon-1##1 net@780#10pin@382_polysilicon-1##2 9.042
R1039 net@780#10pin@382_polysilicon-1##2 net@780#10pin@382_polysilicon-1##3 9.042
R1040 net@780#10pin@382_polysilicon-1##3 net@780#10pin@382_polysilicon-1##4 9.042
R1041 net@780#10pin@382_polysilicon-1##4 net@780#11pin@383_polysilicon-1 9.042
R1042 net@780#11pin@383_polysilicon-1 net@780#11pin@383_polysilicon-1##0 9.3
R1043 net@780#11pin@383_polysilicon-1##0 net@780#11pin@383_polysilicon-1##1 9.3
R1044 net@780#11pin@383_polysilicon-1##1 net@780#11pin@383_polysilicon-1##2 9.3
R1045 net@780#11pin@383_polysilicon-1##2 net@780#11pin@383_polysilicon-1##3 9.3
R1046 net@780#11pin@383_polysilicon-1##3 net@780#11pin@383_polysilicon-1##4 9.3
R1047 net@780#11pin@383_polysilicon-1##4 net@780#11pin@383_polysilicon-1##5 9.3
R1048 net@780#11pin@383_polysilicon-1##5 net@780#11pin@383_polysilicon-1##6 9.3
R1049 net@780#11pin@383_polysilicon-1##6 net@780#4pin@384_polysilicon-1 9.3
R1050 net@517#5nmos@24_poly-right net@517#5nmos@24_poly-right##0 6.2
R1051 net@517#5nmos@24_poly-right##0 net@517#6pin@250_polysilicon-1 6.2
R1052 net@514#6pin@270_polysilicon-1 net@514#6pin@270_polysilicon-1##0 8.37
R1053 net@514#6pin@270_polysilicon-1##0 net@514#6pin@270_polysilicon-1##1 8.37
R1054 net@514#6pin@270_polysilicon-1##1 net@514#6pin@270_polysilicon-1##2 8.37
R1055 net@514#6pin@270_polysilicon-1##2 net@514#6pin@270_polysilicon-1##3 8.37
R1056 net@514#6pin@270_polysilicon-1##3 net@514#2pin@272_polysilicon-1 8.37
R1057 S0#16pin@376_polysilicon-1 S0 4.238
R1058 S1#92nmos@22_poly-right S1#92nmos@22_poly-right##0 7.233
R1059 S1#92nmos@22_poly-right##0 S1#92nmos@22_poly-right##1 7.233
R1060 S1#92nmos@22_poly-right##1 S1#93pin@212_polysilicon-1 7.233
R1061 net@514#8nmos@27_poly-right net@514#8nmos@27_poly-right##0 6.2
R1062 net@514#8nmos@27_poly-right##0 net@514#2pin@272_polysilicon-1 6.2
R1063 S1#94pmos@21_poly-left S1#94pmos@21_poly-left##0 6.2
R1064 S1#94pmos@21_poly-left##0 S1#95pin@215_polysilicon-1 6.2
R1065 S2#53nmos@29_poly-left S2#53nmos@29_poly-left##0 6.975
R1066 S2#53nmos@29_poly-left##0 S2#54pin@266_polysilicon-1 6.975
R1067 S2#54pin@266_polysilicon-1 S2#54pin@266_polysilicon-1##0 9.772
R1068 S2#54pin@266_polysilicon-1##0 S2#54pin@266_polysilicon-1##1 9.772
R1069 S2#54pin@266_polysilicon-1##1 S2#54pin@266_polysilicon-1##2 9.772
R1070 S2#54pin@266_polysilicon-1##2 S2#54pin@266_polysilicon-1##3 9.772
R1071 S2#54pin@266_polysilicon-1##3 S2#54pin@266_polysilicon-1##4 9.772
R1072 S2#54pin@266_polysilicon-1##4 S2#54pin@266_polysilicon-1##5 9.772
R1073 S2#54pin@266_polysilicon-1##5 S2#54pin@266_polysilicon-1##6 9.772
R1074 S2#54pin@266_polysilicon-1##6 S2#54pin@266_polysilicon-1##7 9.772
R1075 S2#54pin@266_polysilicon-1##7 S2#54pin@266_polysilicon-1##8 9.772
R1076 S2#54pin@266_polysilicon-1##8 S2#54pin@266_polysilicon-1##9 9.772
R1077 S2#54pin@266_polysilicon-1##9 S2#54pin@266_polysilicon-1##10 9.772
R1078 S2#54pin@266_polysilicon-1##10 S2#54pin@266_polysilicon-1##11 9.772
R1079 S2#54pin@266_polysilicon-1##11 S2#54pin@266_polysilicon-1##12 9.772
R1080 S2#54pin@266_polysilicon-1##12 S2#54pin@266_polysilicon-1##13 9.772
R1081 S2#54pin@266_polysilicon-1##13 S2#54pin@266_polysilicon-1##14 9.772
R1082 S2#54pin@266_polysilicon-1##14 S2#54pin@266_polysilicon-1##15 9.772
R1083 S2#54pin@266_polysilicon-1##15 S2#54pin@266_polysilicon-1##16 9.772
R1084 S2#54pin@266_polysilicon-1##16 S2#54pin@266_polysilicon-1##17 9.772
R1085 S2#54pin@266_polysilicon-1##17 S2#54pin@266_polysilicon-1##18 9.772
R1086 S2#54pin@266_polysilicon-1##18 S2#54pin@266_polysilicon-1##19 9.772
R1087 S2#54pin@266_polysilicon-1##19 S2#54pin@266_polysilicon-1##20 9.772
R1088 S2#54pin@266_polysilicon-1##20 S2#54pin@266_polysilicon-1##21 9.772
R1089 S2#54pin@266_polysilicon-1##21 S2#28pin@267_polysilicon-1 9.772
R1090 S2#27pin@263_polysilicon-1 S2#27pin@263_polysilicon-1##0 8.267
R1091 S2#27pin@263_polysilicon-1##0 S2#27pin@263_polysilicon-1##1 8.267
R1092 S2#27pin@263_polysilicon-1##1 S2#34pin@258_polysilicon-1 8.267
R1093 net@514#9pmos@29_poly-left net@514#10pin@268_polysilicon-1 7.75
R1094 S1#96nmos@26_poly-left S1#96nmos@26_poly-left##0 6.975
R1095 S1#96nmos@26_poly-left##0 S1#97pin@244_polysilicon-1 6.975
R1096 net@514#10pin@268_polysilicon-1 net@514#10pin@268_polysilicon-1##0 9.042
R1097 net@514#10pin@268_polysilicon-1##0 net@514#10pin@268_polysilicon-1##1 9.042
R1098 net@514#10pin@268_polysilicon-1##1 net@514#10pin@268_polysilicon-1##2 9.042
R1099 net@514#10pin@268_polysilicon-1##2 net@514#10pin@268_polysilicon-1##3 9.042
R1100 net@514#10pin@268_polysilicon-1##3 net@514#10pin@268_polysilicon-1##4 9.042
R1101 net@514#10pin@268_polysilicon-1##4 net@514#11pin@269_polysilicon-1 9.042
R1102 net@514#11pin@269_polysilicon-1 net@514#11pin@269_polysilicon-1##0 9.3
R1103 net@514#11pin@269_polysilicon-1##0 net@514#11pin@269_polysilicon-1##1 9.3
R1104 net@514#11pin@269_polysilicon-1##1 net@514#11pin@269_polysilicon-1##2 9.3
R1105 net@514#11pin@269_polysilicon-1##2 net@514#11pin@269_polysilicon-1##3 9.3
R1106 net@514#11pin@269_polysilicon-1##3 net@514#11pin@269_polysilicon-1##4 9.3
R1107 net@514#11pin@269_polysilicon-1##4 net@514#11pin@269_polysilicon-1##5 9.3
R1108 net@514#11pin@269_polysilicon-1##5 net@514#11pin@269_polysilicon-1##6 9.3
R1109 net@514#11pin@269_polysilicon-1##6 net@514#6pin@270_polysilicon-1 9.3
R1110 net@517#4pin@247_polysilicon-1 net@517#4pin@247_polysilicon-1##0 9.3
R1111 net@517#4pin@247_polysilicon-1##0 net@517#4pin@247_polysilicon-1##1 9.3
R1112 net@517#4pin@247_polysilicon-1##1 net@517#4pin@247_polysilicon-1##2 9.3
R1113 net@517#4pin@247_polysilicon-1##2 net@517#4pin@247_polysilicon-1##3 9.3
R1114 net@517#4pin@247_polysilicon-1##3 net@517#4pin@247_polysilicon-1##4 9.3
R1115 net@517#4pin@247_polysilicon-1##4 net@517#4pin@247_polysilicon-1##5 9.3
R1116 net@517#4pin@247_polysilicon-1##5 net@517#4pin@247_polysilicon-1##6 9.3
R1117 net@517#4pin@247_polysilicon-1##6 net@517#7pin@248_polysilicon-1 9.3
R1118 S1#95pin@215_polysilicon-1 S1#95pin@215_polysilicon-1##0 9.896
R1119 S1#95pin@215_polysilicon-1##0 S1#95pin@215_polysilicon-1##1 9.896
R1120 S1#95pin@215_polysilicon-1##1 S1#95pin@215_polysilicon-1##2 9.896
R1121 S1#95pin@215_polysilicon-1##2 S1#95pin@215_polysilicon-1##3 9.896
R1122 S1#95pin@215_polysilicon-1##3 S1#95pin@215_polysilicon-1##4 9.896
R1123 S1#95pin@215_polysilicon-1##4 S1#95pin@215_polysilicon-1##5 9.896
R1124 S1#95pin@215_polysilicon-1##5 S1#95pin@215_polysilicon-1##6 9.896
R1125 S1#95pin@215_polysilicon-1##6 S1#95pin@215_polysilicon-1##7 9.896
R1126 S1#95pin@215_polysilicon-1##7 S1#95pin@215_polysilicon-1##8 9.896
R1127 S1#95pin@215_polysilicon-1##8 S1#95pin@215_polysilicon-1##9 9.896
R1128 S1#95pin@215_polysilicon-1##9 S1#95pin@215_polysilicon-1##10 9.896
R1129 S1#95pin@215_polysilicon-1##10 S1#95pin@215_polysilicon-1##11 9.896
R1130 S1#95pin@215_polysilicon-1##11 S1#98pin@216_polysilicon-1 9.896
R1131 S1#98pin@216_polysilicon-1 S1#98pin@216_polysilicon-1##0 9.521
R1132 S1#98pin@216_polysilicon-1##0 S1#98pin@216_polysilicon-1##1 9.521
R1133 S1#98pin@216_polysilicon-1##1 S1#98pin@216_polysilicon-1##2 9.521
R1134 S1#98pin@216_polysilicon-1##2 S1#98pin@216_polysilicon-1##3 9.521
R1135 S1#98pin@216_polysilicon-1##3 S1#98pin@216_polysilicon-1##4 9.521
R1136 S1#98pin@216_polysilicon-1##4 S1#98pin@216_polysilicon-1##5 9.521
R1137 S1#98pin@216_polysilicon-1##5 S1#56contact@262_metal-1-metal-2 9.521
R1138 S1#97pin@244_polysilicon-1 S1#97pin@244_polysilicon-1##0 9.772
R1139 S1#97pin@244_polysilicon-1##0 S1#97pin@244_polysilicon-1##1 9.772
R1140 S1#97pin@244_polysilicon-1##1 S1#97pin@244_polysilicon-1##2 9.772
R1141 S1#97pin@244_polysilicon-1##2 S1#97pin@244_polysilicon-1##3 9.772
R1142 S1#97pin@244_polysilicon-1##3 S1#97pin@244_polysilicon-1##4 9.772
R1143 S1#97pin@244_polysilicon-1##4 S1#97pin@244_polysilicon-1##5 9.772
R1144 S1#97pin@244_polysilicon-1##5 S1#97pin@244_polysilicon-1##6 9.772
R1145 S1#97pin@244_polysilicon-1##6 S1#97pin@244_polysilicon-1##7 9.772
R1146 S1#97pin@244_polysilicon-1##7 S1#97pin@244_polysilicon-1##8 9.772
R1147 S1#97pin@244_polysilicon-1##8 S1#97pin@244_polysilicon-1##9 9.772
R1148 S1#97pin@244_polysilicon-1##9 S1#97pin@244_polysilicon-1##10 9.772
R1149 S1#97pin@244_polysilicon-1##10 S1#97pin@244_polysilicon-1##11 9.772
R1150 S1#97pin@244_polysilicon-1##11 S1#97pin@244_polysilicon-1##12 9.772
R1151 S1#97pin@244_polysilicon-1##12 S1#97pin@244_polysilicon-1##13 9.772
R1152 S1#97pin@244_polysilicon-1##13 S1#97pin@244_polysilicon-1##14 9.772
R1153 S1#97pin@244_polysilicon-1##14 S1#97pin@244_polysilicon-1##15 9.772
R1154 S1#97pin@244_polysilicon-1##15 S1#97pin@244_polysilicon-1##16 9.772
R1155 S1#97pin@244_polysilicon-1##16 S1#97pin@244_polysilicon-1##17 9.772
R1156 S1#97pin@244_polysilicon-1##17 S1#97pin@244_polysilicon-1##18 9.772
R1157 S1#97pin@244_polysilicon-1##18 S1#97pin@244_polysilicon-1##19 9.772
R1158 S1#97pin@244_polysilicon-1##19 S1#97pin@244_polysilicon-1##20 9.772
R1159 S1#97pin@244_polysilicon-1##20 S1#97pin@244_polysilicon-1##21 9.772
R1160 S1#97pin@244_polysilicon-1##21 S1#100pin@245_polysilicon-1 9.772
R1161 S1#93pin@212_polysilicon-1 S1#93pin@212_polysilicon-1##0 5.425
R1162 S1#93pin@212_polysilicon-1##0 S1#101pmos@22_poly-right 5.425
R1163 S1#56contact@262_metal-1-metal-2 S1#56contact@262_metal-1-metal-2##0 8.267
R1164 S1#56contact@262_metal-1-metal-2##0 S1#56contact@262_metal-1-metal-2##1 8.267
R1165 S1#56contact@262_metal-1-metal-2##1 S1#103pin@235_polysilicon-1 8.267
R1166 net@556#5pin@225_polysilicon-1 net@556#5pin@225_polysilicon-1##0 8.37
R1167 net@556#5pin@225_polysilicon-1##0 net@556#5pin@225_polysilicon-1##1 8.37
R1168 net@556#5pin@225_polysilicon-1##1 net@556#5pin@225_polysilicon-1##2 8.37
R1169 net@556#5pin@225_polysilicon-1##2 net@556#5pin@225_polysilicon-1##3 8.37
R1170 net@556#5pin@225_polysilicon-1##3 net@556#6pin@227_polysilicon-1 8.37
R1171 net@556#8nmos@21_poly-right net@556#8nmos@21_poly-right##0 6.2
R1172 net@556#8nmos@21_poly-right##0 net@556#6pin@227_polysilicon-1 6.2
R1173 S1#104nmos@23_poly-left S1#104nmos@23_poly-left##0 6.975
R1174 S1#104nmos@23_poly-left##0 S1#105pin@221_polysilicon-1 6.975
R1175 S1#105pin@221_polysilicon-1 S1#105pin@221_polysilicon-1##0 9.772
R1176 S1#105pin@221_polysilicon-1##0 S1#105pin@221_polysilicon-1##1 9.772
R1177 S1#105pin@221_polysilicon-1##1 S1#105pin@221_polysilicon-1##2 9.772
R1178 S1#105pin@221_polysilicon-1##2 S1#105pin@221_polysilicon-1##3 9.772
R1179 S1#105pin@221_polysilicon-1##3 S1#105pin@221_polysilicon-1##4 9.772
R1180 S1#105pin@221_polysilicon-1##4 S1#105pin@221_polysilicon-1##5 9.772
R1181 S1#105pin@221_polysilicon-1##5 S1#105pin@221_polysilicon-1##6 9.772
R1182 S1#105pin@221_polysilicon-1##6 S1#105pin@221_polysilicon-1##7 9.772
R1183 S1#105pin@221_polysilicon-1##7 S1#105pin@221_polysilicon-1##8 9.772
R1184 S1#105pin@221_polysilicon-1##8 S1#105pin@221_polysilicon-1##9 9.772
R1185 S1#105pin@221_polysilicon-1##9 S1#105pin@221_polysilicon-1##10 9.772
R1186 S1#105pin@221_polysilicon-1##10 S1#105pin@221_polysilicon-1##11 9.772
R1187 S1#105pin@221_polysilicon-1##11 S1#105pin@221_polysilicon-1##12 9.772
R1188 S1#105pin@221_polysilicon-1##12 S1#105pin@221_polysilicon-1##13 9.772
R1189 S1#105pin@221_polysilicon-1##13 S1#105pin@221_polysilicon-1##14 9.772
R1190 S1#105pin@221_polysilicon-1##14 S1#105pin@221_polysilicon-1##15 9.772
R1191 S1#105pin@221_polysilicon-1##15 S1#105pin@221_polysilicon-1##16 9.772
R1192 S1#105pin@221_polysilicon-1##16 S1#105pin@221_polysilicon-1##17 9.772
R1193 S1#105pin@221_polysilicon-1##17 S1#105pin@221_polysilicon-1##18 9.772
R1194 S1#105pin@221_polysilicon-1##18 S1#105pin@221_polysilicon-1##19 9.772
R1195 S1#105pin@221_polysilicon-1##19 S1#105pin@221_polysilicon-1##20 9.772
R1196 S1#105pin@221_polysilicon-1##20 S1#105pin@221_polysilicon-1##21 9.772
R1197 S1#105pin@221_polysilicon-1##21 S1#106pin@222_polysilicon-1 9.772
R1198 S1#56contact@262_metal-1-metal-2 S1#56contact@262_metal-1-metal-2##0 8.267
R1199 S1#56contact@262_metal-1-metal-2##0 S1#56contact@262_metal-1-metal-2##1 8.267
R1200 S1#56contact@262_metal-1-metal-2##1 S1#93pin@212_polysilicon-1 8.267
R1201 net@556#9pmos@23_poly-left net@556#10pin@223_polysilicon-1 7.75
R1202 net@556#10pin@223_polysilicon-1 net@556#10pin@223_polysilicon-1##0 9.042
R1203 net@556#10pin@223_polysilicon-1##0 net@556#10pin@223_polysilicon-1##1 9.042
R1204 net@556#10pin@223_polysilicon-1##1 net@556#10pin@223_polysilicon-1##2 9.042
R1205 net@556#10pin@223_polysilicon-1##2 net@556#10pin@223_polysilicon-1##3 9.042
R1206 net@556#10pin@223_polysilicon-1##3 net@556#10pin@223_polysilicon-1##4 9.042
R1207 net@556#10pin@223_polysilicon-1##4 net@556#11pin@224_polysilicon-1 9.042
R1208 net@556#11pin@224_polysilicon-1 net@556#11pin@224_polysilicon-1##0 9.3
R1209 net@556#11pin@224_polysilicon-1##0 net@556#11pin@224_polysilicon-1##1 9.3
R1210 net@556#11pin@224_polysilicon-1##1 net@556#11pin@224_polysilicon-1##2 9.3
R1211 net@556#11pin@224_polysilicon-1##2 net@556#11pin@224_polysilicon-1##3 9.3
R1212 net@556#11pin@224_polysilicon-1##3 net@556#11pin@224_polysilicon-1##4 9.3
R1213 net@556#11pin@224_polysilicon-1##4 net@556#11pin@224_polysilicon-1##5 9.3
R1214 net@556#11pin@224_polysilicon-1##5 net@556#11pin@224_polysilicon-1##6 9.3
R1215 net@556#11pin@224_polysilicon-1##6 net@556#5pin@225_polysilicon-1 9.3
R1216 S1#56contact@262_metal-1-metal-2 S1#56contact@262_metal-1-metal-2##0 9.881
R1217 S1#56contact@262_metal-1-metal-2##0 S1#56contact@262_metal-1-metal-2##1 9.881
R1218 S1#56contact@262_metal-1-metal-2##1 S1#56contact@262_metal-1-metal-2##2 9.881
R1219 S1#56contact@262_metal-1-metal-2##2 S1#56contact@262_metal-1-metal-2##3 9.881
R1220 S1#56contact@262_metal-1-metal-2##3 S1#56contact@262_metal-1-metal-2##4 9.881
R1221 S1#56contact@262_metal-1-metal-2##4 S1#56contact@262_metal-1-metal-2##5 9.881
R1222 S1#56contact@262_metal-1-metal-2##5 S1#56contact@262_metal-1-metal-2##6 9.881
R1223 S1#56contact@262_metal-1-metal-2##6 S1#100pin@245_polysilicon-1 9.881
R1224 net@517#6pin@250_polysilicon-1 net@517#6pin@250_polysilicon-1##0 9.042
R1225 net@517#6pin@250_polysilicon-1##0 net@517#6pin@250_polysilicon-1##1 9.042
R1226 net@517#6pin@250_polysilicon-1##1 net@517#6pin@250_polysilicon-1##2 9.042
R1227 net@517#6pin@250_polysilicon-1##2 net@517#6pin@250_polysilicon-1##3 9.042
R1228 net@517#6pin@250_polysilicon-1##3 net@517#6pin@250_polysilicon-1##4 9.042
R1229 net@517#6pin@250_polysilicon-1##4 net@517 9.042
R1230 S1#56contact@262_metal-1-metal-2 S1#56contact@262_metal-1-metal-2##0 9.881
R1231 S1#56contact@262_metal-1-metal-2##0 S1#56contact@262_metal-1-metal-2##1 9.881
R1232 S1#56contact@262_metal-1-metal-2##1 S1#56contact@262_metal-1-metal-2##2 9.881
R1233 S1#56contact@262_metal-1-metal-2##2 S1#56contact@262_metal-1-metal-2##3 9.881
R1234 S1#56contact@262_metal-1-metal-2##3 S1#56contact@262_metal-1-metal-2##4 9.881
R1235 S1#56contact@262_metal-1-metal-2##4 S1#56contact@262_metal-1-metal-2##5 9.881
R1236 S1#56contact@262_metal-1-metal-2##5 S1#56contact@262_metal-1-metal-2##6 9.881
R1237 S1#56contact@262_metal-1-metal-2##6 S1#106pin@222_polysilicon-1 9.881
R1238 S1#108nmos@25_poly-right S1#108nmos@25_poly-right##0 7.233
R1239 S1#108nmos@25_poly-right##0 S1#108nmos@25_poly-right##1 7.233
R1240 S1#108nmos@25_poly-right##1 S1#103pin@235_polysilicon-1 7.233
R1241 S1#109pmos@24_poly-left S1#109pmos@24_poly-left##0 6.2
R1242 S1#109pmos@24_poly-left##0 S1#110pin@238_polysilicon-1 6.2
R1243 S1#110pin@238_polysilicon-1 S1#110pin@238_polysilicon-1##0 9.896
R1244 S1#110pin@238_polysilicon-1##0 S1#110pin@238_polysilicon-1##1 9.896
R1245 S1#110pin@238_polysilicon-1##1 S1#110pin@238_polysilicon-1##2 9.896
R1246 S1#110pin@238_polysilicon-1##2 S1#110pin@238_polysilicon-1##3 9.896
R1247 S1#110pin@238_polysilicon-1##3 S1#110pin@238_polysilicon-1##4 9.896
R1248 S1#110pin@238_polysilicon-1##4 S1#110pin@238_polysilicon-1##5 9.896
R1249 S1#110pin@238_polysilicon-1##5 S1#110pin@238_polysilicon-1##6 9.896
R1250 S1#110pin@238_polysilicon-1##6 S1#110pin@238_polysilicon-1##7 9.896
R1251 S1#110pin@238_polysilicon-1##7 S1#110pin@238_polysilicon-1##8 9.896
R1252 S1#110pin@238_polysilicon-1##8 S1#110pin@238_polysilicon-1##9 9.896
R1253 S1#110pin@238_polysilicon-1##9 S1#110pin@238_polysilicon-1##10 9.896
R1254 S1#110pin@238_polysilicon-1##10 S1#110pin@238_polysilicon-1##11 9.896
R1255 S1#110pin@238_polysilicon-1##11 S1#111pin@239_polysilicon-1 9.896
R1256 S1#111pin@239_polysilicon-1 S1#111pin@239_polysilicon-1##0 9.521
R1257 S1#111pin@239_polysilicon-1##0 S1#111pin@239_polysilicon-1##1 9.521
R1258 S1#111pin@239_polysilicon-1##1 S1#111pin@239_polysilicon-1##2 9.521
R1259 S1#111pin@239_polysilicon-1##2 S1#111pin@239_polysilicon-1##3 9.521
R1260 S1#111pin@239_polysilicon-1##3 S1#111pin@239_polysilicon-1##4 9.521
R1261 S1#111pin@239_polysilicon-1##4 S1#111pin@239_polysilicon-1##5 9.521
R1262 S1#111pin@239_polysilicon-1##5 S1#56contact@262_metal-1-metal-2 9.521
R1263 S1#103pin@235_polysilicon-1 S1#103pin@235_polysilicon-1##0 5.425
R1264 S1#103pin@235_polysilicon-1##0 S1#112pmos@25_poly-right 5.425
R1265 net@556#6pin@227_polysilicon-1 net@556#6pin@227_polysilicon-1##0 9.042
R1266 net@556#6pin@227_polysilicon-1##0 net@556#6pin@227_polysilicon-1##1 9.042
R1267 net@556#6pin@227_polysilicon-1##1 net@556#6pin@227_polysilicon-1##2 9.042
R1268 net@556#6pin@227_polysilicon-1##2 net@556#6pin@227_polysilicon-1##3 9.042
R1269 net@556#6pin@227_polysilicon-1##3 net@556#6pin@227_polysilicon-1##4 9.042
R1270 net@556#6pin@227_polysilicon-1##4 net@556 9.042
R1271 net@517#7pin@248_polysilicon-1 net@517#7pin@248_polysilicon-1##0 8.37
R1272 net@517#7pin@248_polysilicon-1##0 net@517#7pin@248_polysilicon-1##1 8.37
R1273 net@517#7pin@248_polysilicon-1##1 net@517#7pin@248_polysilicon-1##2 8.37
R1274 net@517#7pin@248_polysilicon-1##2 net@517#7pin@248_polysilicon-1##3 8.37
R1275 net@517#7pin@248_polysilicon-1##3 net@517#6pin@250_polysilicon-1 8.37
R1276 S2 S2#27pin@263_polysilicon-1 6.422
R1277 S1#56contact@262_metal-1-metal-2 S1 6.435
R1278 net@1031#4pin@428_polysilicon-1 net@1031#4pin@428_polysilicon-1##0 8.37
R1279 net@1031#4pin@428_polysilicon-1##0 net@1031#4pin@428_polysilicon-1##1 8.37
R1280 net@1031#4pin@428_polysilicon-1##1 net@1031#4pin@428_polysilicon-1##2 8.37
R1281 net@1031#4pin@428_polysilicon-1##2 net@1031#4pin@428_polysilicon-1##3 8.37
R1282 net@1031#4pin@428_polysilicon-1##3 net@1031#5pin@430_polysilicon-1 8.37
R1283 net@1031#6nmos@42_poly-right net@1031#6nmos@42_poly-right##0 6.2
R1284 net@1031#6nmos@42_poly-right##0 net@1031#5pin@430_polysilicon-1 6.2
R1285 S3 S3##0 9.881
R1286 S3##0 S3##1 9.881
R1287 S3##1 S3##2 9.881
R1288 S3##2 S3##3 9.881
R1289 S3##3 S3##4 9.881
R1290 S3##4 S3##5 9.881
R1291 S3##5 S3##6 9.881
R1292 S3##6 S3#1pin@425_polysilicon-1 9.881
R1293 net@1031#5pin@430_polysilicon-1 net@1031#5pin@430_polysilicon-1##0 9.042
R1294 net@1031#5pin@430_polysilicon-1##0 net@1031#5pin@430_polysilicon-1##1 9.042
R1295 net@1031#5pin@430_polysilicon-1##1 net@1031#5pin@430_polysilicon-1##2 9.042
R1296 net@1031#5pin@430_polysilicon-1##2 net@1031#5pin@430_polysilicon-1##3 9.042
R1297 net@1031#5pin@430_polysilicon-1##3 net@1031#5pin@430_polysilicon-1##4 9.042
R1298 net@1031#5pin@430_polysilicon-1##4 net@1031 9.042
R1299 S3#2nmos@43_poly-right S3#2nmos@43_poly-right##0 7.233
R1300 S3#2nmos@43_poly-right##0 S3#2nmos@43_poly-right##1 7.233
R1301 S3#2nmos@43_poly-right##1 S3#3pin@415_polysilicon-1 7.233
R1302 S3#4pmos@42_poly-left S3#4pmos@42_poly-left##0 6.2
R1303 S3#4pmos@42_poly-left##0 S3#5pin@418_polysilicon-1 6.2
R1304 S3#5pin@418_polysilicon-1 S3#5pin@418_polysilicon-1##0 9.896
R1305 S3#5pin@418_polysilicon-1##0 S3#5pin@418_polysilicon-1##1 9.896
R1306 S3#5pin@418_polysilicon-1##1 S3#5pin@418_polysilicon-1##2 9.896
R1307 S3#5pin@418_polysilicon-1##2 S3#5pin@418_polysilicon-1##3 9.896
R1308 S3#5pin@418_polysilicon-1##3 S3#5pin@418_polysilicon-1##4 9.896
R1309 S3#5pin@418_polysilicon-1##4 S3#5pin@418_polysilicon-1##5 9.896
R1310 S3#5pin@418_polysilicon-1##5 S3#5pin@418_polysilicon-1##6 9.896
R1311 S3#5pin@418_polysilicon-1##6 S3#5pin@418_polysilicon-1##7 9.896
R1312 S3#5pin@418_polysilicon-1##7 S3#5pin@418_polysilicon-1##8 9.896
R1313 S3#5pin@418_polysilicon-1##8 S3#5pin@418_polysilicon-1##9 9.896
R1314 S3#5pin@418_polysilicon-1##9 S3#5pin@418_polysilicon-1##10 9.896
R1315 S3#5pin@418_polysilicon-1##10 S3#5pin@418_polysilicon-1##11 9.896
R1316 S3#5pin@418_polysilicon-1##11 S3#6pin@419_polysilicon-1 9.896
R1317 S3#6pin@419_polysilicon-1 S3#6pin@419_polysilicon-1##0 9.521
R1318 S3#6pin@419_polysilicon-1##0 S3#6pin@419_polysilicon-1##1 9.521
R1319 S3#6pin@419_polysilicon-1##1 S3#6pin@419_polysilicon-1##2 9.521
R1320 S3#6pin@419_polysilicon-1##2 S3#6pin@419_polysilicon-1##3 9.521
R1321 S3#6pin@419_polysilicon-1##3 S3#6pin@419_polysilicon-1##4 9.521
R1322 S3#6pin@419_polysilicon-1##4 S3#6pin@419_polysilicon-1##5 9.521
R1323 S3#6pin@419_polysilicon-1##5 S3 9.521
R1324 S3#3pin@415_polysilicon-1 S3#3pin@415_polysilicon-1##0 5.425
R1325 S3#3pin@415_polysilicon-1##0 S3#8pmos@43_poly-right 5.425
R1326 S3#10nmos@44_poly-left S3#10nmos@44_poly-left##0 6.975
R1327 S3#10nmos@44_poly-left##0 S3#11pin@424_polysilicon-1 6.975
R1328 S3#11pin@424_polysilicon-1 S3#11pin@424_polysilicon-1##0 9.772
R1329 S3#11pin@424_polysilicon-1##0 S3#11pin@424_polysilicon-1##1 9.772
R1330 S3#11pin@424_polysilicon-1##1 S3#11pin@424_polysilicon-1##2 9.772
R1331 S3#11pin@424_polysilicon-1##2 S3#11pin@424_polysilicon-1##3 9.772
R1332 S3#11pin@424_polysilicon-1##3 S3#11pin@424_polysilicon-1##4 9.772
R1333 S3#11pin@424_polysilicon-1##4 S3#11pin@424_polysilicon-1##5 9.772
R1334 S3#11pin@424_polysilicon-1##5 S3#11pin@424_polysilicon-1##6 9.772
R1335 S3#11pin@424_polysilicon-1##6 S3#11pin@424_polysilicon-1##7 9.772
R1336 S3#11pin@424_polysilicon-1##7 S3#11pin@424_polysilicon-1##8 9.772
R1337 S3#11pin@424_polysilicon-1##8 S3#11pin@424_polysilicon-1##9 9.772
R1338 S3#11pin@424_polysilicon-1##9 S3#11pin@424_polysilicon-1##10 9.772
R1339 S3#11pin@424_polysilicon-1##10 S3#11pin@424_polysilicon-1##11 9.772
R1340 S3#11pin@424_polysilicon-1##11 S3#11pin@424_polysilicon-1##12 9.772
R1341 S3#11pin@424_polysilicon-1##12 S3#11pin@424_polysilicon-1##13 9.772
R1342 S3#11pin@424_polysilicon-1##13 S3#11pin@424_polysilicon-1##14 9.772
R1343 S3#11pin@424_polysilicon-1##14 S3#11pin@424_polysilicon-1##15 9.772
R1344 S3#11pin@424_polysilicon-1##15 S3#11pin@424_polysilicon-1##16 9.772
R1345 S3#11pin@424_polysilicon-1##16 S3#11pin@424_polysilicon-1##17 9.772
R1346 S3#11pin@424_polysilicon-1##17 S3#11pin@424_polysilicon-1##18 9.772
R1347 S3#11pin@424_polysilicon-1##18 S3#11pin@424_polysilicon-1##19 9.772
R1348 S3#11pin@424_polysilicon-1##19 S3#11pin@424_polysilicon-1##20 9.772
R1349 S3#11pin@424_polysilicon-1##20 S3#11pin@424_polysilicon-1##21 9.772
R1350 S3#11pin@424_polysilicon-1##21 S3#1pin@425_polysilicon-1 9.772
R1351 S3 S3##0 8.267
R1352 S3##0 S3##1 8.267
R1353 S3##1 S3#3pin@415_polysilicon-1 8.267
R1354 net@1031#9pmos@44_poly-left net@1031#10pin@426_polysilicon-1 7.75
R1355 net@1031#10pin@426_polysilicon-1 net@1031#10pin@426_polysilicon-1##0 9.042
R1356 net@1031#10pin@426_polysilicon-1##0 net@1031#10pin@426_polysilicon-1##1 9.042
R1357 net@1031#10pin@426_polysilicon-1##1 net@1031#10pin@426_polysilicon-1##2 9.042
R1358 net@1031#10pin@426_polysilicon-1##2 net@1031#10pin@426_polysilicon-1##3 9.042
R1359 net@1031#10pin@426_polysilicon-1##3 net@1031#10pin@426_polysilicon-1##4 9.042
R1360 net@1031#10pin@426_polysilicon-1##4 net@1031#11pin@427_polysilicon-1 9.042
R1361 net@1031#11pin@427_polysilicon-1 net@1031#11pin@427_polysilicon-1##0 9.3
R1362 net@1031#11pin@427_polysilicon-1##0 net@1031#11pin@427_polysilicon-1##1 9.3
R1363 net@1031#11pin@427_polysilicon-1##1 net@1031#11pin@427_polysilicon-1##2 9.3
R1364 net@1031#11pin@427_polysilicon-1##2 net@1031#11pin@427_polysilicon-1##3 9.3
R1365 net@1031#11pin@427_polysilicon-1##3 net@1031#11pin@427_polysilicon-1##4 9.3
R1366 net@1031#11pin@427_polysilicon-1##4 net@1031#11pin@427_polysilicon-1##5 9.3
R1367 net@1031#11pin@427_polysilicon-1##5 net@1031#11pin@427_polysilicon-1##6 9.3
R1368 net@1031#11pin@427_polysilicon-1##6 net@1031#4pin@428_polysilicon-1 9.3

* Spice Code nodes in cell cell 'MUX_16_1_TG_2{lay}'
VDD VDD 0 DC 3.3
VGND GND 0 DC 0
Vin16 S2  0 PULSE  (3.3 0 0 1u 1u 400u 800u)
Vin17 S1  0 PULSE  (3.3 0 0 1u 1u 800u 1600u)
Vin18 S0  0 PULSE  (3.3 0 0 1u 1u 1600u 3200u)
Vin19 S3  0 PULSE  (3.3 0 0 1u 1u 3200u 6400u)
Vin0  I0  0 pulse 0 3.3 0u   1u 1u 100u 6400u
Vin1  I1  0 pulse 0 3.3 400u 1u 1u 100u 6400u
Vin2  I2  0 pulse 0 3.3 800u 1u 1u 100u 6400u
Vin3  I3  0 pulse 0 3.3 1200u 1u 1u 100u 6400u
Vin4  I4  0 pulse 0 3.3 1600u 1u 1u 100u 6400u
Vin5  I5  0 pulse 0 3.3 2000u 1u 1u 100u 6400u
Vin6  I6  0 pulse 0 3.3 2400u 1u 1u 100u 6400u
Vin7  I7  0 pulse 0 3.3 2800u 1u 1u 100u 6400u
Vin8  I8  0 pulse 0 3.3 3200u 1u 1u 100u 6400u
Vin9  I9  0 pulse 0 3.3 3600u 1u 1u 100u 6400u
Vin10 I10 0 pulse 0 3.3 4000u 1u 1u 100u 6400u
Vin11 I11 0 pulse 0 3.3 4400u 1u 1u 100u 6400u
Vin12 I12 0 pulse 0 3.3 4800u 1u 1u 100u 6400u
Vin13 I13 0 pulse 0 3.3 5200u 1u 1u 100u 6400u
Vin14 I14 0 pulse 0 3.3 5600u 1u 1u 100u 6400u
Vin15 I15 0 pulse 0 3.3 6000u 1u 1u 100u 6400u
cload out 0 250fF
.TRAN 0 6400u
.include C:\Electric\C5_models.txt
.END
