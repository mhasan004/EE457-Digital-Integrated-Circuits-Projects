*** SPICE deck for cell MUX_16_1_TG_3{lay} from library MUX_16_1
*** Created on Wed May 13, 2020 21:36:23
*** Last revised on Wed May 13, 2020 23:39:01
*** Written on Wed May 13, 2020 23:39:06 by Electric VLSI Design System, version 9.07
*** Layout tech: mocmos, foundry MOSIS
*** UC SPICE *** , MIN_RESIST 4.0, MIN_CAPAC 0.1FF
***    P-Active:	areacap=0.9FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    N-Active:	areacap=0.9FF/um^2,	edgecap=0.0FF/um,	res=3.0ohms/sq
***    Polysilicon-1:	areacap=0.1467FF/um^2,	edgecap=0.0608FF/um,	res=6.2ohms/sq
***    Polysilicon-2:	areacap=1.0FF/um^2,	edgecap=0.0FF/um,	res=50.0ohms/sq
***    Transistor-Poly:	areacap=0.09FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    Poly-Cut:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=2.2ohms/sq
***    Active-Cut:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    Metal-1:	areacap=0.1209FF/um^2,	edgecap=0.1104FF/um,	res=0.078ohms/sq
***    Via1:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=1.0ohms/sq
***    Metal-2:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via2:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.9ohms/sq
***    Metal-3:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via3:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-4:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via4:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-5:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via5:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-6:	areacap=0.0423FF/um^2,	edgecap=0.1273FF/um,	res=0.036ohms/sq
***    Hi-Res:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=1.0ohms/sq

*** TOP LEVEL CELL: MUX_16_1_TG_3{lay}
Mnmos@0 net@0 net@1#6nmos@0_poly-right I4 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@1 net@1 S1#34nmos@1_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@2 net@0 S1#36nmos@2_poly-left I6 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@3 net@33 net@24#4nmos@3_poly-right I5 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@4 net@24#6contact@26_metal-1-n-act S1#50nmos@4_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@5 net@33 S1#41nmos@5_poly-left I7 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@6 net@11 net@80#8nmos@6_poly-right net@0 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@7 net@80#1contact@56_metal-1-polysilicon-1 S2#6nmos@7_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@8 net@11 S2#24nmos@8_poly-left net@33 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@9 net@6 net@7#7nmos@9_poly-right I0 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@10 net@7 S1#25nmos@10_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@11 net@6 S1#11nmos@11_poly-left I2 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@12 net@27 net@8#11nmos@12_poly-right I1 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@13 net@8#4contact@94_metal-1-n-act S1#18nmos@13_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@14 net@27 S1#28nmos@14_poly-left I3 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@15 net@110 net@123#8nmos@15_poly-right net@6 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@16 net@123 S2#4nmos@16_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@17 net@110 S2#16nmos@17_poly-left net@27 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@18 net@269 net@270#6nmos@18_poly-right net@110 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@19 net@270 S0#2nmos@19_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@20 net@269 S0#10nmos@20_poly-left net@11 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@21 net@499 net@500#6nmos@21_poly-right I12 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@22 net@500 S1#89nmos@22_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@23 net@499 S1#91nmos@23_poly-left I14 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@24 net@532 net@523#4nmos@24_poly-right I13 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@25 net@523#6contact@209_metal-1-n-act S1#105nmos@25_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@26 net@532 S1#96nmos@26_poly-left I15 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@27 net@510 net@579#8nmos@27_poly-right net@499 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@28 net@579#1contact@239_metal-1-polysilicon-1 S2#32nmos@28_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@29 net@510 S2#51nmos@29_poly-left net@532 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@30 net@505 net@506#7nmos@30_poly-right I8 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@31 net@506 S1#81nmos@31_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@32 net@505 S1#67nmos@32_poly-left I10 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@33 net@526 net@507#11nmos@33_poly-right I9 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@34 net@507#4contact@277_metal-1-n-act S1#74nmos@34_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@35 net@526 S1#84nmos@35_poly-left I11 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@36 net@609 net@622#8nmos@36_poly-right net@505 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@37 net@622 S2#30nmos@37_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@38 net@609 S2#42nmos@38_poly-left net@526 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@39 net@768 net@769#6nmos@39_poly-right net@609 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@40 net@769 S0#18nmos@40_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@41 net@768 S0#26nmos@41_poly-left net@510 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@42 out net@1027#6nmos@42_poly-right net@269#15pmos@42_diff-bottom gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@43 net@1027 S3#6nmos@43_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=46.969P AD=1.684P PS=75.448U PD=5.425U
Mnmos@44 out S3#3nmos@44_poly-left net@768 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@0 I4 S1#39pmos@0_poly-left net@0 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@1 vdd S1#46pmos@1_poly-right net@1 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=80.607P PS=5.425U PD=79.532U
Mpmos@2 I6 net@1#7pmos@2_poly-left net@0 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@3 I5 S1#51pmos@3_poly-left net@33 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@4 vdd S1#54pmos@4_poly-right net@24#6contact@26_metal-1-n-act vdd PMOS L=0.35U W=1.75U AS=1.684P AD=80.607P PS=5.425U PD=79.532U
Mpmos@5 I7 net@24#2pmos@5_poly-left net@33 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@6 net@0 S2#14pmos@6_poly-left net@11 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@7 vdd S2#20pmos@7_poly-right net@80#1contact@56_metal-1-polysilicon-1 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=80.607P PS=5.425U PD=79.532U
Mpmos@8 net@33 net@80#9pmos@8_poly-left net@11 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@9 I0 S1#26pmos@9_poly-left net@6 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@10 vdd S1#31pmos@10_poly-right net@7 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=80.607P PS=5.425U PD=79.532U
Mpmos@11 I2 net@7#8pmos@11_poly-left net@6 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@12 I1 S1#20pmos@12_poly-left net@27 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@13 vdd S1#24pmos@13_poly-right net@8#4contact@94_metal-1-n-act vdd PMOS L=0.35U W=1.75U AS=1.684P AD=80.607P PS=5.425U PD=79.532U
Mpmos@14 I3 net@8 net@27 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@15 net@6 S2#8pmos@15_poly-left net@110 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@16 vdd S2#12pmos@16_poly-right net@123 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=80.607P PS=5.425U PD=79.532U
Mpmos@17 net@27 net@123#9pmos@17_poly-left net@110 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@18 net@110 S0#4pmos@18_poly-left net@269 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@19 vdd S0#8pmos@19_poly-right net@270 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=80.607P PS=5.425U PD=79.532U
Mpmos@20 net@11 net@270#9pmos@20_poly-left net@269 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@21 I12 S1#94pmos@21_poly-left net@499 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@22 vdd S1#101pmos@22_poly-right net@500 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=80.607P PS=5.425U PD=79.532U
Mpmos@23 I14 net@500#7pmos@23_poly-left net@499 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@24 I13 S1#106pmos@24_poly-left net@532 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@25 vdd S1#109pmos@25_poly-right net@523#6contact@209_metal-1-n-act vdd PMOS L=0.35U W=1.75U AS=1.684P AD=80.607P PS=5.425U PD=79.532U
Mpmos@26 I15 net@523#2pmos@26_poly-left net@532 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@27 net@499 S2#40pmos@27_poly-left net@510 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@28 vdd S2#46pmos@28_poly-right net@579#1contact@239_metal-1-polysilicon-1 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=80.607P PS=5.425U PD=79.532U
Mpmos@29 net@532 net@579#9pmos@29_poly-left net@510 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@30 I8 S1#82pmos@30_poly-left net@505 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@31 vdd S1#87pmos@31_poly-right net@506 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=80.607P PS=5.425U PD=79.532U
Mpmos@32 I10 net@506#8pmos@32_poly-left net@505 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@33 I9 S1#76pmos@33_poly-left net@526 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@34 vdd S1#80pmos@34_poly-right net@507#4contact@277_metal-1-n-act vdd PMOS L=0.35U W=1.75U AS=1.684P AD=80.607P PS=5.425U PD=79.532U
Mpmos@35 I11 net@507 net@526 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@36 net@505 S2#34pmos@36_poly-left net@609 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@37 vdd S2#38pmos@37_poly-right net@622 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=80.607P PS=5.425U PD=79.532U
Mpmos@38 net@526 net@622#9pmos@38_poly-left net@609 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@39 net@609 S0#20pmos@39_poly-left net@768 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@40 vdd S0#24pmos@40_poly-right net@769 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=80.607P PS=5.425U PD=79.532U
Mpmos@41 net@510 net@769#9pmos@41_poly-left net@768 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@42 net@269#15pmos@42_diff-bottom S3#0pmos@42_poly-left out vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@43 vdd S3#8pmos@43_poly-right net@1027 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=80.607P PS=5.425U PD=79.532U
Mpmos@44 net@768 net@1027#9pmos@44_poly-left out vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
** Extracted Parasitic Capacitors ***
C0 I4 0 5.094fF
C1 net@0 0 16.814fF
C2 net@1 0 1.643fF
C3 S1 0 54.533fF
C4 I6 0 6.89fF
C5 I5 0 5.673fF
C6 net@33 0 13.451fF
C7 net@24#6contact@26_metal-1-n-act 0 1.643fF
C8 I7 0 6.683fF
C9 net@11 0 25.138fF
C10 net@80#1contact@56_metal-1-polysilicon-1 0 1.643fF
C11 S2 0 17.187fF
C12 I0 0 13.033fF
C13 net@6 0 16.814fF
C14 net@7 0 1.643fF
C15 I2 0 13.799fF
C16 I1 0 12.638fF
C17 net@27 0 13.451fF
C18 net@8#4contact@94_metal-1-n-act 0 1.643fF
C19 I3 0 13.795fF
C20 net@110 0 12.136fF
C21 net@123 0 1.643fF
C22 net@269 0 14.331fF
C23 net@270 0 1.643fF
C24 S0#0pin@165_polysilicon-1 0 12.121fF
C25 S0 0 30.112fF
C26 I12 0 5.094fF
C27 net@499 0 16.814fF
C28 net@500 0 1.643fF
C29 I14 0 6.89fF
C30 I13 0 5.673fF
C31 net@532 0 13.451fF
C32 net@523#6contact@209_metal-1-n-act 0 1.643fF
C33 I15 0 6.683fF
C34 net@510 0 25.138fF
C35 net@579#1contact@239_metal-1-polysilicon-1 0 1.643fF
C36 S2#26pin@251_polysilicon-1 0 17.208fF
C37 I8 0 12.912fF
C38 net@505 0 16.814fF
C39 net@506 0 1.643fF
C40 I10 0 13.799fF
C41 I9 0 12.638fF
C42 net@526 0 13.451fF
C43 net@507#4contact@277_metal-1-n-act 0 1.643fF
C44 I11 0 13.795fF
C45 net@609 0 12.136fF
C46 net@622 0 1.643fF
C47 net@768 0 17.874fF
C48 net@769 0 1.643fF
C49 S0#16pin@363_polysilicon-1 0 12.121fF
C50 net@269#15pmos@42_diff-bottom 0 10.459fF
C51 out 0 8.105fF
C52 net@1027 0 1.643fF
C53 S1#35pin@2_polysilicon-1 0 0.149fF
C54 S1#40pin@5_polysilicon-1 0 0.13fF
C55 S1#43pin@6_polysilicon-1 0 0.171fF
C56 S1#37pin@11_polysilicon-1 0 0.137fF
C57 S1#38pin@12_polysilicon-1 0 0.177fF
C58 net@1#8pin@13_polysilicon-1 0 0.113fF
C59 net@1#9pin@14_polysilicon-1 0 0.156fF
C60 net@1#3pin@15_polysilicon-1 0 0.149fF
C61 net@1#4pin@17_polysilicon-1 0 0.184fF
C62 S1#48pin@25_polysilicon-1 0 0.149fF
C63 S1#52pin@28_polysilicon-1 0 0.13fF
C64 S1#53pin@29_polysilicon-1 0 0.171fF
C65 S1#42pin@34_polysilicon-1 0 0.137fF
C66 S1#45pin@35_polysilicon-1 0 0.177fF
C67 net@24 0 0.113fF
C68 net@24#1pin@37_polysilicon-1 0 0.156fF
C69 net@24#3pin@38_polysilicon-1 0 0.149fF
C70 net@24#5pin@40_polysilicon-1 0 0.184fF
C71 S2#7pin@48_polysilicon-1 0 0.149fF
C72 S2#15pin@51_polysilicon-1 0 0.13fF
C73 S2#18pin@52_polysilicon-1 0 0.171fF
C74 S2#25pin@56_polysilicon-1 0 0.137fF
C75 S2#1pin@57_polysilicon-1 0 0.177fF
C76 net@80#10pin@58_polysilicon-1 0 0.113fF
C77 net@80#11pin@59_polysilicon-1 0 0.156fF
C78 net@80#6pin@60_polysilicon-1 0 0.149fF
C79 net@80 0 0.184fF
C80 S1#14pin@77_polysilicon-1 0 0.149fF
C81 S1#27pin@80_polysilicon-1 0 0.13fF
C82 S1#30pin@81_polysilicon-1 0 0.171fF
C83 S1#12pin@86_polysilicon-1 0 0.137fF
C84 S1#13pin@87_polysilicon-1 0 0.177fF
C85 net@7#9pin@88_polysilicon-1 0 0.113fF
C86 net@7#10pin@89_polysilicon-1 0 0.156fF
C87 net@7#3pin@90_polysilicon-1 0 0.149fF
C88 net@7#4pin@92_polysilicon-1 0 0.184fF
C89 S1#19pin@100_polysilicon-1 0 0.149fF
C90 S1#21pin@103_polysilicon-1 0 0.13fF
C91 S1#22pin@104_polysilicon-1 0 0.171fF
C92 S1#29pin@109_polysilicon-1 0 0.137fF
C93 S1#16pin@110_polysilicon-1 0 0.177fF
C94 net@8#1pin@111_polysilicon-1 0 0.113fF
C95 net@8#2pin@112_polysilicon-1 0 0.156fF
C96 net@8#3pin@113_polysilicon-1 0 0.149fF
C97 net@8#6pin@115_polysilicon-1 0 0.184fF
C98 S2#5pin@123_polysilicon-1 0 0.149fF
C99 S2#9pin@126_polysilicon-1 0 0.13fF
C100 S2#10pin@127_polysilicon-1 0 0.171fF
C101 S2#17pin@131_polysilicon-1 0 0.137fF
C102 S2#3pin@132_polysilicon-1 0 0.177fF
C103 net@123#10pin@133_polysilicon-1 0 0.113fF
C104 net@123#11pin@134_polysilicon-1 0 0.156fF
C105 net@123#6pin@135_polysilicon-1 0 0.149fF
C106 net@123#2pin@137_polysilicon-1 0 0.184fF
C107 S0#3pin@160_polysilicon-1 0 0.149fF
C108 S0#5pin@163_polysilicon-1 0 0.13fF
C109 S0#6pin@164_polysilicon-1 0 0.171fF
C110 S0#11pin@169_polysilicon-1 0 0.137fF
C111 S0#1pin@170_polysilicon-1 0 0.177fF
C112 net@270#10pin@171_polysilicon-1 0 0.113fF
C113 net@270#11pin@172_polysilicon-1 0 0.156fF
C114 net@270#4pin@173_polysilicon-1 0 0.149fF
C115 net@270#5pin@175_polysilicon-1 0 0.184fF
C116 S1#90pin@200_polysilicon-1 0 0.149fF
C117 S1#95pin@203_polysilicon-1 0 0.13fF
C118 S1#98pin@204_polysilicon-1 0 0.171fF
C119 S1#92pin@209_polysilicon-1 0 0.137fF
C120 S1#93pin@210_polysilicon-1 0 0.177fF
C121 net@500#8pin@211_polysilicon-1 0 0.113fF
C122 net@500#9pin@212_polysilicon-1 0 0.156fF
C123 net@500#3pin@213_polysilicon-1 0 0.149fF
C124 net@500#4pin@215_polysilicon-1 0 0.184fF
C125 S1#103pin@223_polysilicon-1 0 0.149fF
C126 S1#107pin@226_polysilicon-1 0 0.13fF
C127 S1#108pin@227_polysilicon-1 0 0.171fF
C128 S1#97pin@232_polysilicon-1 0 0.137fF
C129 S1#100pin@233_polysilicon-1 0 0.177fF
C130 net@523 0 0.113fF
C131 net@523#1pin@235_polysilicon-1 0 0.156fF
C132 net@523#3pin@236_polysilicon-1 0 0.149fF
C133 net@523#5pin@238_polysilicon-1 0 0.184fF
C134 S2#33pin@246_polysilicon-1 0 0.149fF
C135 S2#41pin@249_polysilicon-1 0 0.13fF
C136 S2#44pin@250_polysilicon-1 0 0.171fF
C137 S2#52pin@254_polysilicon-1 0 0.137fF
C138 S2#27pin@255_polysilicon-1 0 0.177fF
C139 net@579#10pin@256_polysilicon-1 0 0.113fF
C140 net@579#11pin@257_polysilicon-1 0 0.156fF
C141 net@579#6pin@258_polysilicon-1 0 0.149fF
C142 net@579 0 0.184fF
C143 S1#70pin@275_polysilicon-1 0 0.149fF
C144 S1#83pin@278_polysilicon-1 0 0.13fF
C145 S1#86pin@279_polysilicon-1 0 0.171fF
C146 S1#68pin@284_polysilicon-1 0 0.137fF
C147 S1#69pin@285_polysilicon-1 0 0.177fF
C148 net@506#9pin@286_polysilicon-1 0 0.113fF
C149 net@506#10pin@287_polysilicon-1 0 0.156fF
C150 net@506#3pin@288_polysilicon-1 0 0.149fF
C151 net@506#4pin@290_polysilicon-1 0 0.184fF
C152 S1#75pin@298_polysilicon-1 0 0.149fF
C153 S1#77pin@301_polysilicon-1 0 0.13fF
C154 S1#78pin@302_polysilicon-1 0 0.171fF
C155 S1#85pin@307_polysilicon-1 0 0.137fF
C156 S1#72pin@308_polysilicon-1 0 0.177fF
C157 net@507#1pin@309_polysilicon-1 0 0.113fF
C158 net@507#2pin@310_polysilicon-1 0 0.156fF
C159 net@507#3pin@311_polysilicon-1 0 0.149fF
C160 net@507#6pin@313_polysilicon-1 0 0.184fF
C161 S2#31pin@321_polysilicon-1 0 0.149fF
C162 S2#35pin@324_polysilicon-1 0 0.13fF
C163 S2#36pin@325_polysilicon-1 0 0.171fF
C164 S2#43pin@329_polysilicon-1 0 0.137fF
C165 S2#29pin@330_polysilicon-1 0 0.177fF
C166 net@622#10pin@331_polysilicon-1 0 0.113fF
C167 net@622#11pin@332_polysilicon-1 0 0.156fF
C168 net@622#6pin@333_polysilicon-1 0 0.149fF
C169 net@622#2pin@335_polysilicon-1 0 0.184fF
C170 S0#19pin@358_polysilicon-1 0 0.149fF
C171 S0#21pin@361_polysilicon-1 0 0.13fF
C172 S0#22pin@362_polysilicon-1 0 0.171fF
C173 S0#27pin@367_polysilicon-1 0 0.137fF
C174 S0#17pin@368_polysilicon-1 0 0.177fF
C175 net@769#10pin@369_polysilicon-1 0 0.113fF
C176 net@769#11pin@370_polysilicon-1 0 0.156fF
C177 net@769#4pin@371_polysilicon-1 0 0.149fF
C178 net@769#5pin@373_polysilicon-1 0 0.184fF
C179 S3#1pin@415_polysilicon-1 0 0.13fF
C180 S3#2pin@416_polysilicon-1 0 0.17fF
C181 S3#4pin@421_polysilicon-1 0 0.137fF
C182 S3#5pin@422_polysilicon-1 0 0.169fF
C183 net@1027#10pin@423_polysilicon-1 0 0.113fF
C184 net@1027#11pin@424_polysilicon-1 0 0.156fF
C185 net@1027#4pin@425_polysilicon-1 0 0.149fF
C186 net@1027#5pin@427_polysilicon-1 0 0.184fF
C187 S3#7pin@476_polysilicon-1 0 0.17fF
C188 S3#9pin@477_polysilicon-1 0 0.263fF
** Extracted Parasitic Resistors ***
R0 net@8 net@8#1pin@111_polysilicon-1 7.75
R1 net@8#1pin@111_polysilicon-1 net@8#1pin@111_polysilicon-1##0 9.042
R2 net@8#1pin@111_polysilicon-1##0 net@8#1pin@111_polysilicon-1##1 9.042
R3 net@8#1pin@111_polysilicon-1##1 net@8#1pin@111_polysilicon-1##2 9.042
R4 net@8#1pin@111_polysilicon-1##2 net@8#1pin@111_polysilicon-1##3 9.042
R5 net@8#1pin@111_polysilicon-1##3 net@8#1pin@111_polysilicon-1##4 9.042
R6 net@8#1pin@111_polysilicon-1##4 net@8#2pin@112_polysilicon-1 9.042
R7 net@24 net@24##0 9.042
R8 net@24##0 net@24##1 9.042
R9 net@24##1 net@24##2 9.042
R10 net@24##2 net@24##3 9.042
R11 net@24##3 net@24##4 9.042
R12 net@24##4 net@24#1pin@37_polysilicon-1 9.042
R13 net@8#2pin@112_polysilicon-1 net@8#2pin@112_polysilicon-1##0 9.3
R14 net@8#2pin@112_polysilicon-1##0 net@8#2pin@112_polysilicon-1##1 9.3
R15 net@8#2pin@112_polysilicon-1##1 net@8#2pin@112_polysilicon-1##2 9.3
R16 net@8#2pin@112_polysilicon-1##2 net@8#2pin@112_polysilicon-1##3 9.3
R17 net@8#2pin@112_polysilicon-1##3 net@8#2pin@112_polysilicon-1##4 9.3
R18 net@8#2pin@112_polysilicon-1##4 net@8#2pin@112_polysilicon-1##5 9.3
R19 net@8#2pin@112_polysilicon-1##5 net@8#2pin@112_polysilicon-1##6 9.3
R20 net@8#2pin@112_polysilicon-1##6 net@8#3pin@113_polysilicon-1 9.3
R21 net@7#3pin@90_polysilicon-1 net@7#3pin@90_polysilicon-1##0 8.37
R22 net@7#3pin@90_polysilicon-1##0 net@7#3pin@90_polysilicon-1##1 8.37
R23 net@7#3pin@90_polysilicon-1##1 net@7#3pin@90_polysilicon-1##2 8.37
R24 net@7#3pin@90_polysilicon-1##2 net@7#3pin@90_polysilicon-1##3 8.37
R25 net@7#3pin@90_polysilicon-1##3 net@7#4pin@92_polysilicon-1 8.37
R26 net@7#7nmos@9_poly-right net@7#7nmos@9_poly-right##0 6.2
R27 net@7#7nmos@9_poly-right##0 net@7#4pin@92_polysilicon-1 6.2
R28 S2 S2##0 9.881
R29 S2##0 S2##1 9.881
R30 S2##1 S2##2 9.881
R31 S2##2 S2##3 9.881
R32 S2##3 S2##4 9.881
R33 S2##4 S2##5 9.881
R34 S2##5 S2##6 9.881
R35 S2##6 S2#1pin@57_polysilicon-1 9.881
R36 S1#11nmos@11_poly-left S1#11nmos@11_poly-left##0 6.975
R37 S1#11nmos@11_poly-left##0 S1#12pin@86_polysilicon-1 6.975
R38 S1#12pin@86_polysilicon-1 S1#12pin@86_polysilicon-1##0 9.772
R39 S1#12pin@86_polysilicon-1##0 S1#12pin@86_polysilicon-1##1 9.772
R40 S1#12pin@86_polysilicon-1##1 S1#12pin@86_polysilicon-1##2 9.772
R41 S1#12pin@86_polysilicon-1##2 S1#12pin@86_polysilicon-1##3 9.772
R42 S1#12pin@86_polysilicon-1##3 S1#12pin@86_polysilicon-1##4 9.772
R43 S1#12pin@86_polysilicon-1##4 S1#12pin@86_polysilicon-1##5 9.772
R44 S1#12pin@86_polysilicon-1##5 S1#12pin@86_polysilicon-1##6 9.772
R45 S1#12pin@86_polysilicon-1##6 S1#12pin@86_polysilicon-1##7 9.772
R46 S1#12pin@86_polysilicon-1##7 S1#12pin@86_polysilicon-1##8 9.772
R47 S1#12pin@86_polysilicon-1##8 S1#12pin@86_polysilicon-1##9 9.772
R48 S1#12pin@86_polysilicon-1##9 S1#12pin@86_polysilicon-1##10 9.772
R49 S1#12pin@86_polysilicon-1##10 S1#12pin@86_polysilicon-1##11 9.772
R50 S1#12pin@86_polysilicon-1##11 S1#12pin@86_polysilicon-1##12 9.772
R51 S1#12pin@86_polysilicon-1##12 S1#12pin@86_polysilicon-1##13 9.772
R52 S1#12pin@86_polysilicon-1##13 S1#12pin@86_polysilicon-1##14 9.772
R53 S1#12pin@86_polysilicon-1##14 S1#12pin@86_polysilicon-1##15 9.772
R54 S1#12pin@86_polysilicon-1##15 S1#12pin@86_polysilicon-1##16 9.772
R55 S1#12pin@86_polysilicon-1##16 S1#12pin@86_polysilicon-1##17 9.772
R56 S1#12pin@86_polysilicon-1##17 S1#12pin@86_polysilicon-1##18 9.772
R57 S1#12pin@86_polysilicon-1##18 S1#12pin@86_polysilicon-1##19 9.772
R58 S1#12pin@86_polysilicon-1##19 S1#12pin@86_polysilicon-1##20 9.772
R59 S1#12pin@86_polysilicon-1##20 S1#12pin@86_polysilicon-1##21 9.772
R60 S1#12pin@86_polysilicon-1##21 S1#13pin@87_polysilicon-1 9.772
R61 S1 S1##0 8.267
R62 S1##0 S1##1 8.267
R63 S1##1 S1#14pin@77_polysilicon-1 8.267
R64 net@7#8pmos@11_poly-left net@7#9pin@88_polysilicon-1 7.75
R65 net@7#9pin@88_polysilicon-1 net@7#9pin@88_polysilicon-1##0 9.042
R66 net@7#9pin@88_polysilicon-1##0 net@7#9pin@88_polysilicon-1##1 9.042
R67 net@7#9pin@88_polysilicon-1##1 net@7#9pin@88_polysilicon-1##2 9.042
R68 net@7#9pin@88_polysilicon-1##2 net@7#9pin@88_polysilicon-1##3 9.042
R69 net@7#9pin@88_polysilicon-1##3 net@7#9pin@88_polysilicon-1##4 9.042
R70 net@7#9pin@88_polysilicon-1##4 net@7#10pin@89_polysilicon-1 9.042
R71 net@7#10pin@89_polysilicon-1 net@7#10pin@89_polysilicon-1##0 9.3
R72 net@7#10pin@89_polysilicon-1##0 net@7#10pin@89_polysilicon-1##1 9.3
R73 net@7#10pin@89_polysilicon-1##1 net@7#10pin@89_polysilicon-1##2 9.3
R74 net@7#10pin@89_polysilicon-1##2 net@7#10pin@89_polysilicon-1##3 9.3
R75 net@7#10pin@89_polysilicon-1##3 net@7#10pin@89_polysilicon-1##4 9.3
R76 net@7#10pin@89_polysilicon-1##4 net@7#10pin@89_polysilicon-1##5 9.3
R77 net@7#10pin@89_polysilicon-1##5 net@7#10pin@89_polysilicon-1##6 9.3
R78 net@7#10pin@89_polysilicon-1##6 net@7#3pin@90_polysilicon-1 9.3
R79 net@80 net@80##0 9.042
R80 net@80##0 net@80##1 9.042
R81 net@80##1 net@80##2 9.042
R82 net@80##2 net@80##3 9.042
R83 net@80##3 net@80##4 9.042
R84 net@80##4 net@80#1contact@56_metal-1-polysilicon-1 9.042
R85 S1 S1##0 9.881
R86 S1##0 S1##1 9.881
R87 S1##1 S1##2 9.881
R88 S1##2 S1##3 9.881
R89 S1##3 S1##4 9.881
R90 S1##4 S1##5 9.881
R91 S1##5 S1##6 9.881
R92 S1##6 S1#16pin@110_polysilicon-1 9.881
R93 net@8#6pin@115_polysilicon-1 net@8#6pin@115_polysilicon-1##0 9.042
R94 net@8#6pin@115_polysilicon-1##0 net@8#6pin@115_polysilicon-1##1 9.042
R95 net@8#6pin@115_polysilicon-1##1 net@8#6pin@115_polysilicon-1##2 9.042
R96 net@8#6pin@115_polysilicon-1##2 net@8#6pin@115_polysilicon-1##3 9.042
R97 net@8#6pin@115_polysilicon-1##3 net@8#6pin@115_polysilicon-1##4 9.042
R98 net@8#6pin@115_polysilicon-1##4 net@8#4contact@94_metal-1-n-act 9.042
R99 S1 S1##0 9.881
R100 S1##0 S1##1 9.881
R101 S1##1 S1##2 9.881
R102 S1##2 S1##3 9.881
R103 S1##3 S1##4 9.881
R104 S1##4 S1##5 9.881
R105 S1##5 S1##6 9.881
R106 S1##6 S1#13pin@87_polysilicon-1 9.881
R107 S1#18nmos@13_poly-right S1#18nmos@13_poly-right##0 7.233
R108 S1#18nmos@13_poly-right##0 S1#18nmos@13_poly-right##1 7.233
R109 S1#18nmos@13_poly-right##1 S1#19pin@100_polysilicon-1 7.233
R110 S1#20pmos@12_poly-left S1#20pmos@12_poly-left##0 6.2
R111 S1#20pmos@12_poly-left##0 S1#21pin@103_polysilicon-1 6.2
R112 S1#21pin@103_polysilicon-1 S1#21pin@103_polysilicon-1##0 9.896
R113 S1#21pin@103_polysilicon-1##0 S1#21pin@103_polysilicon-1##1 9.896
R114 S1#21pin@103_polysilicon-1##1 S1#21pin@103_polysilicon-1##2 9.896
R115 S1#21pin@103_polysilicon-1##2 S1#21pin@103_polysilicon-1##3 9.896
R116 S1#21pin@103_polysilicon-1##3 S1#21pin@103_polysilicon-1##4 9.896
R117 S1#21pin@103_polysilicon-1##4 S1#21pin@103_polysilicon-1##5 9.896
R118 S1#21pin@103_polysilicon-1##5 S1#21pin@103_polysilicon-1##6 9.896
R119 S1#21pin@103_polysilicon-1##6 S1#21pin@103_polysilicon-1##7 9.896
R120 S1#21pin@103_polysilicon-1##7 S1#21pin@103_polysilicon-1##8 9.896
R121 S1#21pin@103_polysilicon-1##8 S1#21pin@103_polysilicon-1##9 9.896
R122 S1#21pin@103_polysilicon-1##9 S1#21pin@103_polysilicon-1##10 9.896
R123 S1#21pin@103_polysilicon-1##10 S1#21pin@103_polysilicon-1##11 9.896
R124 S1#21pin@103_polysilicon-1##11 S1#22pin@104_polysilicon-1 9.896
R125 S1#22pin@104_polysilicon-1 S1#22pin@104_polysilicon-1##0 9.521
R126 S1#22pin@104_polysilicon-1##0 S1#22pin@104_polysilicon-1##1 9.521
R127 S1#22pin@104_polysilicon-1##1 S1#22pin@104_polysilicon-1##2 9.521
R128 S1#22pin@104_polysilicon-1##2 S1#22pin@104_polysilicon-1##3 9.521
R129 S1#22pin@104_polysilicon-1##3 S1#22pin@104_polysilicon-1##4 9.521
R130 S1#22pin@104_polysilicon-1##4 S1#22pin@104_polysilicon-1##5 9.521
R131 S1#22pin@104_polysilicon-1##5 S1 9.521
R132 S1#19pin@100_polysilicon-1 S1#19pin@100_polysilicon-1##0 5.425
R133 S1#19pin@100_polysilicon-1##0 S1#24pmos@13_poly-right 5.425
R134 net@24#2pmos@5_poly-left net@24 7.75
R135 net@7#4pin@92_polysilicon-1 net@7#4pin@92_polysilicon-1##0 9.042
R136 net@7#4pin@92_polysilicon-1##0 net@7#4pin@92_polysilicon-1##1 9.042
R137 net@7#4pin@92_polysilicon-1##1 net@7#4pin@92_polysilicon-1##2 9.042
R138 net@7#4pin@92_polysilicon-1##2 net@7#4pin@92_polysilicon-1##3 9.042
R139 net@7#4pin@92_polysilicon-1##3 net@7#4pin@92_polysilicon-1##4 9.042
R140 net@7#4pin@92_polysilicon-1##4 net@7 9.042
R141 net@8#3pin@113_polysilicon-1 net@8#3pin@113_polysilicon-1##0 8.37
R142 net@8#3pin@113_polysilicon-1##0 net@8#3pin@113_polysilicon-1##1 8.37
R143 net@8#3pin@113_polysilicon-1##1 net@8#3pin@113_polysilicon-1##2 8.37
R144 net@8#3pin@113_polysilicon-1##2 net@8#3pin@113_polysilicon-1##3 8.37
R145 net@8#3pin@113_polysilicon-1##3 net@8#6pin@115_polysilicon-1 8.37
R146 S2 S2##0 9.881
R147 S2##0 S2##1 9.881
R148 S2##1 S2##2 9.881
R149 S2##2 S2##3 9.881
R150 S2##3 S2##4 9.881
R151 S2##4 S2##5 9.881
R152 S2##5 S2##6 9.881
R153 S2##6 S2#3pin@132_polysilicon-1 9.881
R154 net@123#2pin@137_polysilicon-1 net@123#2pin@137_polysilicon-1##0 9.042
R155 net@123#2pin@137_polysilicon-1##0 net@123#2pin@137_polysilicon-1##1 9.042
R156 net@123#2pin@137_polysilicon-1##1 net@123#2pin@137_polysilicon-1##2 9.042
R157 net@123#2pin@137_polysilicon-1##2 net@123#2pin@137_polysilicon-1##3 9.042
R158 net@123#2pin@137_polysilicon-1##3 net@123#2pin@137_polysilicon-1##4 9.042
R159 net@123#2pin@137_polysilicon-1##4 net@123 9.042
R160 net@24#1pin@37_polysilicon-1 net@24#1pin@37_polysilicon-1##0 9.3
R161 net@24#1pin@37_polysilicon-1##0 net@24#1pin@37_polysilicon-1##1 9.3
R162 net@24#1pin@37_polysilicon-1##1 net@24#1pin@37_polysilicon-1##2 9.3
R163 net@24#1pin@37_polysilicon-1##2 net@24#1pin@37_polysilicon-1##3 9.3
R164 net@24#1pin@37_polysilicon-1##3 net@24#1pin@37_polysilicon-1##4 9.3
R165 net@24#1pin@37_polysilicon-1##4 net@24#1pin@37_polysilicon-1##5 9.3
R166 net@24#1pin@37_polysilicon-1##5 net@24#1pin@37_polysilicon-1##6 9.3
R167 net@24#1pin@37_polysilicon-1##6 net@24#3pin@38_polysilicon-1 9.3
R168 S2#4nmos@16_poly-right S2#4nmos@16_poly-right##0 7.233
R169 S2#4nmos@16_poly-right##0 S2#4nmos@16_poly-right##1 7.233
R170 S2#4nmos@16_poly-right##1 S2#5pin@123_polysilicon-1 7.233
R171 S2#6nmos@7_poly-right S2#6nmos@7_poly-right##0 7.233
R172 S2#6nmos@7_poly-right##0 S2#6nmos@7_poly-right##1 7.233
R173 S2#6nmos@7_poly-right##1 S2#7pin@48_polysilicon-1 7.233
R174 S2#8pmos@15_poly-left S2#8pmos@15_poly-left##0 6.2
R175 S2#8pmos@15_poly-left##0 S2#9pin@126_polysilicon-1 6.2
R176 S2#9pin@126_polysilicon-1 S2#9pin@126_polysilicon-1##0 9.896
R177 S2#9pin@126_polysilicon-1##0 S2#9pin@126_polysilicon-1##1 9.896
R178 S2#9pin@126_polysilicon-1##1 S2#9pin@126_polysilicon-1##2 9.896
R179 S2#9pin@126_polysilicon-1##2 S2#9pin@126_polysilicon-1##3 9.896
R180 S2#9pin@126_polysilicon-1##3 S2#9pin@126_polysilicon-1##4 9.896
R181 S2#9pin@126_polysilicon-1##4 S2#9pin@126_polysilicon-1##5 9.896
R182 S2#9pin@126_polysilicon-1##5 S2#9pin@126_polysilicon-1##6 9.896
R183 S2#9pin@126_polysilicon-1##6 S2#9pin@126_polysilicon-1##7 9.896
R184 S2#9pin@126_polysilicon-1##7 S2#9pin@126_polysilicon-1##8 9.896
R185 S2#9pin@126_polysilicon-1##8 S2#9pin@126_polysilicon-1##9 9.896
R186 S2#9pin@126_polysilicon-1##9 S2#9pin@126_polysilicon-1##10 9.896
R187 S2#9pin@126_polysilicon-1##10 S2#9pin@126_polysilicon-1##11 9.896
R188 S2#9pin@126_polysilicon-1##11 S2#10pin@127_polysilicon-1 9.896
R189 S2#10pin@127_polysilicon-1 S2#10pin@127_polysilicon-1##0 9.521
R190 S2#10pin@127_polysilicon-1##0 S2#10pin@127_polysilicon-1##1 9.521
R191 S2#10pin@127_polysilicon-1##1 S2#10pin@127_polysilicon-1##2 9.521
R192 S2#10pin@127_polysilicon-1##2 S2#10pin@127_polysilicon-1##3 9.521
R193 S2#10pin@127_polysilicon-1##3 S2#10pin@127_polysilicon-1##4 9.521
R194 S2#10pin@127_polysilicon-1##4 S2#10pin@127_polysilicon-1##5 9.521
R195 S2#10pin@127_polysilicon-1##5 S2 9.521
R196 S2#5pin@123_polysilicon-1 S2#5pin@123_polysilicon-1##0 5.425
R197 S2#5pin@123_polysilicon-1##0 S2#12pmos@16_poly-right 5.425
R198 net@8#11nmos@12_poly-right net@8#11nmos@12_poly-right##0 6.2
R199 net@8#11nmos@12_poly-right##0 net@8#6pin@115_polysilicon-1 6.2
R200 net@123#6pin@135_polysilicon-1 net@123#6pin@135_polysilicon-1##0 8.37
R201 net@123#6pin@135_polysilicon-1##0 net@123#6pin@135_polysilicon-1##1 8.37
R202 net@123#6pin@135_polysilicon-1##1 net@123#6pin@135_polysilicon-1##2 8.37
R203 net@123#6pin@135_polysilicon-1##2 net@123#6pin@135_polysilicon-1##3 8.37
R204 net@123#6pin@135_polysilicon-1##3 net@123#2pin@137_polysilicon-1 8.37
R205 S2#14pmos@6_poly-left S2#14pmos@6_poly-left##0 6.2
R206 S2#14pmos@6_poly-left##0 S2#15pin@51_polysilicon-1 6.2
R207 S1#25nmos@10_poly-right S1#25nmos@10_poly-right##0 7.233
R208 S1#25nmos@10_poly-right##0 S1#25nmos@10_poly-right##1 7.233
R209 S1#25nmos@10_poly-right##1 S1#14pin@77_polysilicon-1 7.233
R210 net@1#3pin@15_polysilicon-1 net@1#3pin@15_polysilicon-1##0 8.37
R211 net@1#3pin@15_polysilicon-1##0 net@1#3pin@15_polysilicon-1##1 8.37
R212 net@1#3pin@15_polysilicon-1##1 net@1#3pin@15_polysilicon-1##2 8.37
R213 net@1#3pin@15_polysilicon-1##2 net@1#3pin@15_polysilicon-1##3 8.37
R214 net@1#3pin@15_polysilicon-1##3 net@1#4pin@17_polysilicon-1 8.37
R215 net@123#8nmos@15_poly-right net@123#8nmos@15_poly-right##0 6.2
R216 net@123#8nmos@15_poly-right##0 net@123#2pin@137_polysilicon-1 6.2
R217 S1#26pmos@9_poly-left S1#26pmos@9_poly-left##0 6.2
R218 S1#26pmos@9_poly-left##0 S1#27pin@80_polysilicon-1 6.2
R219 S2#16nmos@17_poly-left S2#16nmos@17_poly-left##0 6.975
R220 S2#16nmos@17_poly-left##0 S2#17pin@131_polysilicon-1 6.975
R221 S2#17pin@131_polysilicon-1 S2#17pin@131_polysilicon-1##0 9.772
R222 S2#17pin@131_polysilicon-1##0 S2#17pin@131_polysilicon-1##1 9.772
R223 S2#17pin@131_polysilicon-1##1 S2#17pin@131_polysilicon-1##2 9.772
R224 S2#17pin@131_polysilicon-1##2 S2#17pin@131_polysilicon-1##3 9.772
R225 S2#17pin@131_polysilicon-1##3 S2#17pin@131_polysilicon-1##4 9.772
R226 S2#17pin@131_polysilicon-1##4 S2#17pin@131_polysilicon-1##5 9.772
R227 S2#17pin@131_polysilicon-1##5 S2#17pin@131_polysilicon-1##6 9.772
R228 S2#17pin@131_polysilicon-1##6 S2#17pin@131_polysilicon-1##7 9.772
R229 S2#17pin@131_polysilicon-1##7 S2#17pin@131_polysilicon-1##8 9.772
R230 S2#17pin@131_polysilicon-1##8 S2#17pin@131_polysilicon-1##9 9.772
R231 S2#17pin@131_polysilicon-1##9 S2#17pin@131_polysilicon-1##10 9.772
R232 S2#17pin@131_polysilicon-1##10 S2#17pin@131_polysilicon-1##11 9.772
R233 S2#17pin@131_polysilicon-1##11 S2#17pin@131_polysilicon-1##12 9.772
R234 S2#17pin@131_polysilicon-1##12 S2#17pin@131_polysilicon-1##13 9.772
R235 S2#17pin@131_polysilicon-1##13 S2#17pin@131_polysilicon-1##14 9.772
R236 S2#17pin@131_polysilicon-1##14 S2#17pin@131_polysilicon-1##15 9.772
R237 S2#17pin@131_polysilicon-1##15 S2#17pin@131_polysilicon-1##16 9.772
R238 S2#17pin@131_polysilicon-1##16 S2#17pin@131_polysilicon-1##17 9.772
R239 S2#17pin@131_polysilicon-1##17 S2#17pin@131_polysilicon-1##18 9.772
R240 S2#17pin@131_polysilicon-1##18 S2#17pin@131_polysilicon-1##19 9.772
R241 S2#17pin@131_polysilicon-1##19 S2#17pin@131_polysilicon-1##20 9.772
R242 S2#17pin@131_polysilicon-1##20 S2#17pin@131_polysilicon-1##21 9.772
R243 S2#17pin@131_polysilicon-1##21 S2#3pin@132_polysilicon-1 9.772
R244 S2 S2##0 8.267
R245 S2##0 S2##1 8.267
R246 S2##1 S2#5pin@123_polysilicon-1 8.267
R247 net@123#9pmos@17_poly-left net@123#10pin@133_polysilicon-1 7.75
R248 S1#28nmos@14_poly-left S1#28nmos@14_poly-left##0 6.975
R249 S1#28nmos@14_poly-left##0 S1#29pin@109_polysilicon-1 6.975
R250 S2#15pin@51_polysilicon-1 S2#15pin@51_polysilicon-1##0 9.896
R251 S2#15pin@51_polysilicon-1##0 S2#15pin@51_polysilicon-1##1 9.896
R252 S2#15pin@51_polysilicon-1##1 S2#15pin@51_polysilicon-1##2 9.896
R253 S2#15pin@51_polysilicon-1##2 S2#15pin@51_polysilicon-1##3 9.896
R254 S2#15pin@51_polysilicon-1##3 S2#15pin@51_polysilicon-1##4 9.896
R255 S2#15pin@51_polysilicon-1##4 S2#15pin@51_polysilicon-1##5 9.896
R256 S2#15pin@51_polysilicon-1##5 S2#15pin@51_polysilicon-1##6 9.896
R257 S2#15pin@51_polysilicon-1##6 S2#15pin@51_polysilicon-1##7 9.896
R258 S2#15pin@51_polysilicon-1##7 S2#15pin@51_polysilicon-1##8 9.896
R259 S2#15pin@51_polysilicon-1##8 S2#15pin@51_polysilicon-1##9 9.896
R260 S2#15pin@51_polysilicon-1##9 S2#15pin@51_polysilicon-1##10 9.896
R261 S2#15pin@51_polysilicon-1##10 S2#15pin@51_polysilicon-1##11 9.896
R262 S2#15pin@51_polysilicon-1##11 S2#18pin@52_polysilicon-1 9.896
R263 net@123#10pin@133_polysilicon-1 net@123#10pin@133_polysilicon-1##0 9.042
R264 net@123#10pin@133_polysilicon-1##0 net@123#10pin@133_polysilicon-1##1 9.042
R265 net@123#10pin@133_polysilicon-1##1 net@123#10pin@133_polysilicon-1##2 9.042
R266 net@123#10pin@133_polysilicon-1##2 net@123#10pin@133_polysilicon-1##3 9.042
R267 net@123#10pin@133_polysilicon-1##3 net@123#10pin@133_polysilicon-1##4 9.042
R268 net@123#10pin@133_polysilicon-1##4 net@123#11pin@134_polysilicon-1 9.042
R269 net@123#11pin@134_polysilicon-1 net@123#11pin@134_polysilicon-1##0 9.3
R270 net@123#11pin@134_polysilicon-1##0 net@123#11pin@134_polysilicon-1##1 9.3
R271 net@123#11pin@134_polysilicon-1##1 net@123#11pin@134_polysilicon-1##2 9.3
R272 net@123#11pin@134_polysilicon-1##2 net@123#11pin@134_polysilicon-1##3 9.3
R273 net@123#11pin@134_polysilicon-1##3 net@123#11pin@134_polysilicon-1##4 9.3
R274 net@123#11pin@134_polysilicon-1##4 net@123#11pin@134_polysilicon-1##5 9.3
R275 net@123#11pin@134_polysilicon-1##5 net@123#11pin@134_polysilicon-1##6 9.3
R276 net@123#11pin@134_polysilicon-1##6 net@123#6pin@135_polysilicon-1 9.3
R277 S1#27pin@80_polysilicon-1 S1#27pin@80_polysilicon-1##0 9.896
R278 S1#27pin@80_polysilicon-1##0 S1#27pin@80_polysilicon-1##1 9.896
R279 S1#27pin@80_polysilicon-1##1 S1#27pin@80_polysilicon-1##2 9.896
R280 S1#27pin@80_polysilicon-1##2 S1#27pin@80_polysilicon-1##3 9.896
R281 S1#27pin@80_polysilicon-1##3 S1#27pin@80_polysilicon-1##4 9.896
R282 S1#27pin@80_polysilicon-1##4 S1#27pin@80_polysilicon-1##5 9.896
R283 S1#27pin@80_polysilicon-1##5 S1#27pin@80_polysilicon-1##6 9.896
R284 S1#27pin@80_polysilicon-1##6 S1#27pin@80_polysilicon-1##7 9.896
R285 S1#27pin@80_polysilicon-1##7 S1#27pin@80_polysilicon-1##8 9.896
R286 S1#27pin@80_polysilicon-1##8 S1#27pin@80_polysilicon-1##9 9.896
R287 S1#27pin@80_polysilicon-1##9 S1#27pin@80_polysilicon-1##10 9.896
R288 S1#27pin@80_polysilicon-1##10 S1#27pin@80_polysilicon-1##11 9.896
R289 S1#27pin@80_polysilicon-1##11 S1#30pin@81_polysilicon-1 9.896
R290 S1#30pin@81_polysilicon-1 S1#30pin@81_polysilicon-1##0 9.521
R291 S1#30pin@81_polysilicon-1##0 S1#30pin@81_polysilicon-1##1 9.521
R292 S1#30pin@81_polysilicon-1##1 S1#30pin@81_polysilicon-1##2 9.521
R293 S1#30pin@81_polysilicon-1##2 S1#30pin@81_polysilicon-1##3 9.521
R294 S1#30pin@81_polysilicon-1##3 S1#30pin@81_polysilicon-1##4 9.521
R295 S1#30pin@81_polysilicon-1##4 S1#30pin@81_polysilicon-1##5 9.521
R296 S1#30pin@81_polysilicon-1##5 S1 9.521
R297 S2#18pin@52_polysilicon-1 S2#18pin@52_polysilicon-1##0 9.521
R298 S2#18pin@52_polysilicon-1##0 S2#18pin@52_polysilicon-1##1 9.521
R299 S2#18pin@52_polysilicon-1##1 S2#18pin@52_polysilicon-1##2 9.521
R300 S2#18pin@52_polysilicon-1##2 S2#18pin@52_polysilicon-1##3 9.521
R301 S2#18pin@52_polysilicon-1##3 S2#18pin@52_polysilicon-1##4 9.521
R302 S2#18pin@52_polysilicon-1##4 S2#18pin@52_polysilicon-1##5 9.521
R303 S2#18pin@52_polysilicon-1##5 S2 9.521
R304 S1#29pin@109_polysilicon-1 S1#29pin@109_polysilicon-1##0 9.772
R305 S1#29pin@109_polysilicon-1##0 S1#29pin@109_polysilicon-1##1 9.772
R306 S1#29pin@109_polysilicon-1##1 S1#29pin@109_polysilicon-1##2 9.772
R307 S1#29pin@109_polysilicon-1##2 S1#29pin@109_polysilicon-1##3 9.772
R308 S1#29pin@109_polysilicon-1##3 S1#29pin@109_polysilicon-1##4 9.772
R309 S1#29pin@109_polysilicon-1##4 S1#29pin@109_polysilicon-1##5 9.772
R310 S1#29pin@109_polysilicon-1##5 S1#29pin@109_polysilicon-1##6 9.772
R311 S1#29pin@109_polysilicon-1##6 S1#29pin@109_polysilicon-1##7 9.772
R312 S1#29pin@109_polysilicon-1##7 S1#29pin@109_polysilicon-1##8 9.772
R313 S1#29pin@109_polysilicon-1##8 S1#29pin@109_polysilicon-1##9 9.772
R314 S1#29pin@109_polysilicon-1##9 S1#29pin@109_polysilicon-1##10 9.772
R315 S1#29pin@109_polysilicon-1##10 S1#29pin@109_polysilicon-1##11 9.772
R316 S1#29pin@109_polysilicon-1##11 S1#29pin@109_polysilicon-1##12 9.772
R317 S1#29pin@109_polysilicon-1##12 S1#29pin@109_polysilicon-1##13 9.772
R318 S1#29pin@109_polysilicon-1##13 S1#29pin@109_polysilicon-1##14 9.772
R319 S1#29pin@109_polysilicon-1##14 S1#29pin@109_polysilicon-1##15 9.772
R320 S1#29pin@109_polysilicon-1##15 S1#29pin@109_polysilicon-1##16 9.772
R321 S1#29pin@109_polysilicon-1##16 S1#29pin@109_polysilicon-1##17 9.772
R322 S1#29pin@109_polysilicon-1##17 S1#29pin@109_polysilicon-1##18 9.772
R323 S1#29pin@109_polysilicon-1##18 S1#29pin@109_polysilicon-1##19 9.772
R324 S1#29pin@109_polysilicon-1##19 S1#29pin@109_polysilicon-1##20 9.772
R325 S1#29pin@109_polysilicon-1##20 S1#29pin@109_polysilicon-1##21 9.772
R326 S1#29pin@109_polysilicon-1##21 S1#16pin@110_polysilicon-1 9.772
R327 S1#14pin@77_polysilicon-1 S1#14pin@77_polysilicon-1##0 5.425
R328 S1#14pin@77_polysilicon-1##0 S1#31pmos@10_poly-right 5.425
R329 S1 S1##0 8.267
R330 S1##0 S1##1 8.267
R331 S1##1 S1#19pin@100_polysilicon-1 8.267
R332 S2#7pin@48_polysilicon-1 S2#7pin@48_polysilicon-1##0 5.425
R333 S2#7pin@48_polysilicon-1##0 S2#20pmos@7_poly-right 5.425
R334 net@270#4pin@173_polysilicon-1 net@270#4pin@173_polysilicon-1##0 8.37
R335 net@270#4pin@173_polysilicon-1##0 net@270#4pin@173_polysilicon-1##1 8.37
R336 net@270#4pin@173_polysilicon-1##1 net@270#4pin@173_polysilicon-1##2 8.37
R337 net@270#4pin@173_polysilicon-1##2 net@270#4pin@173_polysilicon-1##3 8.37
R338 net@270#4pin@173_polysilicon-1##3 net@270#5pin@175_polysilicon-1 8.37
R339 net@270#6nmos@18_poly-right net@270#6nmos@18_poly-right##0 6.2
R340 net@270#6nmos@18_poly-right##0 net@270#5pin@175_polysilicon-1 6.2
R341 S0#0pin@165_polysilicon-1 S0#0pin@165_polysilicon-1##0 9.881
R342 S0#0pin@165_polysilicon-1##0 S0#0pin@165_polysilicon-1##1 9.881
R343 S0#0pin@165_polysilicon-1##1 S0#0pin@165_polysilicon-1##2 9.881
R344 S0#0pin@165_polysilicon-1##2 S0#0pin@165_polysilicon-1##3 9.881
R345 S0#0pin@165_polysilicon-1##3 S0#0pin@165_polysilicon-1##4 9.881
R346 S0#0pin@165_polysilicon-1##4 S0#0pin@165_polysilicon-1##5 9.881
R347 S0#0pin@165_polysilicon-1##5 S0#0pin@165_polysilicon-1##6 9.881
R348 S0#0pin@165_polysilicon-1##6 S0#1pin@170_polysilicon-1 9.881
R349 net@270#5pin@175_polysilicon-1 net@270#5pin@175_polysilicon-1##0 9.042
R350 net@270#5pin@175_polysilicon-1##0 net@270#5pin@175_polysilicon-1##1 9.042
R351 net@270#5pin@175_polysilicon-1##1 net@270#5pin@175_polysilicon-1##2 9.042
R352 net@270#5pin@175_polysilicon-1##2 net@270#5pin@175_polysilicon-1##3 9.042
R353 net@270#5pin@175_polysilicon-1##3 net@270#5pin@175_polysilicon-1##4 9.042
R354 net@270#5pin@175_polysilicon-1##4 net@270 9.042
R355 S0#2nmos@19_poly-right S0#2nmos@19_poly-right##0 7.233
R356 S0#2nmos@19_poly-right##0 S0#2nmos@19_poly-right##1 7.233
R357 S0#2nmos@19_poly-right##1 S0#3pin@160_polysilicon-1 7.233
R358 S0#4pmos@18_poly-left S0#4pmos@18_poly-left##0 6.2
R359 S0#4pmos@18_poly-left##0 S0#5pin@163_polysilicon-1 6.2
R360 S0#5pin@163_polysilicon-1 S0#5pin@163_polysilicon-1##0 9.896
R361 S0#5pin@163_polysilicon-1##0 S0#5pin@163_polysilicon-1##1 9.896
R362 S0#5pin@163_polysilicon-1##1 S0#5pin@163_polysilicon-1##2 9.896
R363 S0#5pin@163_polysilicon-1##2 S0#5pin@163_polysilicon-1##3 9.896
R364 S0#5pin@163_polysilicon-1##3 S0#5pin@163_polysilicon-1##4 9.896
R365 S0#5pin@163_polysilicon-1##4 S0#5pin@163_polysilicon-1##5 9.896
R366 S0#5pin@163_polysilicon-1##5 S0#5pin@163_polysilicon-1##6 9.896
R367 S0#5pin@163_polysilicon-1##6 S0#5pin@163_polysilicon-1##7 9.896
R368 S0#5pin@163_polysilicon-1##7 S0#5pin@163_polysilicon-1##8 9.896
R369 S0#5pin@163_polysilicon-1##8 S0#5pin@163_polysilicon-1##9 9.896
R370 S0#5pin@163_polysilicon-1##9 S0#5pin@163_polysilicon-1##10 9.896
R371 S0#5pin@163_polysilicon-1##10 S0#5pin@163_polysilicon-1##11 9.896
R372 S0#5pin@163_polysilicon-1##11 S0#6pin@164_polysilicon-1 9.896
R373 S0#6pin@164_polysilicon-1 S0#6pin@164_polysilicon-1##0 9.521
R374 S0#6pin@164_polysilicon-1##0 S0#6pin@164_polysilicon-1##1 9.521
R375 S0#6pin@164_polysilicon-1##1 S0#6pin@164_polysilicon-1##2 9.521
R376 S0#6pin@164_polysilicon-1##2 S0#6pin@164_polysilicon-1##3 9.521
R377 S0#6pin@164_polysilicon-1##3 S0#6pin@164_polysilicon-1##4 9.521
R378 S0#6pin@164_polysilicon-1##4 S0#6pin@164_polysilicon-1##5 9.521
R379 S0#6pin@164_polysilicon-1##5 S0#0pin@165_polysilicon-1 9.521
R380 S0#3pin@160_polysilicon-1 S0#3pin@160_polysilicon-1##0 5.425
R381 S0#3pin@160_polysilicon-1##0 S0#8pmos@19_poly-right 5.425
R382 S0#10nmos@20_poly-left S0#10nmos@20_poly-left##0 6.975
R383 S0#10nmos@20_poly-left##0 S0#11pin@169_polysilicon-1 6.975
R384 S0#11pin@169_polysilicon-1 S0#11pin@169_polysilicon-1##0 9.772
R385 S0#11pin@169_polysilicon-1##0 S0#11pin@169_polysilicon-1##1 9.772
R386 S0#11pin@169_polysilicon-1##1 S0#11pin@169_polysilicon-1##2 9.772
R387 S0#11pin@169_polysilicon-1##2 S0#11pin@169_polysilicon-1##3 9.772
R388 S0#11pin@169_polysilicon-1##3 S0#11pin@169_polysilicon-1##4 9.772
R389 S0#11pin@169_polysilicon-1##4 S0#11pin@169_polysilicon-1##5 9.772
R390 S0#11pin@169_polysilicon-1##5 S0#11pin@169_polysilicon-1##6 9.772
R391 S0#11pin@169_polysilicon-1##6 S0#11pin@169_polysilicon-1##7 9.772
R392 S0#11pin@169_polysilicon-1##7 S0#11pin@169_polysilicon-1##8 9.772
R393 S0#11pin@169_polysilicon-1##8 S0#11pin@169_polysilicon-1##9 9.772
R394 S0#11pin@169_polysilicon-1##9 S0#11pin@169_polysilicon-1##10 9.772
R395 S0#11pin@169_polysilicon-1##10 S0#11pin@169_polysilicon-1##11 9.772
R396 S0#11pin@169_polysilicon-1##11 S0#11pin@169_polysilicon-1##12 9.772
R397 S0#11pin@169_polysilicon-1##12 S0#11pin@169_polysilicon-1##13 9.772
R398 S0#11pin@169_polysilicon-1##13 S0#11pin@169_polysilicon-1##14 9.772
R399 S0#11pin@169_polysilicon-1##14 S0#11pin@169_polysilicon-1##15 9.772
R400 S0#11pin@169_polysilicon-1##15 S0#11pin@169_polysilicon-1##16 9.772
R401 S0#11pin@169_polysilicon-1##16 S0#11pin@169_polysilicon-1##17 9.772
R402 S0#11pin@169_polysilicon-1##17 S0#11pin@169_polysilicon-1##18 9.772
R403 S0#11pin@169_polysilicon-1##18 S0#11pin@169_polysilicon-1##19 9.772
R404 S0#11pin@169_polysilicon-1##19 S0#11pin@169_polysilicon-1##20 9.772
R405 S0#11pin@169_polysilicon-1##20 S0#11pin@169_polysilicon-1##21 9.772
R406 S0#11pin@169_polysilicon-1##21 S0#1pin@170_polysilicon-1 9.772
R407 S0#0pin@165_polysilicon-1 S0#0pin@165_polysilicon-1##0 8.267
R408 S0#0pin@165_polysilicon-1##0 S0#0pin@165_polysilicon-1##1 8.267
R409 S0#0pin@165_polysilicon-1##1 S0#3pin@160_polysilicon-1 8.267
R410 net@270#9pmos@20_poly-left net@270#10pin@171_polysilicon-1 7.75
R411 net@1#6nmos@0_poly-right net@1#6nmos@0_poly-right##0 6.2
R412 net@1#6nmos@0_poly-right##0 net@1#4pin@17_polysilicon-1 6.2
R413 net@270#10pin@171_polysilicon-1 net@270#10pin@171_polysilicon-1##0 9.042
R414 net@270#10pin@171_polysilicon-1##0 net@270#10pin@171_polysilicon-1##1 9.042
R415 net@270#10pin@171_polysilicon-1##1 net@270#10pin@171_polysilicon-1##2 9.042
R416 net@270#10pin@171_polysilicon-1##2 net@270#10pin@171_polysilicon-1##3 9.042
R417 net@270#10pin@171_polysilicon-1##3 net@270#10pin@171_polysilicon-1##4 9.042
R418 net@270#10pin@171_polysilicon-1##4 net@270#11pin@172_polysilicon-1 9.042
R419 net@270#11pin@172_polysilicon-1 net@270#11pin@172_polysilicon-1##0 9.3
R420 net@270#11pin@172_polysilicon-1##0 net@270#11pin@172_polysilicon-1##1 9.3
R421 net@270#11pin@172_polysilicon-1##1 net@270#11pin@172_polysilicon-1##2 9.3
R422 net@270#11pin@172_polysilicon-1##2 net@270#11pin@172_polysilicon-1##3 9.3
R423 net@270#11pin@172_polysilicon-1##3 net@270#11pin@172_polysilicon-1##4 9.3
R424 net@270#11pin@172_polysilicon-1##4 net@270#11pin@172_polysilicon-1##5 9.3
R425 net@270#11pin@172_polysilicon-1##5 net@270#11pin@172_polysilicon-1##6 9.3
R426 net@270#11pin@172_polysilicon-1##6 net@270#4pin@173_polysilicon-1 9.3
R427 net@24#4nmos@3_poly-right net@24#4nmos@3_poly-right##0 6.2
R428 net@24#4nmos@3_poly-right##0 net@24#5pin@40_polysilicon-1 6.2
R429 net@80#6pin@60_polysilicon-1 net@80#6pin@60_polysilicon-1##0 8.37
R430 net@80#6pin@60_polysilicon-1##0 net@80#6pin@60_polysilicon-1##1 8.37
R431 net@80#6pin@60_polysilicon-1##1 net@80#6pin@60_polysilicon-1##2 8.37
R432 net@80#6pin@60_polysilicon-1##2 net@80#6pin@60_polysilicon-1##3 8.37
R433 net@80#6pin@60_polysilicon-1##3 net@80 8.37
R434 S0#0pin@165_polysilicon-1 S0 4.29
R435 S1#34nmos@1_poly-right S1#34nmos@1_poly-right##0 7.233
R436 S1#34nmos@1_poly-right##0 S1#34nmos@1_poly-right##1 7.233
R437 S1#34nmos@1_poly-right##1 S1#35pin@2_polysilicon-1 7.233
R438 S1#36nmos@2_poly-left S1#36nmos@2_poly-left##0 6.975
R439 S1#36nmos@2_poly-left##0 S1#37pin@11_polysilicon-1 6.975
R440 S1#37pin@11_polysilicon-1 S1#37pin@11_polysilicon-1##0 9.772
R441 S1#37pin@11_polysilicon-1##0 S1#37pin@11_polysilicon-1##1 9.772
R442 S1#37pin@11_polysilicon-1##1 S1#37pin@11_polysilicon-1##2 9.772
R443 S1#37pin@11_polysilicon-1##2 S1#37pin@11_polysilicon-1##3 9.772
R444 S1#37pin@11_polysilicon-1##3 S1#37pin@11_polysilicon-1##4 9.772
R445 S1#37pin@11_polysilicon-1##4 S1#37pin@11_polysilicon-1##5 9.772
R446 S1#37pin@11_polysilicon-1##5 S1#37pin@11_polysilicon-1##6 9.772
R447 S1#37pin@11_polysilicon-1##6 S1#37pin@11_polysilicon-1##7 9.772
R448 S1#37pin@11_polysilicon-1##7 S1#37pin@11_polysilicon-1##8 9.772
R449 S1#37pin@11_polysilicon-1##8 S1#37pin@11_polysilicon-1##9 9.772
R450 S1#37pin@11_polysilicon-1##9 S1#37pin@11_polysilicon-1##10 9.772
R451 S1#37pin@11_polysilicon-1##10 S1#37pin@11_polysilicon-1##11 9.772
R452 S1#37pin@11_polysilicon-1##11 S1#37pin@11_polysilicon-1##12 9.772
R453 S1#37pin@11_polysilicon-1##12 S1#37pin@11_polysilicon-1##13 9.772
R454 S1#37pin@11_polysilicon-1##13 S1#37pin@11_polysilicon-1##14 9.772
R455 S1#37pin@11_polysilicon-1##14 S1#37pin@11_polysilicon-1##15 9.772
R456 S1#37pin@11_polysilicon-1##15 S1#37pin@11_polysilicon-1##16 9.772
R457 S1#37pin@11_polysilicon-1##16 S1#37pin@11_polysilicon-1##17 9.772
R458 S1#37pin@11_polysilicon-1##17 S1#37pin@11_polysilicon-1##18 9.772
R459 S1#37pin@11_polysilicon-1##18 S1#37pin@11_polysilicon-1##19 9.772
R460 S1#37pin@11_polysilicon-1##19 S1#37pin@11_polysilicon-1##20 9.772
R461 S1#37pin@11_polysilicon-1##20 S1#37pin@11_polysilicon-1##21 9.772
R462 S1#37pin@11_polysilicon-1##21 S1#38pin@12_polysilicon-1 9.772
R463 S1 S1##0 8.267
R464 S1##0 S1##1 8.267
R465 S1##1 S1#35pin@2_polysilicon-1 8.267
R466 net@80#8nmos@6_poly-right net@80#8nmos@6_poly-right##0 6.2
R467 net@80#8nmos@6_poly-right##0 net@80 6.2
R468 S1#39pmos@0_poly-left S1#39pmos@0_poly-left##0 6.2
R469 S1#39pmos@0_poly-left##0 S1#40pin@5_polysilicon-1 6.2
R470 S2#24nmos@8_poly-left S2#24nmos@8_poly-left##0 6.975
R471 S2#24nmos@8_poly-left##0 S2#25pin@56_polysilicon-1 6.975
R472 S2#25pin@56_polysilicon-1 S2#25pin@56_polysilicon-1##0 9.772
R473 S2#25pin@56_polysilicon-1##0 S2#25pin@56_polysilicon-1##1 9.772
R474 S2#25pin@56_polysilicon-1##1 S2#25pin@56_polysilicon-1##2 9.772
R475 S2#25pin@56_polysilicon-1##2 S2#25pin@56_polysilicon-1##3 9.772
R476 S2#25pin@56_polysilicon-1##3 S2#25pin@56_polysilicon-1##4 9.772
R477 S2#25pin@56_polysilicon-1##4 S2#25pin@56_polysilicon-1##5 9.772
R478 S2#25pin@56_polysilicon-1##5 S2#25pin@56_polysilicon-1##6 9.772
R479 S2#25pin@56_polysilicon-1##6 S2#25pin@56_polysilicon-1##7 9.772
R480 S2#25pin@56_polysilicon-1##7 S2#25pin@56_polysilicon-1##8 9.772
R481 S2#25pin@56_polysilicon-1##8 S2#25pin@56_polysilicon-1##9 9.772
R482 S2#25pin@56_polysilicon-1##9 S2#25pin@56_polysilicon-1##10 9.772
R483 S2#25pin@56_polysilicon-1##10 S2#25pin@56_polysilicon-1##11 9.772
R484 S2#25pin@56_polysilicon-1##11 S2#25pin@56_polysilicon-1##12 9.772
R485 S2#25pin@56_polysilicon-1##12 S2#25pin@56_polysilicon-1##13 9.772
R486 S2#25pin@56_polysilicon-1##13 S2#25pin@56_polysilicon-1##14 9.772
R487 S2#25pin@56_polysilicon-1##14 S2#25pin@56_polysilicon-1##15 9.772
R488 S2#25pin@56_polysilicon-1##15 S2#25pin@56_polysilicon-1##16 9.772
R489 S2#25pin@56_polysilicon-1##16 S2#25pin@56_polysilicon-1##17 9.772
R490 S2#25pin@56_polysilicon-1##17 S2#25pin@56_polysilicon-1##18 9.772
R491 S2#25pin@56_polysilicon-1##18 S2#25pin@56_polysilicon-1##19 9.772
R492 S2#25pin@56_polysilicon-1##19 S2#25pin@56_polysilicon-1##20 9.772
R493 S2#25pin@56_polysilicon-1##20 S2#25pin@56_polysilicon-1##21 9.772
R494 S2#25pin@56_polysilicon-1##21 S2#1pin@57_polysilicon-1 9.772
R495 S2 S2##0 8.267
R496 S2##0 S2##1 8.267
R497 S2##1 S2#7pin@48_polysilicon-1 8.267
R498 net@80#9pmos@8_poly-left net@80#10pin@58_polysilicon-1 7.75
R499 S1#41nmos@5_poly-left S1#41nmos@5_poly-left##0 6.975
R500 S1#41nmos@5_poly-left##0 S1#42pin@34_polysilicon-1 6.975
R501 net@80#10pin@58_polysilicon-1 net@80#10pin@58_polysilicon-1##0 9.042
R502 net@80#10pin@58_polysilicon-1##0 net@80#10pin@58_polysilicon-1##1 9.042
R503 net@80#10pin@58_polysilicon-1##1 net@80#10pin@58_polysilicon-1##2 9.042
R504 net@80#10pin@58_polysilicon-1##2 net@80#10pin@58_polysilicon-1##3 9.042
R505 net@80#10pin@58_polysilicon-1##3 net@80#10pin@58_polysilicon-1##4 9.042
R506 net@80#10pin@58_polysilicon-1##4 net@80#11pin@59_polysilicon-1 9.042
R507 net@80#11pin@59_polysilicon-1 net@80#11pin@59_polysilicon-1##0 9.3
R508 net@80#11pin@59_polysilicon-1##0 net@80#11pin@59_polysilicon-1##1 9.3
R509 net@80#11pin@59_polysilicon-1##1 net@80#11pin@59_polysilicon-1##2 9.3
R510 net@80#11pin@59_polysilicon-1##2 net@80#11pin@59_polysilicon-1##3 9.3
R511 net@80#11pin@59_polysilicon-1##3 net@80#11pin@59_polysilicon-1##4 9.3
R512 net@80#11pin@59_polysilicon-1##4 net@80#11pin@59_polysilicon-1##5 9.3
R513 net@80#11pin@59_polysilicon-1##5 net@80#11pin@59_polysilicon-1##6 9.3
R514 net@80#11pin@59_polysilicon-1##6 net@80#6pin@60_polysilicon-1 9.3
R515 net@1#7pmos@2_poly-left net@1#8pin@13_polysilicon-1 7.75
R516 S1#40pin@5_polysilicon-1 S1#40pin@5_polysilicon-1##0 9.896
R517 S1#40pin@5_polysilicon-1##0 S1#40pin@5_polysilicon-1##1 9.896
R518 S1#40pin@5_polysilicon-1##1 S1#40pin@5_polysilicon-1##2 9.896
R519 S1#40pin@5_polysilicon-1##2 S1#40pin@5_polysilicon-1##3 9.896
R520 S1#40pin@5_polysilicon-1##3 S1#40pin@5_polysilicon-1##4 9.896
R521 S1#40pin@5_polysilicon-1##4 S1#40pin@5_polysilicon-1##5 9.896
R522 S1#40pin@5_polysilicon-1##5 S1#40pin@5_polysilicon-1##6 9.896
R523 S1#40pin@5_polysilicon-1##6 S1#40pin@5_polysilicon-1##7 9.896
R524 S1#40pin@5_polysilicon-1##7 S1#40pin@5_polysilicon-1##8 9.896
R525 S1#40pin@5_polysilicon-1##8 S1#40pin@5_polysilicon-1##9 9.896
R526 S1#40pin@5_polysilicon-1##9 S1#40pin@5_polysilicon-1##10 9.896
R527 S1#40pin@5_polysilicon-1##10 S1#40pin@5_polysilicon-1##11 9.896
R528 S1#40pin@5_polysilicon-1##11 S1#43pin@6_polysilicon-1 9.896
R529 S1#43pin@6_polysilicon-1 S1#43pin@6_polysilicon-1##0 9.521
R530 S1#43pin@6_polysilicon-1##0 S1#43pin@6_polysilicon-1##1 9.521
R531 S1#43pin@6_polysilicon-1##1 S1#43pin@6_polysilicon-1##2 9.521
R532 S1#43pin@6_polysilicon-1##2 S1#43pin@6_polysilicon-1##3 9.521
R533 S1#43pin@6_polysilicon-1##3 S1#43pin@6_polysilicon-1##4 9.521
R534 S1#43pin@6_polysilicon-1##4 S1#43pin@6_polysilicon-1##5 9.521
R535 S1#43pin@6_polysilicon-1##5 S1 9.521
R536 S1#42pin@34_polysilicon-1 S1#42pin@34_polysilicon-1##0 9.772
R537 S1#42pin@34_polysilicon-1##0 S1#42pin@34_polysilicon-1##1 9.772
R538 S1#42pin@34_polysilicon-1##1 S1#42pin@34_polysilicon-1##2 9.772
R539 S1#42pin@34_polysilicon-1##2 S1#42pin@34_polysilicon-1##3 9.772
R540 S1#42pin@34_polysilicon-1##3 S1#42pin@34_polysilicon-1##4 9.772
R541 S1#42pin@34_polysilicon-1##4 S1#42pin@34_polysilicon-1##5 9.772
R542 S1#42pin@34_polysilicon-1##5 S1#42pin@34_polysilicon-1##6 9.772
R543 S1#42pin@34_polysilicon-1##6 S1#42pin@34_polysilicon-1##7 9.772
R544 S1#42pin@34_polysilicon-1##7 S1#42pin@34_polysilicon-1##8 9.772
R545 S1#42pin@34_polysilicon-1##8 S1#42pin@34_polysilicon-1##9 9.772
R546 S1#42pin@34_polysilicon-1##9 S1#42pin@34_polysilicon-1##10 9.772
R547 S1#42pin@34_polysilicon-1##10 S1#42pin@34_polysilicon-1##11 9.772
R548 S1#42pin@34_polysilicon-1##11 S1#42pin@34_polysilicon-1##12 9.772
R549 S1#42pin@34_polysilicon-1##12 S1#42pin@34_polysilicon-1##13 9.772
R550 S1#42pin@34_polysilicon-1##13 S1#42pin@34_polysilicon-1##14 9.772
R551 S1#42pin@34_polysilicon-1##14 S1#42pin@34_polysilicon-1##15 9.772
R552 S1#42pin@34_polysilicon-1##15 S1#42pin@34_polysilicon-1##16 9.772
R553 S1#42pin@34_polysilicon-1##16 S1#42pin@34_polysilicon-1##17 9.772
R554 S1#42pin@34_polysilicon-1##17 S1#42pin@34_polysilicon-1##18 9.772
R555 S1#42pin@34_polysilicon-1##18 S1#42pin@34_polysilicon-1##19 9.772
R556 S1#42pin@34_polysilicon-1##19 S1#42pin@34_polysilicon-1##20 9.772
R557 S1#42pin@34_polysilicon-1##20 S1#42pin@34_polysilicon-1##21 9.772
R558 S1#42pin@34_polysilicon-1##21 S1#45pin@35_polysilicon-1 9.772
R559 net@1#8pin@13_polysilicon-1 net@1#8pin@13_polysilicon-1##0 9.042
R560 net@1#8pin@13_polysilicon-1##0 net@1#8pin@13_polysilicon-1##1 9.042
R561 net@1#8pin@13_polysilicon-1##1 net@1#8pin@13_polysilicon-1##2 9.042
R562 net@1#8pin@13_polysilicon-1##2 net@1#8pin@13_polysilicon-1##3 9.042
R563 net@1#8pin@13_polysilicon-1##3 net@1#8pin@13_polysilicon-1##4 9.042
R564 net@1#8pin@13_polysilicon-1##4 net@1#9pin@14_polysilicon-1 9.042
R565 S1#35pin@2_polysilicon-1 S1#35pin@2_polysilicon-1##0 5.425
R566 S1#35pin@2_polysilicon-1##0 S1#46pmos@1_poly-right 5.425
R567 S1 S1##0 8.267
R568 S1##0 S1##1 8.267
R569 S1##1 S1#48pin@25_polysilicon-1 8.267
R570 net@1#9pin@14_polysilicon-1 net@1#9pin@14_polysilicon-1##0 9.3
R571 net@1#9pin@14_polysilicon-1##0 net@1#9pin@14_polysilicon-1##1 9.3
R572 net@1#9pin@14_polysilicon-1##1 net@1#9pin@14_polysilicon-1##2 9.3
R573 net@1#9pin@14_polysilicon-1##2 net@1#9pin@14_polysilicon-1##3 9.3
R574 net@1#9pin@14_polysilicon-1##3 net@1#9pin@14_polysilicon-1##4 9.3
R575 net@1#9pin@14_polysilicon-1##4 net@1#9pin@14_polysilicon-1##5 9.3
R576 net@1#9pin@14_polysilicon-1##5 net@1#9pin@14_polysilicon-1##6 9.3
R577 net@1#9pin@14_polysilicon-1##6 net@1#3pin@15_polysilicon-1 9.3
R578 S1 S1##0 9.881
R579 S1##0 S1##1 9.881
R580 S1##1 S1##2 9.881
R581 S1##2 S1##3 9.881
R582 S1##3 S1##4 9.881
R583 S1##4 S1##5 9.881
R584 S1##5 S1##6 9.881
R585 S1##6 S1#45pin@35_polysilicon-1 9.881
R586 net@24#5pin@40_polysilicon-1 net@24#5pin@40_polysilicon-1##0 9.042
R587 net@24#5pin@40_polysilicon-1##0 net@24#5pin@40_polysilicon-1##1 9.042
R588 net@24#5pin@40_polysilicon-1##1 net@24#5pin@40_polysilicon-1##2 9.042
R589 net@24#5pin@40_polysilicon-1##2 net@24#5pin@40_polysilicon-1##3 9.042
R590 net@24#5pin@40_polysilicon-1##3 net@24#5pin@40_polysilicon-1##4 9.042
R591 net@24#5pin@40_polysilicon-1##4 net@24#6contact@26_metal-1-n-act 9.042
R592 S1 S1##0 9.881
R593 S1##0 S1##1 9.881
R594 S1##1 S1##2 9.881
R595 S1##2 S1##3 9.881
R596 S1##3 S1##4 9.881
R597 S1##4 S1##5 9.881
R598 S1##5 S1##6 9.881
R599 S1##6 S1#38pin@12_polysilicon-1 9.881
R600 S1#50nmos@4_poly-right S1#50nmos@4_poly-right##0 7.233
R601 S1#50nmos@4_poly-right##0 S1#50nmos@4_poly-right##1 7.233
R602 S1#50nmos@4_poly-right##1 S1#48pin@25_polysilicon-1 7.233
R603 S1#51pmos@3_poly-left S1#51pmos@3_poly-left##0 6.2
R604 S1#51pmos@3_poly-left##0 S1#52pin@28_polysilicon-1 6.2
R605 S1#52pin@28_polysilicon-1 S1#52pin@28_polysilicon-1##0 9.896
R606 S1#52pin@28_polysilicon-1##0 S1#52pin@28_polysilicon-1##1 9.896
R607 S1#52pin@28_polysilicon-1##1 S1#52pin@28_polysilicon-1##2 9.896
R608 S1#52pin@28_polysilicon-1##2 S1#52pin@28_polysilicon-1##3 9.896
R609 S1#52pin@28_polysilicon-1##3 S1#52pin@28_polysilicon-1##4 9.896
R610 S1#52pin@28_polysilicon-1##4 S1#52pin@28_polysilicon-1##5 9.896
R611 S1#52pin@28_polysilicon-1##5 S1#52pin@28_polysilicon-1##6 9.896
R612 S1#52pin@28_polysilicon-1##6 S1#52pin@28_polysilicon-1##7 9.896
R613 S1#52pin@28_polysilicon-1##7 S1#52pin@28_polysilicon-1##8 9.896
R614 S1#52pin@28_polysilicon-1##8 S1#52pin@28_polysilicon-1##9 9.896
R615 S1#52pin@28_polysilicon-1##9 S1#52pin@28_polysilicon-1##10 9.896
R616 S1#52pin@28_polysilicon-1##10 S1#52pin@28_polysilicon-1##11 9.896
R617 S1#52pin@28_polysilicon-1##11 S1#53pin@29_polysilicon-1 9.896
R618 S1#53pin@29_polysilicon-1 S1#53pin@29_polysilicon-1##0 9.521
R619 S1#53pin@29_polysilicon-1##0 S1#53pin@29_polysilicon-1##1 9.521
R620 S1#53pin@29_polysilicon-1##1 S1#53pin@29_polysilicon-1##2 9.521
R621 S1#53pin@29_polysilicon-1##2 S1#53pin@29_polysilicon-1##3 9.521
R622 S1#53pin@29_polysilicon-1##3 S1#53pin@29_polysilicon-1##4 9.521
R623 S1#53pin@29_polysilicon-1##4 S1#53pin@29_polysilicon-1##5 9.521
R624 S1#53pin@29_polysilicon-1##5 S1 9.521
R625 S1#48pin@25_polysilicon-1 S1#48pin@25_polysilicon-1##0 5.425
R626 S1#48pin@25_polysilicon-1##0 S1#54pmos@4_poly-right 5.425
R627 net@1#4pin@17_polysilicon-1 net@1#4pin@17_polysilicon-1##0 9.042
R628 net@1#4pin@17_polysilicon-1##0 net@1#4pin@17_polysilicon-1##1 9.042
R629 net@1#4pin@17_polysilicon-1##1 net@1#4pin@17_polysilicon-1##2 9.042
R630 net@1#4pin@17_polysilicon-1##2 net@1#4pin@17_polysilicon-1##3 9.042
R631 net@1#4pin@17_polysilicon-1##3 net@1#4pin@17_polysilicon-1##4 9.042
R632 net@1#4pin@17_polysilicon-1##4 net@1 9.042
R633 net@24#3pin@38_polysilicon-1 net@24#3pin@38_polysilicon-1##0 8.37
R634 net@24#3pin@38_polysilicon-1##0 net@24#3pin@38_polysilicon-1##1 8.37
R635 net@24#3pin@38_polysilicon-1##1 net@24#3pin@38_polysilicon-1##2 8.37
R636 net@24#3pin@38_polysilicon-1##2 net@24#3pin@38_polysilicon-1##3 8.37
R637 net@24#3pin@38_polysilicon-1##3 net@24#5pin@40_polysilicon-1 8.37
R638 net@507 net@507#1pin@309_polysilicon-1 7.75
R639 net@507#1pin@309_polysilicon-1 net@507#1pin@309_polysilicon-1##0 9.042
R640 net@507#1pin@309_polysilicon-1##0 net@507#1pin@309_polysilicon-1##1 9.042
R641 net@507#1pin@309_polysilicon-1##1 net@507#1pin@309_polysilicon-1##2 9.042
R642 net@507#1pin@309_polysilicon-1##2 net@507#1pin@309_polysilicon-1##3 9.042
R643 net@507#1pin@309_polysilicon-1##3 net@507#1pin@309_polysilicon-1##4 9.042
R644 net@507#1pin@309_polysilicon-1##4 net@507#2pin@310_polysilicon-1 9.042
R645 net@523 net@523##0 9.042
R646 net@523##0 net@523##1 9.042
R647 net@523##1 net@523##2 9.042
R648 net@523##2 net@523##3 9.042
R649 net@523##3 net@523##4 9.042
R650 net@523##4 net@523#1pin@235_polysilicon-1 9.042
R651 net@507#2pin@310_polysilicon-1 net@507#2pin@310_polysilicon-1##0 9.3
R652 net@507#2pin@310_polysilicon-1##0 net@507#2pin@310_polysilicon-1##1 9.3
R653 net@507#2pin@310_polysilicon-1##1 net@507#2pin@310_polysilicon-1##2 9.3
R654 net@507#2pin@310_polysilicon-1##2 net@507#2pin@310_polysilicon-1##3 9.3
R655 net@507#2pin@310_polysilicon-1##3 net@507#2pin@310_polysilicon-1##4 9.3
R656 net@507#2pin@310_polysilicon-1##4 net@507#2pin@310_polysilicon-1##5 9.3
R657 net@507#2pin@310_polysilicon-1##5 net@507#2pin@310_polysilicon-1##6 9.3
R658 net@507#2pin@310_polysilicon-1##6 net@507#3pin@311_polysilicon-1 9.3
R659 net@506#3pin@288_polysilicon-1 net@506#3pin@288_polysilicon-1##0 8.37
R660 net@506#3pin@288_polysilicon-1##0 net@506#3pin@288_polysilicon-1##1 8.37
R661 net@506#3pin@288_polysilicon-1##1 net@506#3pin@288_polysilicon-1##2 8.37
R662 net@506#3pin@288_polysilicon-1##2 net@506#3pin@288_polysilicon-1##3 8.37
R663 net@506#3pin@288_polysilicon-1##3 net@506#4pin@290_polysilicon-1 8.37
R664 net@506#7nmos@30_poly-right net@506#7nmos@30_poly-right##0 6.2
R665 net@506#7nmos@30_poly-right##0 net@506#4pin@290_polysilicon-1 6.2
R666 S2#26pin@251_polysilicon-1 S2#26pin@251_polysilicon-1##0 9.881
R667 S2#26pin@251_polysilicon-1##0 S2#26pin@251_polysilicon-1##1 9.881
R668 S2#26pin@251_polysilicon-1##1 S2#26pin@251_polysilicon-1##2 9.881
R669 S2#26pin@251_polysilicon-1##2 S2#26pin@251_polysilicon-1##3 9.881
R670 S2#26pin@251_polysilicon-1##3 S2#26pin@251_polysilicon-1##4 9.881
R671 S2#26pin@251_polysilicon-1##4 S2#26pin@251_polysilicon-1##5 9.881
R672 S2#26pin@251_polysilicon-1##5 S2#26pin@251_polysilicon-1##6 9.881
R673 S2#26pin@251_polysilicon-1##6 S2#27pin@255_polysilicon-1 9.881
R674 S1#67nmos@32_poly-left S1#67nmos@32_poly-left##0 6.975
R675 S1#67nmos@32_poly-left##0 S1#68pin@284_polysilicon-1 6.975
R676 S1#68pin@284_polysilicon-1 S1#68pin@284_polysilicon-1##0 9.772
R677 S1#68pin@284_polysilicon-1##0 S1#68pin@284_polysilicon-1##1 9.772
R678 S1#68pin@284_polysilicon-1##1 S1#68pin@284_polysilicon-1##2 9.772
R679 S1#68pin@284_polysilicon-1##2 S1#68pin@284_polysilicon-1##3 9.772
R680 S1#68pin@284_polysilicon-1##3 S1#68pin@284_polysilicon-1##4 9.772
R681 S1#68pin@284_polysilicon-1##4 S1#68pin@284_polysilicon-1##5 9.772
R682 S1#68pin@284_polysilicon-1##5 S1#68pin@284_polysilicon-1##6 9.772
R683 S1#68pin@284_polysilicon-1##6 S1#68pin@284_polysilicon-1##7 9.772
R684 S1#68pin@284_polysilicon-1##7 S1#68pin@284_polysilicon-1##8 9.772
R685 S1#68pin@284_polysilicon-1##8 S1#68pin@284_polysilicon-1##9 9.772
R686 S1#68pin@284_polysilicon-1##9 S1#68pin@284_polysilicon-1##10 9.772
R687 S1#68pin@284_polysilicon-1##10 S1#68pin@284_polysilicon-1##11 9.772
R688 S1#68pin@284_polysilicon-1##11 S1#68pin@284_polysilicon-1##12 9.772
R689 S1#68pin@284_polysilicon-1##12 S1#68pin@284_polysilicon-1##13 9.772
R690 S1#68pin@284_polysilicon-1##13 S1#68pin@284_polysilicon-1##14 9.772
R691 S1#68pin@284_polysilicon-1##14 S1#68pin@284_polysilicon-1##15 9.772
R692 S1#68pin@284_polysilicon-1##15 S1#68pin@284_polysilicon-1##16 9.772
R693 S1#68pin@284_polysilicon-1##16 S1#68pin@284_polysilicon-1##17 9.772
R694 S1#68pin@284_polysilicon-1##17 S1#68pin@284_polysilicon-1##18 9.772
R695 S1#68pin@284_polysilicon-1##18 S1#68pin@284_polysilicon-1##19 9.772
R696 S1#68pin@284_polysilicon-1##19 S1#68pin@284_polysilicon-1##20 9.772
R697 S1#68pin@284_polysilicon-1##20 S1#68pin@284_polysilicon-1##21 9.772
R698 S1#68pin@284_polysilicon-1##21 S1#69pin@285_polysilicon-1 9.772
R699 S1 S1##0 8.267
R700 S1##0 S1##1 8.267
R701 S1##1 S1#70pin@275_polysilicon-1 8.267
R702 net@506#8pmos@32_poly-left net@506#9pin@286_polysilicon-1 7.75
R703 net@506#9pin@286_polysilicon-1 net@506#9pin@286_polysilicon-1##0 9.042
R704 net@506#9pin@286_polysilicon-1##0 net@506#9pin@286_polysilicon-1##1 9.042
R705 net@506#9pin@286_polysilicon-1##1 net@506#9pin@286_polysilicon-1##2 9.042
R706 net@506#9pin@286_polysilicon-1##2 net@506#9pin@286_polysilicon-1##3 9.042
R707 net@506#9pin@286_polysilicon-1##3 net@506#9pin@286_polysilicon-1##4 9.042
R708 net@506#9pin@286_polysilicon-1##4 net@506#10pin@287_polysilicon-1 9.042
R709 net@506#10pin@287_polysilicon-1 net@506#10pin@287_polysilicon-1##0 9.3
R710 net@506#10pin@287_polysilicon-1##0 net@506#10pin@287_polysilicon-1##1 9.3
R711 net@506#10pin@287_polysilicon-1##1 net@506#10pin@287_polysilicon-1##2 9.3
R712 net@506#10pin@287_polysilicon-1##2 net@506#10pin@287_polysilicon-1##3 9.3
R713 net@506#10pin@287_polysilicon-1##3 net@506#10pin@287_polysilicon-1##4 9.3
R714 net@506#10pin@287_polysilicon-1##4 net@506#10pin@287_polysilicon-1##5 9.3
R715 net@506#10pin@287_polysilicon-1##5 net@506#10pin@287_polysilicon-1##6 9.3
R716 net@506#10pin@287_polysilicon-1##6 net@506#3pin@288_polysilicon-1 9.3
R717 net@579 net@579##0 9.042
R718 net@579##0 net@579##1 9.042
R719 net@579##1 net@579##2 9.042
R720 net@579##2 net@579##3 9.042
R721 net@579##3 net@579##4 9.042
R722 net@579##4 net@579#1contact@239_metal-1-polysilicon-1 9.042
R723 S1 S1##0 9.881
R724 S1##0 S1##1 9.881
R725 S1##1 S1##2 9.881
R726 S1##2 S1##3 9.881
R727 S1##3 S1##4 9.881
R728 S1##4 S1##5 9.881
R729 S1##5 S1##6 9.881
R730 S1##6 S1#72pin@308_polysilicon-1 9.881
R731 net@507#6pin@313_polysilicon-1 net@507#6pin@313_polysilicon-1##0 9.042
R732 net@507#6pin@313_polysilicon-1##0 net@507#6pin@313_polysilicon-1##1 9.042
R733 net@507#6pin@313_polysilicon-1##1 net@507#6pin@313_polysilicon-1##2 9.042
R734 net@507#6pin@313_polysilicon-1##2 net@507#6pin@313_polysilicon-1##3 9.042
R735 net@507#6pin@313_polysilicon-1##3 net@507#6pin@313_polysilicon-1##4 9.042
R736 net@507#6pin@313_polysilicon-1##4 net@507#4contact@277_metal-1-n-act 9.042
R737 S1 S1##0 9.881
R738 S1##0 S1##1 9.881
R739 S1##1 S1##2 9.881
R740 S1##2 S1##3 9.881
R741 S1##3 S1##4 9.881
R742 S1##4 S1##5 9.881
R743 S1##5 S1##6 9.881
R744 S1##6 S1#69pin@285_polysilicon-1 9.881
R745 S1#74nmos@34_poly-right S1#74nmos@34_poly-right##0 7.233
R746 S1#74nmos@34_poly-right##0 S1#74nmos@34_poly-right##1 7.233
R747 S1#74nmos@34_poly-right##1 S1#75pin@298_polysilicon-1 7.233
R748 S1#76pmos@33_poly-left S1#76pmos@33_poly-left##0 6.2
R749 S1#76pmos@33_poly-left##0 S1#77pin@301_polysilicon-1 6.2
R750 S1#77pin@301_polysilicon-1 S1#77pin@301_polysilicon-1##0 9.896
R751 S1#77pin@301_polysilicon-1##0 S1#77pin@301_polysilicon-1##1 9.896
R752 S1#77pin@301_polysilicon-1##1 S1#77pin@301_polysilicon-1##2 9.896
R753 S1#77pin@301_polysilicon-1##2 S1#77pin@301_polysilicon-1##3 9.896
R754 S1#77pin@301_polysilicon-1##3 S1#77pin@301_polysilicon-1##4 9.896
R755 S1#77pin@301_polysilicon-1##4 S1#77pin@301_polysilicon-1##5 9.896
R756 S1#77pin@301_polysilicon-1##5 S1#77pin@301_polysilicon-1##6 9.896
R757 S1#77pin@301_polysilicon-1##6 S1#77pin@301_polysilicon-1##7 9.896
R758 S1#77pin@301_polysilicon-1##7 S1#77pin@301_polysilicon-1##8 9.896
R759 S1#77pin@301_polysilicon-1##8 S1#77pin@301_polysilicon-1##9 9.896
R760 S1#77pin@301_polysilicon-1##9 S1#77pin@301_polysilicon-1##10 9.896
R761 S1#77pin@301_polysilicon-1##10 S1#77pin@301_polysilicon-1##11 9.896
R762 S1#77pin@301_polysilicon-1##11 S1#78pin@302_polysilicon-1 9.896
R763 S1#78pin@302_polysilicon-1 S1#78pin@302_polysilicon-1##0 9.521
R764 S1#78pin@302_polysilicon-1##0 S1#78pin@302_polysilicon-1##1 9.521
R765 S1#78pin@302_polysilicon-1##1 S1#78pin@302_polysilicon-1##2 9.521
R766 S1#78pin@302_polysilicon-1##2 S1#78pin@302_polysilicon-1##3 9.521
R767 S1#78pin@302_polysilicon-1##3 S1#78pin@302_polysilicon-1##4 9.521
R768 S1#78pin@302_polysilicon-1##4 S1#78pin@302_polysilicon-1##5 9.521
R769 S1#78pin@302_polysilicon-1##5 S1 9.521
R770 S1#75pin@298_polysilicon-1 S1#75pin@298_polysilicon-1##0 5.425
R771 S1#75pin@298_polysilicon-1##0 S1#80pmos@34_poly-right 5.425
R772 net@523#2pmos@26_poly-left net@523 7.75
R773 net@506#4pin@290_polysilicon-1 net@506#4pin@290_polysilicon-1##0 9.042
R774 net@506#4pin@290_polysilicon-1##0 net@506#4pin@290_polysilicon-1##1 9.042
R775 net@506#4pin@290_polysilicon-1##1 net@506#4pin@290_polysilicon-1##2 9.042
R776 net@506#4pin@290_polysilicon-1##2 net@506#4pin@290_polysilicon-1##3 9.042
R777 net@506#4pin@290_polysilicon-1##3 net@506#4pin@290_polysilicon-1##4 9.042
R778 net@506#4pin@290_polysilicon-1##4 net@506 9.042
R779 net@507#3pin@311_polysilicon-1 net@507#3pin@311_polysilicon-1##0 8.37
R780 net@507#3pin@311_polysilicon-1##0 net@507#3pin@311_polysilicon-1##1 8.37
R781 net@507#3pin@311_polysilicon-1##1 net@507#3pin@311_polysilicon-1##2 8.37
R782 net@507#3pin@311_polysilicon-1##2 net@507#3pin@311_polysilicon-1##3 8.37
R783 net@507#3pin@311_polysilicon-1##3 net@507#6pin@313_polysilicon-1 8.37
R784 S2#26pin@251_polysilicon-1 S2#26pin@251_polysilicon-1##0 9.881
R785 S2#26pin@251_polysilicon-1##0 S2#26pin@251_polysilicon-1##1 9.881
R786 S2#26pin@251_polysilicon-1##1 S2#26pin@251_polysilicon-1##2 9.881
R787 S2#26pin@251_polysilicon-1##2 S2#26pin@251_polysilicon-1##3 9.881
R788 S2#26pin@251_polysilicon-1##3 S2#26pin@251_polysilicon-1##4 9.881
R789 S2#26pin@251_polysilicon-1##4 S2#26pin@251_polysilicon-1##5 9.881
R790 S2#26pin@251_polysilicon-1##5 S2#26pin@251_polysilicon-1##6 9.881
R791 S2#26pin@251_polysilicon-1##6 S2#29pin@330_polysilicon-1 9.881
R792 net@622#2pin@335_polysilicon-1 net@622#2pin@335_polysilicon-1##0 9.042
R793 net@622#2pin@335_polysilicon-1##0 net@622#2pin@335_polysilicon-1##1 9.042
R794 net@622#2pin@335_polysilicon-1##1 net@622#2pin@335_polysilicon-1##2 9.042
R795 net@622#2pin@335_polysilicon-1##2 net@622#2pin@335_polysilicon-1##3 9.042
R796 net@622#2pin@335_polysilicon-1##3 net@622#2pin@335_polysilicon-1##4 9.042
R797 net@622#2pin@335_polysilicon-1##4 net@622 9.042
R798 net@523#1pin@235_polysilicon-1 net@523#1pin@235_polysilicon-1##0 9.3
R799 net@523#1pin@235_polysilicon-1##0 net@523#1pin@235_polysilicon-1##1 9.3
R800 net@523#1pin@235_polysilicon-1##1 net@523#1pin@235_polysilicon-1##2 9.3
R801 net@523#1pin@235_polysilicon-1##2 net@523#1pin@235_polysilicon-1##3 9.3
R802 net@523#1pin@235_polysilicon-1##3 net@523#1pin@235_polysilicon-1##4 9.3
R803 net@523#1pin@235_polysilicon-1##4 net@523#1pin@235_polysilicon-1##5 9.3
R804 net@523#1pin@235_polysilicon-1##5 net@523#1pin@235_polysilicon-1##6 9.3
R805 net@523#1pin@235_polysilicon-1##6 net@523#3pin@236_polysilicon-1 9.3
R806 S2#30nmos@37_poly-right S2#30nmos@37_poly-right##0 7.233
R807 S2#30nmos@37_poly-right##0 S2#30nmos@37_poly-right##1 7.233
R808 S2#30nmos@37_poly-right##1 S2#31pin@321_polysilicon-1 7.233
R809 S2#32nmos@28_poly-right S2#32nmos@28_poly-right##0 7.233
R810 S2#32nmos@28_poly-right##0 S2#32nmos@28_poly-right##1 7.233
R811 S2#32nmos@28_poly-right##1 S2#33pin@246_polysilicon-1 7.233
R812 S2#34pmos@36_poly-left S2#34pmos@36_poly-left##0 6.2
R813 S2#34pmos@36_poly-left##0 S2#35pin@324_polysilicon-1 6.2
R814 S2#35pin@324_polysilicon-1 S2#35pin@324_polysilicon-1##0 9.896
R815 S2#35pin@324_polysilicon-1##0 S2#35pin@324_polysilicon-1##1 9.896
R816 S2#35pin@324_polysilicon-1##1 S2#35pin@324_polysilicon-1##2 9.896
R817 S2#35pin@324_polysilicon-1##2 S2#35pin@324_polysilicon-1##3 9.896
R818 S2#35pin@324_polysilicon-1##3 S2#35pin@324_polysilicon-1##4 9.896
R819 S2#35pin@324_polysilicon-1##4 S2#35pin@324_polysilicon-1##5 9.896
R820 S2#35pin@324_polysilicon-1##5 S2#35pin@324_polysilicon-1##6 9.896
R821 S2#35pin@324_polysilicon-1##6 S2#35pin@324_polysilicon-1##7 9.896
R822 S2#35pin@324_polysilicon-1##7 S2#35pin@324_polysilicon-1##8 9.896
R823 S2#35pin@324_polysilicon-1##8 S2#35pin@324_polysilicon-1##9 9.896
R824 S2#35pin@324_polysilicon-1##9 S2#35pin@324_polysilicon-1##10 9.896
R825 S2#35pin@324_polysilicon-1##10 S2#35pin@324_polysilicon-1##11 9.896
R826 S2#35pin@324_polysilicon-1##11 S2#36pin@325_polysilicon-1 9.896
R827 S2#36pin@325_polysilicon-1 S2#36pin@325_polysilicon-1##0 9.521
R828 S2#36pin@325_polysilicon-1##0 S2#36pin@325_polysilicon-1##1 9.521
R829 S2#36pin@325_polysilicon-1##1 S2#36pin@325_polysilicon-1##2 9.521
R830 S2#36pin@325_polysilicon-1##2 S2#36pin@325_polysilicon-1##3 9.521
R831 S2#36pin@325_polysilicon-1##3 S2#36pin@325_polysilicon-1##4 9.521
R832 S2#36pin@325_polysilicon-1##4 S2#36pin@325_polysilicon-1##5 9.521
R833 S2#36pin@325_polysilicon-1##5 S2#26pin@251_polysilicon-1 9.521
R834 S2#31pin@321_polysilicon-1 S2#31pin@321_polysilicon-1##0 5.425
R835 S2#31pin@321_polysilicon-1##0 S2#38pmos@37_poly-right 5.425
R836 net@507#11nmos@33_poly-right net@507#11nmos@33_poly-right##0 6.2
R837 net@507#11nmos@33_poly-right##0 net@507#6pin@313_polysilicon-1 6.2
R838 net@622#6pin@333_polysilicon-1 net@622#6pin@333_polysilicon-1##0 8.37
R839 net@622#6pin@333_polysilicon-1##0 net@622#6pin@333_polysilicon-1##1 8.37
R840 net@622#6pin@333_polysilicon-1##1 net@622#6pin@333_polysilicon-1##2 8.37
R841 net@622#6pin@333_polysilicon-1##2 net@622#6pin@333_polysilicon-1##3 8.37
R842 net@622#6pin@333_polysilicon-1##3 net@622#2pin@335_polysilicon-1 8.37
R843 S2#40pmos@27_poly-left S2#40pmos@27_poly-left##0 6.2
R844 S2#40pmos@27_poly-left##0 S2#41pin@249_polysilicon-1 6.2
R845 S1#81nmos@31_poly-right S1#81nmos@31_poly-right##0 7.233
R846 S1#81nmos@31_poly-right##0 S1#81nmos@31_poly-right##1 7.233
R847 S1#81nmos@31_poly-right##1 S1#70pin@275_polysilicon-1 7.233
R848 net@500#3pin@213_polysilicon-1 net@500#3pin@213_polysilicon-1##0 8.37
R849 net@500#3pin@213_polysilicon-1##0 net@500#3pin@213_polysilicon-1##1 8.37
R850 net@500#3pin@213_polysilicon-1##1 net@500#3pin@213_polysilicon-1##2 8.37
R851 net@500#3pin@213_polysilicon-1##2 net@500#3pin@213_polysilicon-1##3 8.37
R852 net@500#3pin@213_polysilicon-1##3 net@500#4pin@215_polysilicon-1 8.37
R853 net@622#8nmos@36_poly-right net@622#8nmos@36_poly-right##0 6.2
R854 net@622#8nmos@36_poly-right##0 net@622#2pin@335_polysilicon-1 6.2
R855 S1#82pmos@30_poly-left S1#82pmos@30_poly-left##0 6.2
R856 S1#82pmos@30_poly-left##0 S1#83pin@278_polysilicon-1 6.2
R857 S2#42nmos@38_poly-left S2#42nmos@38_poly-left##0 6.975
R858 S2#42nmos@38_poly-left##0 S2#43pin@329_polysilicon-1 6.975
R859 S2#43pin@329_polysilicon-1 S2#43pin@329_polysilicon-1##0 9.772
R860 S2#43pin@329_polysilicon-1##0 S2#43pin@329_polysilicon-1##1 9.772
R861 S2#43pin@329_polysilicon-1##1 S2#43pin@329_polysilicon-1##2 9.772
R862 S2#43pin@329_polysilicon-1##2 S2#43pin@329_polysilicon-1##3 9.772
R863 S2#43pin@329_polysilicon-1##3 S2#43pin@329_polysilicon-1##4 9.772
R864 S2#43pin@329_polysilicon-1##4 S2#43pin@329_polysilicon-1##5 9.772
R865 S2#43pin@329_polysilicon-1##5 S2#43pin@329_polysilicon-1##6 9.772
R866 S2#43pin@329_polysilicon-1##6 S2#43pin@329_polysilicon-1##7 9.772
R867 S2#43pin@329_polysilicon-1##7 S2#43pin@329_polysilicon-1##8 9.772
R868 S2#43pin@329_polysilicon-1##8 S2#43pin@329_polysilicon-1##9 9.772
R869 S2#43pin@329_polysilicon-1##9 S2#43pin@329_polysilicon-1##10 9.772
R870 S2#43pin@329_polysilicon-1##10 S2#43pin@329_polysilicon-1##11 9.772
R871 S2#43pin@329_polysilicon-1##11 S2#43pin@329_polysilicon-1##12 9.772
R872 S2#43pin@329_polysilicon-1##12 S2#43pin@329_polysilicon-1##13 9.772
R873 S2#43pin@329_polysilicon-1##13 S2#43pin@329_polysilicon-1##14 9.772
R874 S2#43pin@329_polysilicon-1##14 S2#43pin@329_polysilicon-1##15 9.772
R875 S2#43pin@329_polysilicon-1##15 S2#43pin@329_polysilicon-1##16 9.772
R876 S2#43pin@329_polysilicon-1##16 S2#43pin@329_polysilicon-1##17 9.772
R877 S2#43pin@329_polysilicon-1##17 S2#43pin@329_polysilicon-1##18 9.772
R878 S2#43pin@329_polysilicon-1##18 S2#43pin@329_polysilicon-1##19 9.772
R879 S2#43pin@329_polysilicon-1##19 S2#43pin@329_polysilicon-1##20 9.772
R880 S2#43pin@329_polysilicon-1##20 S2#43pin@329_polysilicon-1##21 9.772
R881 S2#43pin@329_polysilicon-1##21 S2#29pin@330_polysilicon-1 9.772
R882 S2#26pin@251_polysilicon-1 S2#26pin@251_polysilicon-1##0 8.267
R883 S2#26pin@251_polysilicon-1##0 S2#26pin@251_polysilicon-1##1 8.267
R884 S2#26pin@251_polysilicon-1##1 S2#31pin@321_polysilicon-1 8.267
R885 net@622#9pmos@38_poly-left net@622#10pin@331_polysilicon-1 7.75
R886 S1#84nmos@35_poly-left S1#84nmos@35_poly-left##0 6.975
R887 S1#84nmos@35_poly-left##0 S1#85pin@307_polysilicon-1 6.975
R888 S2#41pin@249_polysilicon-1 S2#41pin@249_polysilicon-1##0 9.896
R889 S2#41pin@249_polysilicon-1##0 S2#41pin@249_polysilicon-1##1 9.896
R890 S2#41pin@249_polysilicon-1##1 S2#41pin@249_polysilicon-1##2 9.896
R891 S2#41pin@249_polysilicon-1##2 S2#41pin@249_polysilicon-1##3 9.896
R892 S2#41pin@249_polysilicon-1##3 S2#41pin@249_polysilicon-1##4 9.896
R893 S2#41pin@249_polysilicon-1##4 S2#41pin@249_polysilicon-1##5 9.896
R894 S2#41pin@249_polysilicon-1##5 S2#41pin@249_polysilicon-1##6 9.896
R895 S2#41pin@249_polysilicon-1##6 S2#41pin@249_polysilicon-1##7 9.896
R896 S2#41pin@249_polysilicon-1##7 S2#41pin@249_polysilicon-1##8 9.896
R897 S2#41pin@249_polysilicon-1##8 S2#41pin@249_polysilicon-1##9 9.896
R898 S2#41pin@249_polysilicon-1##9 S2#41pin@249_polysilicon-1##10 9.896
R899 S2#41pin@249_polysilicon-1##10 S2#41pin@249_polysilicon-1##11 9.896
R900 S2#41pin@249_polysilicon-1##11 S2#44pin@250_polysilicon-1 9.896
R901 net@622#10pin@331_polysilicon-1 net@622#10pin@331_polysilicon-1##0 9.042
R902 net@622#10pin@331_polysilicon-1##0 net@622#10pin@331_polysilicon-1##1 9.042
R903 net@622#10pin@331_polysilicon-1##1 net@622#10pin@331_polysilicon-1##2 9.042
R904 net@622#10pin@331_polysilicon-1##2 net@622#10pin@331_polysilicon-1##3 9.042
R905 net@622#10pin@331_polysilicon-1##3 net@622#10pin@331_polysilicon-1##4 9.042
R906 net@622#10pin@331_polysilicon-1##4 net@622#11pin@332_polysilicon-1 9.042
R907 net@622#11pin@332_polysilicon-1 net@622#11pin@332_polysilicon-1##0 9.3
R908 net@622#11pin@332_polysilicon-1##0 net@622#11pin@332_polysilicon-1##1 9.3
R909 net@622#11pin@332_polysilicon-1##1 net@622#11pin@332_polysilicon-1##2 9.3
R910 net@622#11pin@332_polysilicon-1##2 net@622#11pin@332_polysilicon-1##3 9.3
R911 net@622#11pin@332_polysilicon-1##3 net@622#11pin@332_polysilicon-1##4 9.3
R912 net@622#11pin@332_polysilicon-1##4 net@622#11pin@332_polysilicon-1##5 9.3
R913 net@622#11pin@332_polysilicon-1##5 net@622#11pin@332_polysilicon-1##6 9.3
R914 net@622#11pin@332_polysilicon-1##6 net@622#6pin@333_polysilicon-1 9.3
R915 S1#83pin@278_polysilicon-1 S1#83pin@278_polysilicon-1##0 9.896
R916 S1#83pin@278_polysilicon-1##0 S1#83pin@278_polysilicon-1##1 9.896
R917 S1#83pin@278_polysilicon-1##1 S1#83pin@278_polysilicon-1##2 9.896
R918 S1#83pin@278_polysilicon-1##2 S1#83pin@278_polysilicon-1##3 9.896
R919 S1#83pin@278_polysilicon-1##3 S1#83pin@278_polysilicon-1##4 9.896
R920 S1#83pin@278_polysilicon-1##4 S1#83pin@278_polysilicon-1##5 9.896
R921 S1#83pin@278_polysilicon-1##5 S1#83pin@278_polysilicon-1##6 9.896
R922 S1#83pin@278_polysilicon-1##6 S1#83pin@278_polysilicon-1##7 9.896
R923 S1#83pin@278_polysilicon-1##7 S1#83pin@278_polysilicon-1##8 9.896
R924 S1#83pin@278_polysilicon-1##8 S1#83pin@278_polysilicon-1##9 9.896
R925 S1#83pin@278_polysilicon-1##9 S1#83pin@278_polysilicon-1##10 9.896
R926 S1#83pin@278_polysilicon-1##10 S1#83pin@278_polysilicon-1##11 9.896
R927 S1#83pin@278_polysilicon-1##11 S1#86pin@279_polysilicon-1 9.896
R928 S1#86pin@279_polysilicon-1 S1#86pin@279_polysilicon-1##0 9.521
R929 S1#86pin@279_polysilicon-1##0 S1#86pin@279_polysilicon-1##1 9.521
R930 S1#86pin@279_polysilicon-1##1 S1#86pin@279_polysilicon-1##2 9.521
R931 S1#86pin@279_polysilicon-1##2 S1#86pin@279_polysilicon-1##3 9.521
R932 S1#86pin@279_polysilicon-1##3 S1#86pin@279_polysilicon-1##4 9.521
R933 S1#86pin@279_polysilicon-1##4 S1#86pin@279_polysilicon-1##5 9.521
R934 S1#86pin@279_polysilicon-1##5 S1 9.521
R935 S2#44pin@250_polysilicon-1 S2#44pin@250_polysilicon-1##0 9.521
R936 S2#44pin@250_polysilicon-1##0 S2#44pin@250_polysilicon-1##1 9.521
R937 S2#44pin@250_polysilicon-1##1 S2#44pin@250_polysilicon-1##2 9.521
R938 S2#44pin@250_polysilicon-1##2 S2#44pin@250_polysilicon-1##3 9.521
R939 S2#44pin@250_polysilicon-1##3 S2#44pin@250_polysilicon-1##4 9.521
R940 S2#44pin@250_polysilicon-1##4 S2#44pin@250_polysilicon-1##5 9.521
R941 S2#44pin@250_polysilicon-1##5 S2#26pin@251_polysilicon-1 9.521
R942 S1#85pin@307_polysilicon-1 S1#85pin@307_polysilicon-1##0 9.772
R943 S1#85pin@307_polysilicon-1##0 S1#85pin@307_polysilicon-1##1 9.772
R944 S1#85pin@307_polysilicon-1##1 S1#85pin@307_polysilicon-1##2 9.772
R945 S1#85pin@307_polysilicon-1##2 S1#85pin@307_polysilicon-1##3 9.772
R946 S1#85pin@307_polysilicon-1##3 S1#85pin@307_polysilicon-1##4 9.772
R947 S1#85pin@307_polysilicon-1##4 S1#85pin@307_polysilicon-1##5 9.772
R948 S1#85pin@307_polysilicon-1##5 S1#85pin@307_polysilicon-1##6 9.772
R949 S1#85pin@307_polysilicon-1##6 S1#85pin@307_polysilicon-1##7 9.772
R950 S1#85pin@307_polysilicon-1##7 S1#85pin@307_polysilicon-1##8 9.772
R951 S1#85pin@307_polysilicon-1##8 S1#85pin@307_polysilicon-1##9 9.772
R952 S1#85pin@307_polysilicon-1##9 S1#85pin@307_polysilicon-1##10 9.772
R953 S1#85pin@307_polysilicon-1##10 S1#85pin@307_polysilicon-1##11 9.772
R954 S1#85pin@307_polysilicon-1##11 S1#85pin@307_polysilicon-1##12 9.772
R955 S1#85pin@307_polysilicon-1##12 S1#85pin@307_polysilicon-1##13 9.772
R956 S1#85pin@307_polysilicon-1##13 S1#85pin@307_polysilicon-1##14 9.772
R957 S1#85pin@307_polysilicon-1##14 S1#85pin@307_polysilicon-1##15 9.772
R958 S1#85pin@307_polysilicon-1##15 S1#85pin@307_polysilicon-1##16 9.772
R959 S1#85pin@307_polysilicon-1##16 S1#85pin@307_polysilicon-1##17 9.772
R960 S1#85pin@307_polysilicon-1##17 S1#85pin@307_polysilicon-1##18 9.772
R961 S1#85pin@307_polysilicon-1##18 S1#85pin@307_polysilicon-1##19 9.772
R962 S1#85pin@307_polysilicon-1##19 S1#85pin@307_polysilicon-1##20 9.772
R963 S1#85pin@307_polysilicon-1##20 S1#85pin@307_polysilicon-1##21 9.772
R964 S1#85pin@307_polysilicon-1##21 S1#72pin@308_polysilicon-1 9.772
R965 S1#70pin@275_polysilicon-1 S1#70pin@275_polysilicon-1##0 5.425
R966 S1#70pin@275_polysilicon-1##0 S1#87pmos@31_poly-right 5.425
R967 S1 S1##0 8.267
R968 S1##0 S1##1 8.267
R969 S1##1 S1#75pin@298_polysilicon-1 8.267
R970 S2#33pin@246_polysilicon-1 S2#33pin@246_polysilicon-1##0 5.425
R971 S2#33pin@246_polysilicon-1##0 S2#46pmos@28_poly-right 5.425
R972 net@769#4pin@371_polysilicon-1 net@769#4pin@371_polysilicon-1##0 8.37
R973 net@769#4pin@371_polysilicon-1##0 net@769#4pin@371_polysilicon-1##1 8.37
R974 net@769#4pin@371_polysilicon-1##1 net@769#4pin@371_polysilicon-1##2 8.37
R975 net@769#4pin@371_polysilicon-1##2 net@769#4pin@371_polysilicon-1##3 8.37
R976 net@769#4pin@371_polysilicon-1##3 net@769#5pin@373_polysilicon-1 8.37
R977 net@769#6nmos@39_poly-right net@769#6nmos@39_poly-right##0 6.2
R978 net@769#6nmos@39_poly-right##0 net@769#5pin@373_polysilicon-1 6.2
R979 S0#16pin@363_polysilicon-1 S0#16pin@363_polysilicon-1##0 9.881
R980 S0#16pin@363_polysilicon-1##0 S0#16pin@363_polysilicon-1##1 9.881
R981 S0#16pin@363_polysilicon-1##1 S0#16pin@363_polysilicon-1##2 9.881
R982 S0#16pin@363_polysilicon-1##2 S0#16pin@363_polysilicon-1##3 9.881
R983 S0#16pin@363_polysilicon-1##3 S0#16pin@363_polysilicon-1##4 9.881
R984 S0#16pin@363_polysilicon-1##4 S0#16pin@363_polysilicon-1##5 9.881
R985 S0#16pin@363_polysilicon-1##5 S0#16pin@363_polysilicon-1##6 9.881
R986 S0#16pin@363_polysilicon-1##6 S0#17pin@368_polysilicon-1 9.881
R987 net@769#5pin@373_polysilicon-1 net@769#5pin@373_polysilicon-1##0 9.042
R988 net@769#5pin@373_polysilicon-1##0 net@769#5pin@373_polysilicon-1##1 9.042
R989 net@769#5pin@373_polysilicon-1##1 net@769#5pin@373_polysilicon-1##2 9.042
R990 net@769#5pin@373_polysilicon-1##2 net@769#5pin@373_polysilicon-1##3 9.042
R991 net@769#5pin@373_polysilicon-1##3 net@769#5pin@373_polysilicon-1##4 9.042
R992 net@769#5pin@373_polysilicon-1##4 net@769 9.042
R993 S0#18nmos@40_poly-right S0#18nmos@40_poly-right##0 7.233
R994 S0#18nmos@40_poly-right##0 S0#18nmos@40_poly-right##1 7.233
R995 S0#18nmos@40_poly-right##1 S0#19pin@358_polysilicon-1 7.233
R996 S0#20pmos@39_poly-left S0#20pmos@39_poly-left##0 6.2
R997 S0#20pmos@39_poly-left##0 S0#21pin@361_polysilicon-1 6.2
R998 S0#21pin@361_polysilicon-1 S0#21pin@361_polysilicon-1##0 9.896
R999 S0#21pin@361_polysilicon-1##0 S0#21pin@361_polysilicon-1##1 9.896
R1000 S0#21pin@361_polysilicon-1##1 S0#21pin@361_polysilicon-1##2 9.896
R1001 S0#21pin@361_polysilicon-1##2 S0#21pin@361_polysilicon-1##3 9.896
R1002 S0#21pin@361_polysilicon-1##3 S0#21pin@361_polysilicon-1##4 9.896
R1003 S0#21pin@361_polysilicon-1##4 S0#21pin@361_polysilicon-1##5 9.896
R1004 S0#21pin@361_polysilicon-1##5 S0#21pin@361_polysilicon-1##6 9.896
R1005 S0#21pin@361_polysilicon-1##6 S0#21pin@361_polysilicon-1##7 9.896
R1006 S0#21pin@361_polysilicon-1##7 S0#21pin@361_polysilicon-1##8 9.896
R1007 S0#21pin@361_polysilicon-1##8 S0#21pin@361_polysilicon-1##9 9.896
R1008 S0#21pin@361_polysilicon-1##9 S0#21pin@361_polysilicon-1##10 9.896
R1009 S0#21pin@361_polysilicon-1##10 S0#21pin@361_polysilicon-1##11 9.896
R1010 S0#21pin@361_polysilicon-1##11 S0#22pin@362_polysilicon-1 9.896
R1011 S0#22pin@362_polysilicon-1 S0#22pin@362_polysilicon-1##0 9.521
R1012 S0#22pin@362_polysilicon-1##0 S0#22pin@362_polysilicon-1##1 9.521
R1013 S0#22pin@362_polysilicon-1##1 S0#22pin@362_polysilicon-1##2 9.521
R1014 S0#22pin@362_polysilicon-1##2 S0#22pin@362_polysilicon-1##3 9.521
R1015 S0#22pin@362_polysilicon-1##3 S0#22pin@362_polysilicon-1##4 9.521
R1016 S0#22pin@362_polysilicon-1##4 S0#22pin@362_polysilicon-1##5 9.521
R1017 S0#22pin@362_polysilicon-1##5 S0#16pin@363_polysilicon-1 9.521
R1018 S0#19pin@358_polysilicon-1 S0#19pin@358_polysilicon-1##0 5.425
R1019 S0#19pin@358_polysilicon-1##0 S0#24pmos@40_poly-right 5.425
R1020 S0#26nmos@41_poly-left S0#26nmos@41_poly-left##0 6.975
R1021 S0#26nmos@41_poly-left##0 S0#27pin@367_polysilicon-1 6.975
R1022 S0#27pin@367_polysilicon-1 S0#27pin@367_polysilicon-1##0 9.772
R1023 S0#27pin@367_polysilicon-1##0 S0#27pin@367_polysilicon-1##1 9.772
R1024 S0#27pin@367_polysilicon-1##1 S0#27pin@367_polysilicon-1##2 9.772
R1025 S0#27pin@367_polysilicon-1##2 S0#27pin@367_polysilicon-1##3 9.772
R1026 S0#27pin@367_polysilicon-1##3 S0#27pin@367_polysilicon-1##4 9.772
R1027 S0#27pin@367_polysilicon-1##4 S0#27pin@367_polysilicon-1##5 9.772
R1028 S0#27pin@367_polysilicon-1##5 S0#27pin@367_polysilicon-1##6 9.772
R1029 S0#27pin@367_polysilicon-1##6 S0#27pin@367_polysilicon-1##7 9.772
R1030 S0#27pin@367_polysilicon-1##7 S0#27pin@367_polysilicon-1##8 9.772
R1031 S0#27pin@367_polysilicon-1##8 S0#27pin@367_polysilicon-1##9 9.772
R1032 S0#27pin@367_polysilicon-1##9 S0#27pin@367_polysilicon-1##10 9.772
R1033 S0#27pin@367_polysilicon-1##10 S0#27pin@367_polysilicon-1##11 9.772
R1034 S0#27pin@367_polysilicon-1##11 S0#27pin@367_polysilicon-1##12 9.772
R1035 S0#27pin@367_polysilicon-1##12 S0#27pin@367_polysilicon-1##13 9.772
R1036 S0#27pin@367_polysilicon-1##13 S0#27pin@367_polysilicon-1##14 9.772
R1037 S0#27pin@367_polysilicon-1##14 S0#27pin@367_polysilicon-1##15 9.772
R1038 S0#27pin@367_polysilicon-1##15 S0#27pin@367_polysilicon-1##16 9.772
R1039 S0#27pin@367_polysilicon-1##16 S0#27pin@367_polysilicon-1##17 9.772
R1040 S0#27pin@367_polysilicon-1##17 S0#27pin@367_polysilicon-1##18 9.772
R1041 S0#27pin@367_polysilicon-1##18 S0#27pin@367_polysilicon-1##19 9.772
R1042 S0#27pin@367_polysilicon-1##19 S0#27pin@367_polysilicon-1##20 9.772
R1043 S0#27pin@367_polysilicon-1##20 S0#27pin@367_polysilicon-1##21 9.772
R1044 S0#27pin@367_polysilicon-1##21 S0#17pin@368_polysilicon-1 9.772
R1045 S0#16pin@363_polysilicon-1 S0#16pin@363_polysilicon-1##0 8.267
R1046 S0#16pin@363_polysilicon-1##0 S0#16pin@363_polysilicon-1##1 8.267
R1047 S0#16pin@363_polysilicon-1##1 S0#19pin@358_polysilicon-1 8.267
R1048 net@769#9pmos@41_poly-left net@769#10pin@369_polysilicon-1 7.75
R1049 net@500#6nmos@21_poly-right net@500#6nmos@21_poly-right##0 6.2
R1050 net@500#6nmos@21_poly-right##0 net@500#4pin@215_polysilicon-1 6.2
R1051 net@769#10pin@369_polysilicon-1 net@769#10pin@369_polysilicon-1##0 9.042
R1052 net@769#10pin@369_polysilicon-1##0 net@769#10pin@369_polysilicon-1##1 9.042
R1053 net@769#10pin@369_polysilicon-1##1 net@769#10pin@369_polysilicon-1##2 9.042
R1054 net@769#10pin@369_polysilicon-1##2 net@769#10pin@369_polysilicon-1##3 9.042
R1055 net@769#10pin@369_polysilicon-1##3 net@769#10pin@369_polysilicon-1##4 9.042
R1056 net@769#10pin@369_polysilicon-1##4 net@769#11pin@370_polysilicon-1 9.042
R1057 net@769#11pin@370_polysilicon-1 net@769#11pin@370_polysilicon-1##0 9.3
R1058 net@769#11pin@370_polysilicon-1##0 net@769#11pin@370_polysilicon-1##1 9.3
R1059 net@769#11pin@370_polysilicon-1##1 net@769#11pin@370_polysilicon-1##2 9.3
R1060 net@769#11pin@370_polysilicon-1##2 net@769#11pin@370_polysilicon-1##3 9.3
R1061 net@769#11pin@370_polysilicon-1##3 net@769#11pin@370_polysilicon-1##4 9.3
R1062 net@769#11pin@370_polysilicon-1##4 net@769#11pin@370_polysilicon-1##5 9.3
R1063 net@769#11pin@370_polysilicon-1##5 net@769#11pin@370_polysilicon-1##6 9.3
R1064 net@769#11pin@370_polysilicon-1##6 net@769#4pin@371_polysilicon-1 9.3
R1065 net@523#4nmos@24_poly-right net@523#4nmos@24_poly-right##0 6.2
R1066 net@523#4nmos@24_poly-right##0 net@523#5pin@238_polysilicon-1 6.2
R1067 net@579#6pin@258_polysilicon-1 net@579#6pin@258_polysilicon-1##0 8.37
R1068 net@579#6pin@258_polysilicon-1##0 net@579#6pin@258_polysilicon-1##1 8.37
R1069 net@579#6pin@258_polysilicon-1##1 net@579#6pin@258_polysilicon-1##2 8.37
R1070 net@579#6pin@258_polysilicon-1##2 net@579#6pin@258_polysilicon-1##3 8.37
R1071 net@579#6pin@258_polysilicon-1##3 net@579 8.37
R1072 S0#16pin@363_polysilicon-1 S0 4.29
R1073 S1#89nmos@22_poly-right S1#89nmos@22_poly-right##0 7.233
R1074 S1#89nmos@22_poly-right##0 S1#89nmos@22_poly-right##1 7.233
R1075 S1#89nmos@22_poly-right##1 S1#90pin@200_polysilicon-1 7.233
R1076 S1#91nmos@23_poly-left S1#91nmos@23_poly-left##0 6.975
R1077 S1#91nmos@23_poly-left##0 S1#92pin@209_polysilicon-1 6.975
R1078 S1#92pin@209_polysilicon-1 S1#92pin@209_polysilicon-1##0 9.772
R1079 S1#92pin@209_polysilicon-1##0 S1#92pin@209_polysilicon-1##1 9.772
R1080 S1#92pin@209_polysilicon-1##1 S1#92pin@209_polysilicon-1##2 9.772
R1081 S1#92pin@209_polysilicon-1##2 S1#92pin@209_polysilicon-1##3 9.772
R1082 S1#92pin@209_polysilicon-1##3 S1#92pin@209_polysilicon-1##4 9.772
R1083 S1#92pin@209_polysilicon-1##4 S1#92pin@209_polysilicon-1##5 9.772
R1084 S1#92pin@209_polysilicon-1##5 S1#92pin@209_polysilicon-1##6 9.772
R1085 S1#92pin@209_polysilicon-1##6 S1#92pin@209_polysilicon-1##7 9.772
R1086 S1#92pin@209_polysilicon-1##7 S1#92pin@209_polysilicon-1##8 9.772
R1087 S1#92pin@209_polysilicon-1##8 S1#92pin@209_polysilicon-1##9 9.772
R1088 S1#92pin@209_polysilicon-1##9 S1#92pin@209_polysilicon-1##10 9.772
R1089 S1#92pin@209_polysilicon-1##10 S1#92pin@209_polysilicon-1##11 9.772
R1090 S1#92pin@209_polysilicon-1##11 S1#92pin@209_polysilicon-1##12 9.772
R1091 S1#92pin@209_polysilicon-1##12 S1#92pin@209_polysilicon-1##13 9.772
R1092 S1#92pin@209_polysilicon-1##13 S1#92pin@209_polysilicon-1##14 9.772
R1093 S1#92pin@209_polysilicon-1##14 S1#92pin@209_polysilicon-1##15 9.772
R1094 S1#92pin@209_polysilicon-1##15 S1#92pin@209_polysilicon-1##16 9.772
R1095 S1#92pin@209_polysilicon-1##16 S1#92pin@209_polysilicon-1##17 9.772
R1096 S1#92pin@209_polysilicon-1##17 S1#92pin@209_polysilicon-1##18 9.772
R1097 S1#92pin@209_polysilicon-1##18 S1#92pin@209_polysilicon-1##19 9.772
R1098 S1#92pin@209_polysilicon-1##19 S1#92pin@209_polysilicon-1##20 9.772
R1099 S1#92pin@209_polysilicon-1##20 S1#92pin@209_polysilicon-1##21 9.772
R1100 S1#92pin@209_polysilicon-1##21 S1#93pin@210_polysilicon-1 9.772
R1101 S1 S1##0 8.267
R1102 S1##0 S1##1 8.267
R1103 S1##1 S1#90pin@200_polysilicon-1 8.267
R1104 net@579#8nmos@27_poly-right net@579#8nmos@27_poly-right##0 6.2
R1105 net@579#8nmos@27_poly-right##0 net@579 6.2
R1106 S1#94pmos@21_poly-left S1#94pmos@21_poly-left##0 6.2
R1107 S1#94pmos@21_poly-left##0 S1#95pin@203_polysilicon-1 6.2
R1108 S2#51nmos@29_poly-left S2#51nmos@29_poly-left##0 6.975
R1109 S2#51nmos@29_poly-left##0 S2#52pin@254_polysilicon-1 6.975
R1110 S2#52pin@254_polysilicon-1 S2#52pin@254_polysilicon-1##0 9.772
R1111 S2#52pin@254_polysilicon-1##0 S2#52pin@254_polysilicon-1##1 9.772
R1112 S2#52pin@254_polysilicon-1##1 S2#52pin@254_polysilicon-1##2 9.772
R1113 S2#52pin@254_polysilicon-1##2 S2#52pin@254_polysilicon-1##3 9.772
R1114 S2#52pin@254_polysilicon-1##3 S2#52pin@254_polysilicon-1##4 9.772
R1115 S2#52pin@254_polysilicon-1##4 S2#52pin@254_polysilicon-1##5 9.772
R1116 S2#52pin@254_polysilicon-1##5 S2#52pin@254_polysilicon-1##6 9.772
R1117 S2#52pin@254_polysilicon-1##6 S2#52pin@254_polysilicon-1##7 9.772
R1118 S2#52pin@254_polysilicon-1##7 S2#52pin@254_polysilicon-1##8 9.772
R1119 S2#52pin@254_polysilicon-1##8 S2#52pin@254_polysilicon-1##9 9.772
R1120 S2#52pin@254_polysilicon-1##9 S2#52pin@254_polysilicon-1##10 9.772
R1121 S2#52pin@254_polysilicon-1##10 S2#52pin@254_polysilicon-1##11 9.772
R1122 S2#52pin@254_polysilicon-1##11 S2#52pin@254_polysilicon-1##12 9.772
R1123 S2#52pin@254_polysilicon-1##12 S2#52pin@254_polysilicon-1##13 9.772
R1124 S2#52pin@254_polysilicon-1##13 S2#52pin@254_polysilicon-1##14 9.772
R1125 S2#52pin@254_polysilicon-1##14 S2#52pin@254_polysilicon-1##15 9.772
R1126 S2#52pin@254_polysilicon-1##15 S2#52pin@254_polysilicon-1##16 9.772
R1127 S2#52pin@254_polysilicon-1##16 S2#52pin@254_polysilicon-1##17 9.772
R1128 S2#52pin@254_polysilicon-1##17 S2#52pin@254_polysilicon-1##18 9.772
R1129 S2#52pin@254_polysilicon-1##18 S2#52pin@254_polysilicon-1##19 9.772
R1130 S2#52pin@254_polysilicon-1##19 S2#52pin@254_polysilicon-1##20 9.772
R1131 S2#52pin@254_polysilicon-1##20 S2#52pin@254_polysilicon-1##21 9.772
R1132 S2#52pin@254_polysilicon-1##21 S2#27pin@255_polysilicon-1 9.772
R1133 S2#26pin@251_polysilicon-1 S2#26pin@251_polysilicon-1##0 8.267
R1134 S2#26pin@251_polysilicon-1##0 S2#26pin@251_polysilicon-1##1 8.267
R1135 S2#26pin@251_polysilicon-1##1 S2#33pin@246_polysilicon-1 8.267
R1136 net@579#9pmos@29_poly-left net@579#10pin@256_polysilicon-1 7.75
R1137 S1#96nmos@26_poly-left S1#96nmos@26_poly-left##0 6.975
R1138 S1#96nmos@26_poly-left##0 S1#97pin@232_polysilicon-1 6.975
R1139 net@579#10pin@256_polysilicon-1 net@579#10pin@256_polysilicon-1##0 9.042
R1140 net@579#10pin@256_polysilicon-1##0 net@579#10pin@256_polysilicon-1##1 9.042
R1141 net@579#10pin@256_polysilicon-1##1 net@579#10pin@256_polysilicon-1##2 9.042
R1142 net@579#10pin@256_polysilicon-1##2 net@579#10pin@256_polysilicon-1##3 9.042
R1143 net@579#10pin@256_polysilicon-1##3 net@579#10pin@256_polysilicon-1##4 9.042
R1144 net@579#10pin@256_polysilicon-1##4 net@579#11pin@257_polysilicon-1 9.042
R1145 net@579#11pin@257_polysilicon-1 net@579#11pin@257_polysilicon-1##0 9.3
R1146 net@579#11pin@257_polysilicon-1##0 net@579#11pin@257_polysilicon-1##1 9.3
R1147 net@579#11pin@257_polysilicon-1##1 net@579#11pin@257_polysilicon-1##2 9.3
R1148 net@579#11pin@257_polysilicon-1##2 net@579#11pin@257_polysilicon-1##3 9.3
R1149 net@579#11pin@257_polysilicon-1##3 net@579#11pin@257_polysilicon-1##4 9.3
R1150 net@579#11pin@257_polysilicon-1##4 net@579#11pin@257_polysilicon-1##5 9.3
R1151 net@579#11pin@257_polysilicon-1##5 net@579#11pin@257_polysilicon-1##6 9.3
R1152 net@579#11pin@257_polysilicon-1##6 net@579#6pin@258_polysilicon-1 9.3
R1153 net@500#7pmos@23_poly-left net@500#8pin@211_polysilicon-1 7.75
R1154 S1#95pin@203_polysilicon-1 S1#95pin@203_polysilicon-1##0 9.896
R1155 S1#95pin@203_polysilicon-1##0 S1#95pin@203_polysilicon-1##1 9.896
R1156 S1#95pin@203_polysilicon-1##1 S1#95pin@203_polysilicon-1##2 9.896
R1157 S1#95pin@203_polysilicon-1##2 S1#95pin@203_polysilicon-1##3 9.896
R1158 S1#95pin@203_polysilicon-1##3 S1#95pin@203_polysilicon-1##4 9.896
R1159 S1#95pin@203_polysilicon-1##4 S1#95pin@203_polysilicon-1##5 9.896
R1160 S1#95pin@203_polysilicon-1##5 S1#95pin@203_polysilicon-1##6 9.896
R1161 S1#95pin@203_polysilicon-1##6 S1#95pin@203_polysilicon-1##7 9.896
R1162 S1#95pin@203_polysilicon-1##7 S1#95pin@203_polysilicon-1##8 9.896
R1163 S1#95pin@203_polysilicon-1##8 S1#95pin@203_polysilicon-1##9 9.896
R1164 S1#95pin@203_polysilicon-1##9 S1#95pin@203_polysilicon-1##10 9.896
R1165 S1#95pin@203_polysilicon-1##10 S1#95pin@203_polysilicon-1##11 9.896
R1166 S1#95pin@203_polysilicon-1##11 S1#98pin@204_polysilicon-1 9.896
R1167 S1#98pin@204_polysilicon-1 S1#98pin@204_polysilicon-1##0 9.521
R1168 S1#98pin@204_polysilicon-1##0 S1#98pin@204_polysilicon-1##1 9.521
R1169 S1#98pin@204_polysilicon-1##1 S1#98pin@204_polysilicon-1##2 9.521
R1170 S1#98pin@204_polysilicon-1##2 S1#98pin@204_polysilicon-1##3 9.521
R1171 S1#98pin@204_polysilicon-1##3 S1#98pin@204_polysilicon-1##4 9.521
R1172 S1#98pin@204_polysilicon-1##4 S1#98pin@204_polysilicon-1##5 9.521
R1173 S1#98pin@204_polysilicon-1##5 S1 9.521
R1174 S1#97pin@232_polysilicon-1 S1#97pin@232_polysilicon-1##0 9.772
R1175 S1#97pin@232_polysilicon-1##0 S1#97pin@232_polysilicon-1##1 9.772
R1176 S1#97pin@232_polysilicon-1##1 S1#97pin@232_polysilicon-1##2 9.772
R1177 S1#97pin@232_polysilicon-1##2 S1#97pin@232_polysilicon-1##3 9.772
R1178 S1#97pin@232_polysilicon-1##3 S1#97pin@232_polysilicon-1##4 9.772
R1179 S1#97pin@232_polysilicon-1##4 S1#97pin@232_polysilicon-1##5 9.772
R1180 S1#97pin@232_polysilicon-1##5 S1#97pin@232_polysilicon-1##6 9.772
R1181 S1#97pin@232_polysilicon-1##6 S1#97pin@232_polysilicon-1##7 9.772
R1182 S1#97pin@232_polysilicon-1##7 S1#97pin@232_polysilicon-1##8 9.772
R1183 S1#97pin@232_polysilicon-1##8 S1#97pin@232_polysilicon-1##9 9.772
R1184 S1#97pin@232_polysilicon-1##9 S1#97pin@232_polysilicon-1##10 9.772
R1185 S1#97pin@232_polysilicon-1##10 S1#97pin@232_polysilicon-1##11 9.772
R1186 S1#97pin@232_polysilicon-1##11 S1#97pin@232_polysilicon-1##12 9.772
R1187 S1#97pin@232_polysilicon-1##12 S1#97pin@232_polysilicon-1##13 9.772
R1188 S1#97pin@232_polysilicon-1##13 S1#97pin@232_polysilicon-1##14 9.772
R1189 S1#97pin@232_polysilicon-1##14 S1#97pin@232_polysilicon-1##15 9.772
R1190 S1#97pin@232_polysilicon-1##15 S1#97pin@232_polysilicon-1##16 9.772
R1191 S1#97pin@232_polysilicon-1##16 S1#97pin@232_polysilicon-1##17 9.772
R1192 S1#97pin@232_polysilicon-1##17 S1#97pin@232_polysilicon-1##18 9.772
R1193 S1#97pin@232_polysilicon-1##18 S1#97pin@232_polysilicon-1##19 9.772
R1194 S1#97pin@232_polysilicon-1##19 S1#97pin@232_polysilicon-1##20 9.772
R1195 S1#97pin@232_polysilicon-1##20 S1#97pin@232_polysilicon-1##21 9.772
R1196 S1#97pin@232_polysilicon-1##21 S1#100pin@233_polysilicon-1 9.772
R1197 net@500#8pin@211_polysilicon-1 net@500#8pin@211_polysilicon-1##0 9.042
R1198 net@500#8pin@211_polysilicon-1##0 net@500#8pin@211_polysilicon-1##1 9.042
R1199 net@500#8pin@211_polysilicon-1##1 net@500#8pin@211_polysilicon-1##2 9.042
R1200 net@500#8pin@211_polysilicon-1##2 net@500#8pin@211_polysilicon-1##3 9.042
R1201 net@500#8pin@211_polysilicon-1##3 net@500#8pin@211_polysilicon-1##4 9.042
R1202 net@500#8pin@211_polysilicon-1##4 net@500#9pin@212_polysilicon-1 9.042
R1203 S1#90pin@200_polysilicon-1 S1#90pin@200_polysilicon-1##0 5.425
R1204 S1#90pin@200_polysilicon-1##0 S1#101pmos@22_poly-right 5.425
R1205 S1 S1##0 8.267
R1206 S1##0 S1##1 8.267
R1207 S1##1 S1#103pin@223_polysilicon-1 8.267
R1208 net@500#9pin@212_polysilicon-1 net@500#9pin@212_polysilicon-1##0 9.3
R1209 net@500#9pin@212_polysilicon-1##0 net@500#9pin@212_polysilicon-1##1 9.3
R1210 net@500#9pin@212_polysilicon-1##1 net@500#9pin@212_polysilicon-1##2 9.3
R1211 net@500#9pin@212_polysilicon-1##2 net@500#9pin@212_polysilicon-1##3 9.3
R1212 net@500#9pin@212_polysilicon-1##3 net@500#9pin@212_polysilicon-1##4 9.3
R1213 net@500#9pin@212_polysilicon-1##4 net@500#9pin@212_polysilicon-1##5 9.3
R1214 net@500#9pin@212_polysilicon-1##5 net@500#9pin@212_polysilicon-1##6 9.3
R1215 net@500#9pin@212_polysilicon-1##6 net@500#3pin@213_polysilicon-1 9.3
R1216 S1 S1##0 9.881
R1217 S1##0 S1##1 9.881
R1218 S1##1 S1##2 9.881
R1219 S1##2 S1##3 9.881
R1220 S1##3 S1##4 9.881
R1221 S1##4 S1##5 9.881
R1222 S1##5 S1##6 9.881
R1223 S1##6 S1#100pin@233_polysilicon-1 9.881
R1224 net@523#5pin@238_polysilicon-1 net@523#5pin@238_polysilicon-1##0 9.042
R1225 net@523#5pin@238_polysilicon-1##0 net@523#5pin@238_polysilicon-1##1 9.042
R1226 net@523#5pin@238_polysilicon-1##1 net@523#5pin@238_polysilicon-1##2 9.042
R1227 net@523#5pin@238_polysilicon-1##2 net@523#5pin@238_polysilicon-1##3 9.042
R1228 net@523#5pin@238_polysilicon-1##3 net@523#5pin@238_polysilicon-1##4 9.042
R1229 net@523#5pin@238_polysilicon-1##4 net@523#6contact@209_metal-1-n-act 9.042
R1230 S1 S1##0 9.881
R1231 S1##0 S1##1 9.881
R1232 S1##1 S1##2 9.881
R1233 S1##2 S1##3 9.881
R1234 S1##3 S1##4 9.881
R1235 S1##4 S1##5 9.881
R1236 S1##5 S1##6 9.881
R1237 S1##6 S1#93pin@210_polysilicon-1 9.881
R1238 S1#105nmos@25_poly-right S1#105nmos@25_poly-right##0 7.233
R1239 S1#105nmos@25_poly-right##0 S1#105nmos@25_poly-right##1 7.233
R1240 S1#105nmos@25_poly-right##1 S1#103pin@223_polysilicon-1 7.233
R1241 S1#106pmos@24_poly-left S1#106pmos@24_poly-left##0 6.2
R1242 S1#106pmos@24_poly-left##0 S1#107pin@226_polysilicon-1 6.2
R1243 S1#107pin@226_polysilicon-1 S1#107pin@226_polysilicon-1##0 9.896
R1244 S1#107pin@226_polysilicon-1##0 S1#107pin@226_polysilicon-1##1 9.896
R1245 S1#107pin@226_polysilicon-1##1 S1#107pin@226_polysilicon-1##2 9.896
R1246 S1#107pin@226_polysilicon-1##2 S1#107pin@226_polysilicon-1##3 9.896
R1247 S1#107pin@226_polysilicon-1##3 S1#107pin@226_polysilicon-1##4 9.896
R1248 S1#107pin@226_polysilicon-1##4 S1#107pin@226_polysilicon-1##5 9.896
R1249 S1#107pin@226_polysilicon-1##5 S1#107pin@226_polysilicon-1##6 9.896
R1250 S1#107pin@226_polysilicon-1##6 S1#107pin@226_polysilicon-1##7 9.896
R1251 S1#107pin@226_polysilicon-1##7 S1#107pin@226_polysilicon-1##8 9.896
R1252 S1#107pin@226_polysilicon-1##8 S1#107pin@226_polysilicon-1##9 9.896
R1253 S1#107pin@226_polysilicon-1##9 S1#107pin@226_polysilicon-1##10 9.896
R1254 S1#107pin@226_polysilicon-1##10 S1#107pin@226_polysilicon-1##11 9.896
R1255 S1#107pin@226_polysilicon-1##11 S1#108pin@227_polysilicon-1 9.896
R1256 S1#108pin@227_polysilicon-1 S1#108pin@227_polysilicon-1##0 9.521
R1257 S1#108pin@227_polysilicon-1##0 S1#108pin@227_polysilicon-1##1 9.521
R1258 S1#108pin@227_polysilicon-1##1 S1#108pin@227_polysilicon-1##2 9.521
R1259 S1#108pin@227_polysilicon-1##2 S1#108pin@227_polysilicon-1##3 9.521
R1260 S1#108pin@227_polysilicon-1##3 S1#108pin@227_polysilicon-1##4 9.521
R1261 S1#108pin@227_polysilicon-1##4 S1#108pin@227_polysilicon-1##5 9.521
R1262 S1#108pin@227_polysilicon-1##5 S1 9.521
R1263 S1#103pin@223_polysilicon-1 S1#103pin@223_polysilicon-1##0 5.425
R1264 S1#103pin@223_polysilicon-1##0 S1#109pmos@25_poly-right 5.425
R1265 net@500#4pin@215_polysilicon-1 net@500#4pin@215_polysilicon-1##0 9.042
R1266 net@500#4pin@215_polysilicon-1##0 net@500#4pin@215_polysilicon-1##1 9.042
R1267 net@500#4pin@215_polysilicon-1##1 net@500#4pin@215_polysilicon-1##2 9.042
R1268 net@500#4pin@215_polysilicon-1##2 net@500#4pin@215_polysilicon-1##3 9.042
R1269 net@500#4pin@215_polysilicon-1##3 net@500#4pin@215_polysilicon-1##4 9.042
R1270 net@500#4pin@215_polysilicon-1##4 net@500 9.042
R1271 net@523#3pin@236_polysilicon-1 net@523#3pin@236_polysilicon-1##0 8.37
R1272 net@523#3pin@236_polysilicon-1##0 net@523#3pin@236_polysilicon-1##1 8.37
R1273 net@523#3pin@236_polysilicon-1##1 net@523#3pin@236_polysilicon-1##2 8.37
R1274 net@523#3pin@236_polysilicon-1##2 net@523#3pin@236_polysilicon-1##3 8.37
R1275 net@523#3pin@236_polysilicon-1##3 net@523#5pin@238_polysilicon-1 8.37
R1276 S2 S2#26pin@251_polysilicon-1 6.5
R1277 net@1027#4pin@425_polysilicon-1 net@1027#4pin@425_polysilicon-1##0 8.37
R1278 net@1027#4pin@425_polysilicon-1##0 net@1027#4pin@425_polysilicon-1##1 8.37
R1279 net@1027#4pin@425_polysilicon-1##1 net@1027#4pin@425_polysilicon-1##2 8.37
R1280 net@1027#4pin@425_polysilicon-1##2 net@1027#4pin@425_polysilicon-1##3 8.37
R1281 net@1027#4pin@425_polysilicon-1##3 net@1027#5pin@427_polysilicon-1 8.37
R1282 net@1027#6nmos@42_poly-right net@1027#6nmos@42_poly-right##0 6.2
R1283 net@1027#6nmos@42_poly-right##0 net@1027#5pin@427_polysilicon-1 6.2
R1284 net@1027#5pin@427_polysilicon-1 net@1027#5pin@427_polysilicon-1##0 9.042
R1285 net@1027#5pin@427_polysilicon-1##0 net@1027#5pin@427_polysilicon-1##1 9.042
R1286 net@1027#5pin@427_polysilicon-1##1 net@1027#5pin@427_polysilicon-1##2 9.042
R1287 net@1027#5pin@427_polysilicon-1##2 net@1027#5pin@427_polysilicon-1##3 9.042
R1288 net@1027#5pin@427_polysilicon-1##3 net@1027#5pin@427_polysilicon-1##4 9.042
R1289 net@1027#5pin@427_polysilicon-1##4 net@1027 9.042
R1290 S3#0pmos@42_poly-left S3#0pmos@42_poly-left##0 6.2
R1291 S3#0pmos@42_poly-left##0 S3#1pin@415_polysilicon-1 6.2
R1292 S3#1pin@415_polysilicon-1 S3#1pin@415_polysilicon-1##0 9.896
R1293 S3#1pin@415_polysilicon-1##0 S3#1pin@415_polysilicon-1##1 9.896
R1294 S3#1pin@415_polysilicon-1##1 S3#1pin@415_polysilicon-1##2 9.896
R1295 S3#1pin@415_polysilicon-1##2 S3#1pin@415_polysilicon-1##3 9.896
R1296 S3#1pin@415_polysilicon-1##3 S3#1pin@415_polysilicon-1##4 9.896
R1297 S3#1pin@415_polysilicon-1##4 S3#1pin@415_polysilicon-1##5 9.896
R1298 S3#1pin@415_polysilicon-1##5 S3#1pin@415_polysilicon-1##6 9.896
R1299 S3#1pin@415_polysilicon-1##6 S3#1pin@415_polysilicon-1##7 9.896
R1300 S3#1pin@415_polysilicon-1##7 S3#1pin@415_polysilicon-1##8 9.896
R1301 S3#1pin@415_polysilicon-1##8 S3#1pin@415_polysilicon-1##9 9.896
R1302 S3#1pin@415_polysilicon-1##9 S3#1pin@415_polysilicon-1##10 9.896
R1303 S3#1pin@415_polysilicon-1##10 S3#1pin@415_polysilicon-1##11 9.896
R1304 S3#1pin@415_polysilicon-1##11 S3#2pin@416_polysilicon-1 9.896
R1305 S3#3nmos@44_poly-left S3#3nmos@44_poly-left##0 6.975
R1306 S3#3nmos@44_poly-left##0 S3#4pin@421_polysilicon-1 6.975
R1307 S3#4pin@421_polysilicon-1 S3#4pin@421_polysilicon-1##0 9.772
R1308 S3#4pin@421_polysilicon-1##0 S3#4pin@421_polysilicon-1##1 9.772
R1309 S3#4pin@421_polysilicon-1##1 S3#4pin@421_polysilicon-1##2 9.772
R1310 S3#4pin@421_polysilicon-1##2 S3#4pin@421_polysilicon-1##3 9.772
R1311 S3#4pin@421_polysilicon-1##3 S3#4pin@421_polysilicon-1##4 9.772
R1312 S3#4pin@421_polysilicon-1##4 S3#4pin@421_polysilicon-1##5 9.772
R1313 S3#4pin@421_polysilicon-1##5 S3#4pin@421_polysilicon-1##6 9.772
R1314 S3#4pin@421_polysilicon-1##6 S3#4pin@421_polysilicon-1##7 9.772
R1315 S3#4pin@421_polysilicon-1##7 S3#4pin@421_polysilicon-1##8 9.772
R1316 S3#4pin@421_polysilicon-1##8 S3#4pin@421_polysilicon-1##9 9.772
R1317 S3#4pin@421_polysilicon-1##9 S3#4pin@421_polysilicon-1##10 9.772
R1318 S3#4pin@421_polysilicon-1##10 S3#4pin@421_polysilicon-1##11 9.772
R1319 S3#4pin@421_polysilicon-1##11 S3#4pin@421_polysilicon-1##12 9.772
R1320 S3#4pin@421_polysilicon-1##12 S3#4pin@421_polysilicon-1##13 9.772
R1321 S3#4pin@421_polysilicon-1##13 S3#4pin@421_polysilicon-1##14 9.772
R1322 S3#4pin@421_polysilicon-1##14 S3#4pin@421_polysilicon-1##15 9.772
R1323 S3#4pin@421_polysilicon-1##15 S3#4pin@421_polysilicon-1##16 9.772
R1324 S3#4pin@421_polysilicon-1##16 S3#4pin@421_polysilicon-1##17 9.772
R1325 S3#4pin@421_polysilicon-1##17 S3#4pin@421_polysilicon-1##18 9.772
R1326 S3#4pin@421_polysilicon-1##18 S3#4pin@421_polysilicon-1##19 9.772
R1327 S3#4pin@421_polysilicon-1##19 S3#4pin@421_polysilicon-1##20 9.772
R1328 S3#4pin@421_polysilicon-1##20 S3#4pin@421_polysilicon-1##21 9.772
R1329 S3#4pin@421_polysilicon-1##21 S3#5pin@422_polysilicon-1 9.772
R1330 net@1027#9pmos@44_poly-left net@1027#10pin@423_polysilicon-1 7.75
R1331 net@1027#10pin@423_polysilicon-1 net@1027#10pin@423_polysilicon-1##0 9.042
R1332 net@1027#10pin@423_polysilicon-1##0 net@1027#10pin@423_polysilicon-1##1 9.042
R1333 net@1027#10pin@423_polysilicon-1##1 net@1027#10pin@423_polysilicon-1##2 9.042
R1334 net@1027#10pin@423_polysilicon-1##2 net@1027#10pin@423_polysilicon-1##3 9.042
R1335 net@1027#10pin@423_polysilicon-1##3 net@1027#10pin@423_polysilicon-1##4 9.042
R1336 net@1027#10pin@423_polysilicon-1##4 net@1027#11pin@424_polysilicon-1 9.042
R1337 net@1027#11pin@424_polysilicon-1 net@1027#11pin@424_polysilicon-1##0 9.3
R1338 net@1027#11pin@424_polysilicon-1##0 net@1027#11pin@424_polysilicon-1##1 9.3
R1339 net@1027#11pin@424_polysilicon-1##1 net@1027#11pin@424_polysilicon-1##2 9.3
R1340 net@1027#11pin@424_polysilicon-1##2 net@1027#11pin@424_polysilicon-1##3 9.3
R1341 net@1027#11pin@424_polysilicon-1##3 net@1027#11pin@424_polysilicon-1##4 9.3
R1342 net@1027#11pin@424_polysilicon-1##4 net@1027#11pin@424_polysilicon-1##5 9.3
R1343 net@1027#11pin@424_polysilicon-1##5 net@1027#11pin@424_polysilicon-1##6 9.3
R1344 net@1027#11pin@424_polysilicon-1##6 net@1027#4pin@425_polysilicon-1 9.3
R1345 net@269 net@269#15pmos@42_diff-bottom 4.043
R1346 S3#6nmos@43_poly-right S3#6nmos@43_poly-right##0 6.975
R1347 S3#6nmos@43_poly-right##0 S3#7pin@476_polysilicon-1 6.975
R1348 S3#7pin@476_polysilicon-1 S3#7pin@476_polysilicon-1##0 9.3
R1349 S3#7pin@476_polysilicon-1##0 S3#8pmos@43_poly-right 9.3
R1350 S3#5pin@422_polysilicon-1 S3#5pin@422_polysilicon-1##0 8.913
R1351 S3#5pin@422_polysilicon-1##0 S3#5pin@422_polysilicon-1##1 8.913
R1352 S3#5pin@422_polysilicon-1##1 S3#5pin@422_polysilicon-1##2 8.913
R1353 S3#5pin@422_polysilicon-1##2 S3#5pin@422_polysilicon-1##3 8.913
R1354 S3#5pin@422_polysilicon-1##3 S3#5pin@422_polysilicon-1##4 8.913
R1355 S3#5pin@422_polysilicon-1##4 S3#5pin@422_polysilicon-1##5 8.913
R1356 S3#5pin@422_polysilicon-1##5 S3#5pin@422_polysilicon-1##6 8.913
R1357 S3#5pin@422_polysilicon-1##6 S3#9pin@477_polysilicon-1 8.913
R1358 S3#9pin@477_polysilicon-1 S3#9pin@477_polysilicon-1##0 9.3
R1359 S3#9pin@477_polysilicon-1##0 S3#9pin@477_polysilicon-1##1 9.3
R1360 S3#9pin@477_polysilicon-1##1 S3#9pin@477_polysilicon-1##2 9.3
R1361 S3#9pin@477_polysilicon-1##2 S3#9pin@477_polysilicon-1##3 9.3
R1362 S3#9pin@477_polysilicon-1##3 S3#9pin@477_polysilicon-1##4 9.3
R1363 S3#9pin@477_polysilicon-1##4 S3#9pin@477_polysilicon-1##5 9.3
R1364 S3#9pin@477_polysilicon-1##5 S3#9pin@477_polysilicon-1##6 9.3
R1365 S3#9pin@477_polysilicon-1##6 S3#2pin@416_polysilicon-1 9.3
R1366 S3#7pin@476_polysilicon-1 S3#7pin@476_polysilicon-1##0 8.783
R1367 S3#7pin@476_polysilicon-1##0 S3#7pin@476_polysilicon-1##1 8.783
R1368 S3#7pin@476_polysilicon-1##1 S3#9pin@477_polysilicon-1 8.783
R1369 S3#9pin@477_polysilicon-1 S3#9pin@477_polysilicon-1##0 6.2
R1370 S3#9pin@477_polysilicon-1##0 S3#10pin@478_polysilicon-1 6.2
R1371 S3#10pin@478_polysilicon-1 S3#10pin@478_polysilicon-1##0 7.75
R1372 S3#10pin@478_polysilicon-1##0 S3#10pin@478_polysilicon-1##1 7.75
R1373 S3#10pin@478_polysilicon-1##1 S3 7.75

* Spice Code nodes in cell cell 'MUX_16_1_TG_3{lay}'
VDD VDD 0 DC 3.3
VGND GND 0 DC 0
Vin16 S2  0 PULSE  (3.3 0 0 1u 1u 400u 800u)
Vin17 S1  0 PULSE  (3.3 0 0 1u 1u 800u 1600u)
Vin18 S0  0 PULSE  (3.3 0 0 1u 1u 1600u 3200u)
Vin19 S3  0 PULSE  (3.3 0 0 1u 1u 3200u 6400u)
Vin0  I0  0 pulse 0 3.3 0u   1u 1u 100u 6400u
Vin1  I1  0 pulse 0 3.3 400u 1u 1u 100u 6400u
Vin2  I2  0 pulse 0 3.3 800u 1u 1u 100u 6400u
Vin3  I3  0 pulse 0 3.3 1200u 1u 1u 100u 6400u
Vin4  I4  0 pulse 0 3.3 1600u 1u 1u 100u 6400u
Vin5  I5  0 pulse 0 3.3 2000u 1u 1u 100u 6400u
Vin6  I6  0 pulse 0 3.3 2400u 1u 1u 100u 6400u
Vin7  I7  0 pulse 0 3.3 2800u 1u 1u 100u 6400u
Vin8  I8  0 pulse 0 3.3 3200u 1u 1u 100u 6400u
Vin9  I9  0 pulse 0 3.3 3600u 1u 1u 100u 6400u
Vin10 I10 0 pulse 0 3.3 4000u 1u 1u 100u 6400u
Vin11 I11 0 pulse 0 3.3 4400u 1u 1u 100u 6400u
Vin12 I12 0 pulse 0 3.3 4800u 1u 1u 100u 6400u
Vin13 I13 0 pulse 0 3.3 5200u 1u 1u 100u 6400u
Vin14 I14 0 pulse 0 3.3 5600u 1u 1u 100u 6400u
Vin15 I15 0 pulse 0 3.3 6000u 1u 1u 100u 6400u
cload out 0 250fF
.TRAN 0 6400u
.include C:\Electric\C5_models.txt
.END
