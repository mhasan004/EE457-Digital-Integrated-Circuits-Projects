*** SPICE deck for cell MUX_16_1_TG_2_2{lay} from library MUX_16_1
*** Created on Wed May 13, 2020 21:36:32
*** Last revised on Wed May 13, 2020 22:24:37
*** Written on Wed May 13, 2020 22:24:39 by Electric VLSI Design System, version 9.07
*** Layout tech: mocmos, foundry MOSIS
*** UC SPICE *** , MIN_RESIST 4.0, MIN_CAPAC 0.1FF
***    P-Active:	areacap=0.9FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    N-Active:	areacap=0.9FF/um^2,	edgecap=0.0FF/um,	res=3.0ohms/sq
***    Polysilicon-1:	areacap=0.1467FF/um^2,	edgecap=0.0608FF/um,	res=6.2ohms/sq
***    Polysilicon-2:	areacap=1.0FF/um^2,	edgecap=0.0FF/um,	res=50.0ohms/sq
***    Transistor-Poly:	areacap=0.09FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    Poly-Cut:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=2.2ohms/sq
***    Active-Cut:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    Metal-1:	areacap=0.1209FF/um^2,	edgecap=0.1104FF/um,	res=0.078ohms/sq
***    Via1:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=1.0ohms/sq
***    Metal-2:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via2:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.9ohms/sq
***    Metal-3:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via3:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-4:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via4:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-5:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via5:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-6:	areacap=0.0423FF/um^2,	edgecap=0.1273FF/um,	res=0.036ohms/sq
***    Hi-Res:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=1.0ohms/sq

*** TOP LEVEL CELL: MUX_16_1_TG_2_2{lay}
Mnmos@0 net@0 net@1#6nmos@0_poly-right I4 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@1 net@1 S1#34nmos@1_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=49.01P AD=1.684P PS=76.615U PD=5.425U
Mnmos@2 net@0 S1#36nmos@2_poly-left I6 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@3 net@33 net@24#4nmos@3_poly-right I5 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@4 net@24#6contact@26_metal-1-n-act S1#50nmos@4_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=49.01P AD=1.684P PS=76.615U PD=5.425U
Mnmos@5 net@33 S1#41nmos@5_poly-left I7 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@6 net@11 net@80#8nmos@6_poly-right net@0 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@7 net@80#1contact@56_metal-1-polysilicon-1 S2#6nmos@7_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=49.01P AD=1.684P PS=76.615U PD=5.425U
Mnmos@8 net@11 S2#24nmos@8_poly-left net@33 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@9 net@6 net@7#7nmos@9_poly-right I0 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@10 net@7 S1#25nmos@10_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=49.01P AD=1.684P PS=76.615U PD=5.425U
Mnmos@11 net@6 S1#11nmos@11_poly-left I2 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@12 net@27 net@8#11nmos@12_poly-right I1 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@13 net@8#4contact@94_metal-1-n-act S1#18nmos@13_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=49.01P AD=1.684P PS=76.615U PD=5.425U
Mnmos@14 net@27 S1#28nmos@14_poly-left I3 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@15 net@110 net@123#8nmos@15_poly-right net@6 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@16 net@123 S2#4nmos@16_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=49.01P AD=1.684P PS=76.615U PD=5.425U
Mnmos@17 net@110 S2#16nmos@17_poly-left net@27 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@18 net@269 net@270#6nmos@18_poly-right net@110 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@19 net@270 S0#2nmos@19_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=49.01P AD=1.684P PS=76.615U PD=5.425U
Mnmos@20 net@269 S0#10nmos@20_poly-left net@11 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@21 net@999 net@1000#6nmos@21_poly-right I12 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@22 net@1000 net@1001#22nmos@22_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=49.01P AD=1.684P PS=76.615U PD=5.425U
Mnmos@23 net@999 net@1001#24nmos@23_poly-left I14 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@24 net@1175 net@1064#3nmos@24_poly-right I13 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@25 net@1064#5contact@209_metal-1-n-act net@1001#40nmos@25_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=49.01P AD=1.684P PS=76.615U PD=5.425U
Mnmos@26 net@1175 net@1001#31nmos@26_poly-left I15 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@27 net@1034 net@1082#8nmos@27_poly-right net@999 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@28 net@1082 S2#47nmos@28_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=49.01P AD=1.684P PS=76.615U PD=5.425U
Mnmos@29 net@1034 S2#42nmos@29_poly-left net@1175 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@30 net@1024 net@1063#6nmos@30_poly-right I0 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@31 net@1063 net@1001#56nmos@31_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=49.01P AD=1.684P PS=76.615U PD=5.425U
Mnmos@32 net@1024 net@1001#47nmos@32_poly-left I10 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@33 net@1002 net@1028#10nmos@33_poly-right I9 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@34 net@1028#4pmos@34_diff-top net@1001#51nmos@34_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=49.01P AD=1.684P PS=76.615U PD=5.425U
Mnmos@35 net@1002 net@1001#5nmos@35_poly-left i11 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@36 net@1021 net@1006 net@1024 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@37 net@1006#6contact@296_metal-1-n-act S2#46nmos@37_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=49.01P AD=1.684P PS=76.615U PD=5.425U
Mnmos@38 net@1021 S2#26nmos@38_poly-left net@1002 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@39 net@1099 net@1102#6nmos@39_poly-right net@1021 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@40 net@1102 S0#18nmos@40_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=49.01P AD=1.684P PS=76.615U PD=5.425U
Mnmos@41 net@1099 S0#26nmos@41_poly-left net@1034 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@42 out net@1511#6nmos@42_poly-right net@269 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mnmos@43 net@1511 S3#2nmos@43_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=49.01P AD=1.684P PS=76.615U PD=5.425U
Mnmos@44 out S3#10nmos@44_poly-left net@1099 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@0 I4 S1#39pmos@0_poly-left net@0 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@1 vdd S1#46pmos@1_poly-right net@1 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=67.336P PS=5.425U PD=80.232U
Mpmos@2 I6 net@1#7pmos@2_poly-left net@0 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@3 I5 S1#51pmos@3_poly-left net@33 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@4 vdd S1#54pmos@4_poly-right net@24#6contact@26_metal-1-n-act vdd PMOS L=0.35U W=1.75U AS=1.684P AD=67.336P PS=5.425U PD=80.232U
Mpmos@5 I7 net@24#2pmos@5_poly-left net@33 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@6 net@0 S2#14pmos@6_poly-left net@11 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@7 vdd S2#20pmos@7_poly-right net@80#1contact@56_metal-1-polysilicon-1 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=67.336P PS=5.425U PD=80.232U
Mpmos@8 net@33 net@80#9pmos@8_poly-left net@11 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@9 I0 S1#26pmos@9_poly-left net@6 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@10 vdd S1#31pmos@10_poly-right net@7 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=67.336P PS=5.425U PD=80.232U
Mpmos@11 I2 net@7#8pmos@11_poly-left net@6 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@12 I1 S1#20pmos@12_poly-left net@27 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@13 vdd S1#24pmos@13_poly-right net@8#4contact@94_metal-1-n-act vdd PMOS L=0.35U W=1.75U AS=1.684P AD=67.336P PS=5.425U PD=80.232U
Mpmos@14 I3 net@8 net@27 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@15 net@6 S2#8pmos@15_poly-left net@110 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@16 vdd S2#12pmos@16_poly-right net@123 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=67.336P PS=5.425U PD=80.232U
Mpmos@17 net@27 net@123#9pmos@17_poly-left net@110 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@18 net@110 S0#4pmos@18_poly-left net@269 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@19 vdd S0#8pmos@19_poly-right net@270 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=67.336P PS=5.425U PD=80.232U
Mpmos@20 net@11 net@270#9pmos@20_poly-left net@269 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@21 I12 net@1001#29pmos@21_poly-left net@999 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@22 vdd net@1001#36pmos@22_poly-right net@1000 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=67.336P PS=5.425U PD=80.232U
Mpmos@23 I14 net@1000#7pmos@23_poly-left net@999 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@24 I13 net@1001#41pmos@24_poly-left net@1175 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@25 vdd net@1001#44pmos@25_poly-right net@1064#5contact@209_metal-1-n-act vdd PMOS L=0.35U W=1.75U AS=1.684P AD=67.336P PS=5.425U PD=80.232U
Mpmos@26 I15 net@1064#2pmos@26_poly-left net@1175 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@27 net@999 S2#52pmos@27_poly-left net@1034 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@28 vdd S2#36pmos@28_poly-right net@1082 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=67.336P PS=5.425U PD=80.232U
Mpmos@29 net@1175 net@1082#9pmos@29_poly-left net@1034 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@30 I0 net@1001#3pmos@30_poly-left net@1024 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@31 vdd net@1001#15pmos@31_poly-right net@1063 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=67.336P PS=5.425U PD=80.232U
Mpmos@32 I10 net@1063#7pmos@32_poly-left net@1024 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@33 I9 net@1001#52pmos@33_poly-left net@1002 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@34 vdd net@1001#27pmos@34_poly-right net@1028#4pmos@34_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=67.336P PS=5.425U PD=80.232U
Mpmos@35 i11 net@1028#8pmos@35_poly-left net@1002 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@36 net@1024 S2#48pmos@36_poly-left net@1021 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@37 vdd S2#51pmos@37_poly-right net@1006#6contact@296_metal-1-n-act vdd PMOS L=0.35U W=1.75U AS=1.684P AD=67.336P PS=5.425U PD=80.232U
Mpmos@38 net@1002 net@1006#2pmos@38_poly-left net@1021 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@39 net@1021 S0#20pmos@39_poly-left net@1099 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@40 vdd S0#24pmos@40_poly-right net@1102 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=67.336P PS=5.425U PD=80.232U
Mpmos@41 net@1034 net@1102#9pmos@41_poly-left net@1099 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@42 net@269 S3#4pmos@42_poly-left out vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
Mpmos@43 vdd S3#8pmos@43_poly-right net@1511 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=67.336P PS=5.425U PD=80.232U
Mpmos@44 net@1099 net@1511#9pmos@44_poly-left out vdd PMOS L=0.35U W=1.75U AS=1.684P AD=1.684P PS=5.425U PD=5.425U
** Extracted Parasitic Capacitors ***
C0 I4 0 5.094fF
C1 net@0 0 16.814fF
C2 net@1 0 1.643fF
C3 S1 0 20.228fF
C4 I6 0 6.89fF
C5 I5 0 5.673fF
C6 net@33 0 13.451fF
C7 net@24#6contact@26_metal-1-n-act 0 1.643fF
C8 I7 0 6.683fF
C9 net@11 0 25.138fF
C10 net@80#1contact@56_metal-1-polysilicon-1 0 1.643fF
C11 S2 0 19.157fF
C12 I0 0 39.434fF
C13 net@6 0 16.814fF
C14 net@7 0 1.643fF
C15 I2 0 13.799fF
C16 I1 0 12.638fF
C17 net@27 0 13.451fF
C18 net@8#4contact@94_metal-1-n-act 0 1.643fF
C19 I3 0 13.795fF
C20 net@110 0 12.136fF
C21 net@123 0 1.643fF
C22 net@269 0 21.317fF
C23 net@270 0 1.643fF
C24 S0#0pin@165_polysilicon-1 0 12.121fF
C25 S0 0 13.964fF
C26 I12 0 5.094fF
C27 net@999 0 16.814fF
C28 net@1000 0 1.643fF
C29 net@1001 0 20.228fF
C30 I14 0 6.89fF
C31 I13 0 5.673fF
C32 net@1175 0 13.451fF
C33 net@1064#5contact@209_metal-1-n-act 0 1.643fF
C34 I15 0 6.683fF
C35 net@1034 0 25.138fF
C36 net@1082 0 1.643fF
C37 S2#29contact@299_metal-1-polysilicon-1 0 15.582fF
C38 net@1024 0 16.814fF
C39 net@1063 0 1.643fF
C40 I10 0 13.799fF
C41 I9 0 12.638fF
C42 net@1002 0 13.451fF
C43 net@1028#4pmos@34_diff-top 0 1.643fF
C44 i11 0 13.795fF
C45 net@1021 0 12.136fF
C46 net@1006#6contact@296_metal-1-n-act 0 1.643fF
C47 net@1099 0 13.462fF
C48 net@1102 0 1.643fF
C49 S0#16pin@362_polysilicon-1 0 12.121fF
C50 S0#31contact@360_metal-1-metal-2 0 13.985fF
C51 out 0 5.7fF
C52 net@1511 0 1.643fF
C53 S3 0 1.724fF
C54 S1#35pin@2_polysilicon-1 0 0.149fF
C55 S1#40pin@5_polysilicon-1 0 0.13fF
C56 S1#43pin@6_polysilicon-1 0 0.171fF
C57 S1#37pin@11_polysilicon-1 0 0.137fF
C58 S1#38pin@12_polysilicon-1 0 0.177fF
C59 net@1#8pin@13_polysilicon-1 0 0.113fF
C60 net@1#9pin@14_polysilicon-1 0 0.156fF
C61 net@1#3pin@15_polysilicon-1 0 0.149fF
C62 net@1#4pin@17_polysilicon-1 0 0.184fF
C63 S1#48pin@25_polysilicon-1 0 0.149fF
C64 S1#52pin@28_polysilicon-1 0 0.13fF
C65 S1#53pin@29_polysilicon-1 0 0.171fF
C66 S1#42pin@34_polysilicon-1 0 0.137fF
C67 S1#45pin@35_polysilicon-1 0 0.177fF
C68 net@24 0 0.113fF
C69 net@24#1pin@37_polysilicon-1 0 0.156fF
C70 net@24#3pin@38_polysilicon-1 0 0.149fF
C71 net@24#5pin@40_polysilicon-1 0 0.184fF
C72 S2#7pin@48_polysilicon-1 0 0.149fF
C73 S2#15pin@51_polysilicon-1 0 0.13fF
C74 S2#18pin@52_polysilicon-1 0 0.171fF
C75 S2#25pin@56_polysilicon-1 0 0.137fF
C76 S2#1pin@57_polysilicon-1 0 0.177fF
C77 net@80#10pin@58_polysilicon-1 0 0.113fF
C78 net@80#11pin@59_polysilicon-1 0 0.156fF
C79 net@80#6pin@60_polysilicon-1 0 0.149fF
C80 net@80 0 0.184fF
C81 S1#14pin@77_polysilicon-1 0 0.149fF
C82 S1#27pin@80_polysilicon-1 0 0.13fF
C83 S1#30pin@81_polysilicon-1 0 0.171fF
C84 S1#12pin@86_polysilicon-1 0 0.137fF
C85 S1#13pin@87_polysilicon-1 0 0.177fF
C86 net@7#9pin@88_polysilicon-1 0 0.113fF
C87 net@7#10pin@89_polysilicon-1 0 0.156fF
C88 net@7#3pin@90_polysilicon-1 0 0.149fF
C89 net@7#4pin@92_polysilicon-1 0 0.184fF
C90 S1#19pin@100_polysilicon-1 0 0.149fF
C91 S1#21pin@103_polysilicon-1 0 0.13fF
C92 S1#22pin@104_polysilicon-1 0 0.171fF
C93 S1#29pin@109_polysilicon-1 0 0.137fF
C94 S1#16pin@110_polysilicon-1 0 0.177fF
C95 net@8#1pin@111_polysilicon-1 0 0.113fF
C96 net@8#2pin@112_polysilicon-1 0 0.156fF
C97 net@8#3pin@113_polysilicon-1 0 0.149fF
C98 net@8#6pin@115_polysilicon-1 0 0.184fF
C99 S2#5pin@123_polysilicon-1 0 0.149fF
C100 S2#9pin@126_polysilicon-1 0 0.13fF
C101 S2#10pin@127_polysilicon-1 0 0.171fF
C102 S2#17pin@131_polysilicon-1 0 0.137fF
C103 S2#3pin@132_polysilicon-1 0 0.177fF
C104 net@123#10pin@133_polysilicon-1 0 0.113fF
C105 net@123#11pin@134_polysilicon-1 0 0.156fF
C106 net@123#6pin@135_polysilicon-1 0 0.149fF
C107 net@123#2pin@137_polysilicon-1 0 0.184fF
C108 S0#3pin@160_polysilicon-1 0 0.149fF
C109 S0#5pin@163_polysilicon-1 0 0.13fF
C110 S0#6pin@164_polysilicon-1 0 0.171fF
C111 S0#11pin@169_polysilicon-1 0 0.137fF
C112 S0#1pin@170_polysilicon-1 0 0.177fF
C113 net@270#10pin@171_polysilicon-1 0 0.113fF
C114 net@270#11pin@172_polysilicon-1 0 0.156fF
C115 net@270#4pin@173_polysilicon-1 0 0.149fF
C116 net@270#5pin@175_polysilicon-1 0 0.184fF
C117 net@1001#23pin@199_polysilicon-1 0 0.149fF
C118 net@1001#30pin@202_polysilicon-1 0 0.13fF
C119 net@1001#33pin@203_polysilicon-1 0 0.171fF
C120 net@1001#25pin@208_polysilicon-1 0 0.137fF
C121 net@1001#26pin@209_polysilicon-1 0 0.177fF
C122 net@1000#8pin@210_polysilicon-1 0 0.113fF
C123 net@1000#9pin@211_polysilicon-1 0 0.156fF
C124 net@1000#2pin@212_polysilicon-1 0 0.149fF
C125 net@1000#3pin@214_polysilicon-1 0 0.184fF
C126 net@1001#38pin@222_polysilicon-1 0 0.149fF
C127 net@1001#42pin@225_polysilicon-1 0 0.13fF
C128 net@1001#43pin@226_polysilicon-1 0 0.171fF
C129 net@1001#32pin@231_polysilicon-1 0 0.137fF
C130 net@1001#35pin@232_polysilicon-1 0 0.177fF
C131 net@1064 0 0.113fF
C132 net@1064#1pin@234_polysilicon-1 0 0.156fF
C133 net@1064#10pin@235_polysilicon-1 0 0.149fF
C134 net@1064#4pin@237_polysilicon-1 0 0.184fF
C135 S2#35pin@245_polysilicon-1 0 0.149fF
C136 S2#31pin@248_polysilicon-1 0 0.13fF
C137 S2#32pin@249_polysilicon-1 0 0.171fF
C138 S2#43pin@253_polysilicon-1 0 0.137fF
C139 S2#44pin@254_polysilicon-1 0 0.177fF
C140 net@1082#10pin@255_polysilicon-1 0 0.113fF
C141 net@1082#11pin@256_polysilicon-1 0 0.156fF
C142 net@1082#5pin@257_polysilicon-1 0 0.149fF
C143 net@1082#6pin@259_polysilicon-1 0 0.184fF
C144 net@1001#14pin@274_polysilicon-1 0 0.149fF
C145 net@1001#4pin@277_polysilicon-1 0 0.13fF
C146 net@1001#10pin@278_polysilicon-1 0 0.171fF
C147 net@1001#48pin@283_polysilicon-1 0 0.137fF
C148 net@1001#49pin@284_polysilicon-1 0 0.177fF
C149 net@1063#8pin@285_polysilicon-1 0 0.113fF
C150 net@1063#9pin@286_polysilicon-1 0 0.156fF
C151 net@1063#3pin@287_polysilicon-1 0 0.149fF
C152 net@1063#2pin@289_polysilicon-1 0 0.184fF
C153 net@1001#16pin@297_polysilicon-1 0 0.149fF
C154 net@1001#53pin@300_polysilicon-1 0 0.13fF
C155 net@1001#54pin@301_polysilicon-1 0 0.171fF
C156 net@1001#6pin@306_polysilicon-1 0 0.137fF
C157 net@1001#12pin@307_polysilicon-1 0 0.177fF
C158 net@1028 0 0.113fF
C159 net@1028#1pin@309_polysilicon-1 0 0.156fF
C160 net@1028#2pin@310_polysilicon-1 0 0.149fF
C161 net@1028#3pin@312_polysilicon-1 0 0.184fF
C162 S2#30pin@320_polysilicon-1 0 0.149fF
C163 S2#49pin@323_polysilicon-1 0 0.13fF
C164 S2#50pin@324_polysilicon-1 0 0.171fF
C165 S2#27pin@328_polysilicon-1 0 0.137fF
C166 S2#28pin@329_polysilicon-1 0 0.177fF
C167 net@1006#3pin@330_polysilicon-1 0 0.113fF
C168 net@1006#4pin@331_polysilicon-1 0 0.156fF
C169 net@1006#5pin@332_polysilicon-1 0 0.149fF
C170 net@1006#1pin@334_polysilicon-1 0 0.184fF
C171 S0#19pin@357_polysilicon-1 0 0.149fF
C172 S0#21pin@360_polysilicon-1 0 0.13fF
C173 S0#22pin@361_polysilicon-1 0 0.171fF
C174 S0#27pin@366_polysilicon-1 0 0.137fF
C175 S0#17pin@367_polysilicon-1 0 0.177fF
C176 net@1102#10pin@368_polysilicon-1 0 0.113fF
C177 net@1102#11pin@369_polysilicon-1 0 0.156fF
C178 net@1102#4pin@370_polysilicon-1 0 0.149fF
C179 net@1102#5pin@372_polysilicon-1 0 0.184fF
C180 S3#3pin@403_polysilicon-1 0 0.149fF
C181 S3#5pin@406_polysilicon-1 0 0.13fF
C182 S3#6pin@407_polysilicon-1 0 0.171fF
C183 S3#11pin@412_polysilicon-1 0 0.137fF
C184 S3#1pin@413_polysilicon-1 0 0.177fF
C185 net@1511#10pin@414_polysilicon-1 0 0.113fF
C186 net@1511#11pin@415_polysilicon-1 0 0.156fF
C187 net@1511#4pin@416_polysilicon-1 0 0.149fF
C188 net@1511#5pin@418_polysilicon-1 0 0.184fF
** Extracted Parasitic Resistors ***
R0 net@8 net@8#1pin@111_polysilicon-1 7.75
R1 net@8#1pin@111_polysilicon-1 net@8#1pin@111_polysilicon-1##0 9.042
R2 net@8#1pin@111_polysilicon-1##0 net@8#1pin@111_polysilicon-1##1 9.042
R3 net@8#1pin@111_polysilicon-1##1 net@8#1pin@111_polysilicon-1##2 9.042
R4 net@8#1pin@111_polysilicon-1##2 net@8#1pin@111_polysilicon-1##3 9.042
R5 net@8#1pin@111_polysilicon-1##3 net@8#1pin@111_polysilicon-1##4 9.042
R6 net@8#1pin@111_polysilicon-1##4 net@8#2pin@112_polysilicon-1 9.042
R7 net@24 net@24##0 9.042
R8 net@24##0 net@24##1 9.042
R9 net@24##1 net@24##2 9.042
R10 net@24##2 net@24##3 9.042
R11 net@24##3 net@24##4 9.042
R12 net@24##4 net@24#1pin@37_polysilicon-1 9.042
R13 net@8#2pin@112_polysilicon-1 net@8#2pin@112_polysilicon-1##0 9.3
R14 net@8#2pin@112_polysilicon-1##0 net@8#2pin@112_polysilicon-1##1 9.3
R15 net@8#2pin@112_polysilicon-1##1 net@8#2pin@112_polysilicon-1##2 9.3
R16 net@8#2pin@112_polysilicon-1##2 net@8#2pin@112_polysilicon-1##3 9.3
R17 net@8#2pin@112_polysilicon-1##3 net@8#2pin@112_polysilicon-1##4 9.3
R18 net@8#2pin@112_polysilicon-1##4 net@8#2pin@112_polysilicon-1##5 9.3
R19 net@8#2pin@112_polysilicon-1##5 net@8#2pin@112_polysilicon-1##6 9.3
R20 net@8#2pin@112_polysilicon-1##6 net@8#3pin@113_polysilicon-1 9.3
R21 net@7#3pin@90_polysilicon-1 net@7#3pin@90_polysilicon-1##0 8.37
R22 net@7#3pin@90_polysilicon-1##0 net@7#3pin@90_polysilicon-1##1 8.37
R23 net@7#3pin@90_polysilicon-1##1 net@7#3pin@90_polysilicon-1##2 8.37
R24 net@7#3pin@90_polysilicon-1##2 net@7#3pin@90_polysilicon-1##3 8.37
R25 net@7#3pin@90_polysilicon-1##3 net@7#4pin@92_polysilicon-1 8.37
R26 net@7#7nmos@9_poly-right net@7#7nmos@9_poly-right##0 6.2
R27 net@7#7nmos@9_poly-right##0 net@7#4pin@92_polysilicon-1 6.2
R28 S2 S2##0 9.881
R29 S2##0 S2##1 9.881
R30 S2##1 S2##2 9.881
R31 S2##2 S2##3 9.881
R32 S2##3 S2##4 9.881
R33 S2##4 S2##5 9.881
R34 S2##5 S2##6 9.881
R35 S2##6 S2#1pin@57_polysilicon-1 9.881
R36 S1#11nmos@11_poly-left S1#11nmos@11_poly-left##0 6.975
R37 S1#11nmos@11_poly-left##0 S1#12pin@86_polysilicon-1 6.975
R38 S1#12pin@86_polysilicon-1 S1#12pin@86_polysilicon-1##0 9.772
R39 S1#12pin@86_polysilicon-1##0 S1#12pin@86_polysilicon-1##1 9.772
R40 S1#12pin@86_polysilicon-1##1 S1#12pin@86_polysilicon-1##2 9.772
R41 S1#12pin@86_polysilicon-1##2 S1#12pin@86_polysilicon-1##3 9.772
R42 S1#12pin@86_polysilicon-1##3 S1#12pin@86_polysilicon-1##4 9.772
R43 S1#12pin@86_polysilicon-1##4 S1#12pin@86_polysilicon-1##5 9.772
R44 S1#12pin@86_polysilicon-1##5 S1#12pin@86_polysilicon-1##6 9.772
R45 S1#12pin@86_polysilicon-1##6 S1#12pin@86_polysilicon-1##7 9.772
R46 S1#12pin@86_polysilicon-1##7 S1#12pin@86_polysilicon-1##8 9.772
R47 S1#12pin@86_polysilicon-1##8 S1#12pin@86_polysilicon-1##9 9.772
R48 S1#12pin@86_polysilicon-1##9 S1#12pin@86_polysilicon-1##10 9.772
R49 S1#12pin@86_polysilicon-1##10 S1#12pin@86_polysilicon-1##11 9.772
R50 S1#12pin@86_polysilicon-1##11 S1#12pin@86_polysilicon-1##12 9.772
R51 S1#12pin@86_polysilicon-1##12 S1#12pin@86_polysilicon-1##13 9.772
R52 S1#12pin@86_polysilicon-1##13 S1#12pin@86_polysilicon-1##14 9.772
R53 S1#12pin@86_polysilicon-1##14 S1#12pin@86_polysilicon-1##15 9.772
R54 S1#12pin@86_polysilicon-1##15 S1#12pin@86_polysilicon-1##16 9.772
R55 S1#12pin@86_polysilicon-1##16 S1#12pin@86_polysilicon-1##17 9.772
R56 S1#12pin@86_polysilicon-1##17 S1#12pin@86_polysilicon-1##18 9.772
R57 S1#12pin@86_polysilicon-1##18 S1#12pin@86_polysilicon-1##19 9.772
R58 S1#12pin@86_polysilicon-1##19 S1#12pin@86_polysilicon-1##20 9.772
R59 S1#12pin@86_polysilicon-1##20 S1#12pin@86_polysilicon-1##21 9.772
R60 S1#12pin@86_polysilicon-1##21 S1#13pin@87_polysilicon-1 9.772
R61 S1 S1##0 8.267
R62 S1##0 S1##1 8.267
R63 S1##1 S1#14pin@77_polysilicon-1 8.267
R64 net@7#8pmos@11_poly-left net@7#9pin@88_polysilicon-1 7.75
R65 net@7#9pin@88_polysilicon-1 net@7#9pin@88_polysilicon-1##0 9.042
R66 net@7#9pin@88_polysilicon-1##0 net@7#9pin@88_polysilicon-1##1 9.042
R67 net@7#9pin@88_polysilicon-1##1 net@7#9pin@88_polysilicon-1##2 9.042
R68 net@7#9pin@88_polysilicon-1##2 net@7#9pin@88_polysilicon-1##3 9.042
R69 net@7#9pin@88_polysilicon-1##3 net@7#9pin@88_polysilicon-1##4 9.042
R70 net@7#9pin@88_polysilicon-1##4 net@7#10pin@89_polysilicon-1 9.042
R71 net@7#10pin@89_polysilicon-1 net@7#10pin@89_polysilicon-1##0 9.3
R72 net@7#10pin@89_polysilicon-1##0 net@7#10pin@89_polysilicon-1##1 9.3
R73 net@7#10pin@89_polysilicon-1##1 net@7#10pin@89_polysilicon-1##2 9.3
R74 net@7#10pin@89_polysilicon-1##2 net@7#10pin@89_polysilicon-1##3 9.3
R75 net@7#10pin@89_polysilicon-1##3 net@7#10pin@89_polysilicon-1##4 9.3
R76 net@7#10pin@89_polysilicon-1##4 net@7#10pin@89_polysilicon-1##5 9.3
R77 net@7#10pin@89_polysilicon-1##5 net@7#10pin@89_polysilicon-1##6 9.3
R78 net@7#10pin@89_polysilicon-1##6 net@7#3pin@90_polysilicon-1 9.3
R79 net@80 net@80##0 9.042
R80 net@80##0 net@80##1 9.042
R81 net@80##1 net@80##2 9.042
R82 net@80##2 net@80##3 9.042
R83 net@80##3 net@80##4 9.042
R84 net@80##4 net@80#1contact@56_metal-1-polysilicon-1 9.042
R85 S1 S1##0 9.881
R86 S1##0 S1##1 9.881
R87 S1##1 S1##2 9.881
R88 S1##2 S1##3 9.881
R89 S1##3 S1##4 9.881
R90 S1##4 S1##5 9.881
R91 S1##5 S1##6 9.881
R92 S1##6 S1#16pin@110_polysilicon-1 9.881
R93 net@8#6pin@115_polysilicon-1 net@8#6pin@115_polysilicon-1##0 9.042
R94 net@8#6pin@115_polysilicon-1##0 net@8#6pin@115_polysilicon-1##1 9.042
R95 net@8#6pin@115_polysilicon-1##1 net@8#6pin@115_polysilicon-1##2 9.042
R96 net@8#6pin@115_polysilicon-1##2 net@8#6pin@115_polysilicon-1##3 9.042
R97 net@8#6pin@115_polysilicon-1##3 net@8#6pin@115_polysilicon-1##4 9.042
R98 net@8#6pin@115_polysilicon-1##4 net@8#4contact@94_metal-1-n-act 9.042
R99 S1 S1##0 9.881
R100 S1##0 S1##1 9.881
R101 S1##1 S1##2 9.881
R102 S1##2 S1##3 9.881
R103 S1##3 S1##4 9.881
R104 S1##4 S1##5 9.881
R105 S1##5 S1##6 9.881
R106 S1##6 S1#13pin@87_polysilicon-1 9.881
R107 S1#18nmos@13_poly-right S1#18nmos@13_poly-right##0 7.233
R108 S1#18nmos@13_poly-right##0 S1#18nmos@13_poly-right##1 7.233
R109 S1#18nmos@13_poly-right##1 S1#19pin@100_polysilicon-1 7.233
R110 S1#20pmos@12_poly-left S1#20pmos@12_poly-left##0 6.2
R111 S1#20pmos@12_poly-left##0 S1#21pin@103_polysilicon-1 6.2
R112 S1#21pin@103_polysilicon-1 S1#21pin@103_polysilicon-1##0 9.896
R113 S1#21pin@103_polysilicon-1##0 S1#21pin@103_polysilicon-1##1 9.896
R114 S1#21pin@103_polysilicon-1##1 S1#21pin@103_polysilicon-1##2 9.896
R115 S1#21pin@103_polysilicon-1##2 S1#21pin@103_polysilicon-1##3 9.896
R116 S1#21pin@103_polysilicon-1##3 S1#21pin@103_polysilicon-1##4 9.896
R117 S1#21pin@103_polysilicon-1##4 S1#21pin@103_polysilicon-1##5 9.896
R118 S1#21pin@103_polysilicon-1##5 S1#21pin@103_polysilicon-1##6 9.896
R119 S1#21pin@103_polysilicon-1##6 S1#21pin@103_polysilicon-1##7 9.896
R120 S1#21pin@103_polysilicon-1##7 S1#21pin@103_polysilicon-1##8 9.896
R121 S1#21pin@103_polysilicon-1##8 S1#21pin@103_polysilicon-1##9 9.896
R122 S1#21pin@103_polysilicon-1##9 S1#21pin@103_polysilicon-1##10 9.896
R123 S1#21pin@103_polysilicon-1##10 S1#21pin@103_polysilicon-1##11 9.896
R124 S1#21pin@103_polysilicon-1##11 S1#22pin@104_polysilicon-1 9.896
R125 S1#22pin@104_polysilicon-1 S1#22pin@104_polysilicon-1##0 9.521
R126 S1#22pin@104_polysilicon-1##0 S1#22pin@104_polysilicon-1##1 9.521
R127 S1#22pin@104_polysilicon-1##1 S1#22pin@104_polysilicon-1##2 9.521
R128 S1#22pin@104_polysilicon-1##2 S1#22pin@104_polysilicon-1##3 9.521
R129 S1#22pin@104_polysilicon-1##3 S1#22pin@104_polysilicon-1##4 9.521
R130 S1#22pin@104_polysilicon-1##4 S1#22pin@104_polysilicon-1##5 9.521
R131 S1#22pin@104_polysilicon-1##5 S1 9.521
R132 S1#19pin@100_polysilicon-1 S1#19pin@100_polysilicon-1##0 5.425
R133 S1#19pin@100_polysilicon-1##0 S1#24pmos@13_poly-right 5.425
R134 net@24#2pmos@5_poly-left net@24 7.75
R135 net@7#4pin@92_polysilicon-1 net@7#4pin@92_polysilicon-1##0 9.042
R136 net@7#4pin@92_polysilicon-1##0 net@7#4pin@92_polysilicon-1##1 9.042
R137 net@7#4pin@92_polysilicon-1##1 net@7#4pin@92_polysilicon-1##2 9.042
R138 net@7#4pin@92_polysilicon-1##2 net@7#4pin@92_polysilicon-1##3 9.042
R139 net@7#4pin@92_polysilicon-1##3 net@7#4pin@92_polysilicon-1##4 9.042
R140 net@7#4pin@92_polysilicon-1##4 net@7 9.042
R141 net@8#3pin@113_polysilicon-1 net@8#3pin@113_polysilicon-1##0 8.37
R142 net@8#3pin@113_polysilicon-1##0 net@8#3pin@113_polysilicon-1##1 8.37
R143 net@8#3pin@113_polysilicon-1##1 net@8#3pin@113_polysilicon-1##2 8.37
R144 net@8#3pin@113_polysilicon-1##2 net@8#3pin@113_polysilicon-1##3 8.37
R145 net@8#3pin@113_polysilicon-1##3 net@8#6pin@115_polysilicon-1 8.37
R146 S2 S2##0 9.881
R147 S2##0 S2##1 9.881
R148 S2##1 S2##2 9.881
R149 S2##2 S2##3 9.881
R150 S2##3 S2##4 9.881
R151 S2##4 S2##5 9.881
R152 S2##5 S2##6 9.881
R153 S2##6 S2#3pin@132_polysilicon-1 9.881
R154 net@123#2pin@137_polysilicon-1 net@123#2pin@137_polysilicon-1##0 9.042
R155 net@123#2pin@137_polysilicon-1##0 net@123#2pin@137_polysilicon-1##1 9.042
R156 net@123#2pin@137_polysilicon-1##1 net@123#2pin@137_polysilicon-1##2 9.042
R157 net@123#2pin@137_polysilicon-1##2 net@123#2pin@137_polysilicon-1##3 9.042
R158 net@123#2pin@137_polysilicon-1##3 net@123#2pin@137_polysilicon-1##4 9.042
R159 net@123#2pin@137_polysilicon-1##4 net@123 9.042
R160 net@24#1pin@37_polysilicon-1 net@24#1pin@37_polysilicon-1##0 9.3
R161 net@24#1pin@37_polysilicon-1##0 net@24#1pin@37_polysilicon-1##1 9.3
R162 net@24#1pin@37_polysilicon-1##1 net@24#1pin@37_polysilicon-1##2 9.3
R163 net@24#1pin@37_polysilicon-1##2 net@24#1pin@37_polysilicon-1##3 9.3
R164 net@24#1pin@37_polysilicon-1##3 net@24#1pin@37_polysilicon-1##4 9.3
R165 net@24#1pin@37_polysilicon-1##4 net@24#1pin@37_polysilicon-1##5 9.3
R166 net@24#1pin@37_polysilicon-1##5 net@24#1pin@37_polysilicon-1##6 9.3
R167 net@24#1pin@37_polysilicon-1##6 net@24#3pin@38_polysilicon-1 9.3
R168 S2#4nmos@16_poly-right S2#4nmos@16_poly-right##0 7.233
R169 S2#4nmos@16_poly-right##0 S2#4nmos@16_poly-right##1 7.233
R170 S2#4nmos@16_poly-right##1 S2#5pin@123_polysilicon-1 7.233
R171 S2#6nmos@7_poly-right S2#6nmos@7_poly-right##0 7.233
R172 S2#6nmos@7_poly-right##0 S2#6nmos@7_poly-right##1 7.233
R173 S2#6nmos@7_poly-right##1 S2#7pin@48_polysilicon-1 7.233
R174 S2#8pmos@15_poly-left S2#8pmos@15_poly-left##0 6.2
R175 S2#8pmos@15_poly-left##0 S2#9pin@126_polysilicon-1 6.2
R176 S2#9pin@126_polysilicon-1 S2#9pin@126_polysilicon-1##0 9.896
R177 S2#9pin@126_polysilicon-1##0 S2#9pin@126_polysilicon-1##1 9.896
R178 S2#9pin@126_polysilicon-1##1 S2#9pin@126_polysilicon-1##2 9.896
R179 S2#9pin@126_polysilicon-1##2 S2#9pin@126_polysilicon-1##3 9.896
R180 S2#9pin@126_polysilicon-1##3 S2#9pin@126_polysilicon-1##4 9.896
R181 S2#9pin@126_polysilicon-1##4 S2#9pin@126_polysilicon-1##5 9.896
R182 S2#9pin@126_polysilicon-1##5 S2#9pin@126_polysilicon-1##6 9.896
R183 S2#9pin@126_polysilicon-1##6 S2#9pin@126_polysilicon-1##7 9.896
R184 S2#9pin@126_polysilicon-1##7 S2#9pin@126_polysilicon-1##8 9.896
R185 S2#9pin@126_polysilicon-1##8 S2#9pin@126_polysilicon-1##9 9.896
R186 S2#9pin@126_polysilicon-1##9 S2#9pin@126_polysilicon-1##10 9.896
R187 S2#9pin@126_polysilicon-1##10 S2#9pin@126_polysilicon-1##11 9.896
R188 S2#9pin@126_polysilicon-1##11 S2#10pin@127_polysilicon-1 9.896
R189 S2#10pin@127_polysilicon-1 S2#10pin@127_polysilicon-1##0 9.521
R190 S2#10pin@127_polysilicon-1##0 S2#10pin@127_polysilicon-1##1 9.521
R191 S2#10pin@127_polysilicon-1##1 S2#10pin@127_polysilicon-1##2 9.521
R192 S2#10pin@127_polysilicon-1##2 S2#10pin@127_polysilicon-1##3 9.521
R193 S2#10pin@127_polysilicon-1##3 S2#10pin@127_polysilicon-1##4 9.521
R194 S2#10pin@127_polysilicon-1##4 S2#10pin@127_polysilicon-1##5 9.521
R195 S2#10pin@127_polysilicon-1##5 S2 9.521
R196 S2#5pin@123_polysilicon-1 S2#5pin@123_polysilicon-1##0 5.425
R197 S2#5pin@123_polysilicon-1##0 S2#12pmos@16_poly-right 5.425
R198 net@8#11nmos@12_poly-right net@8#11nmos@12_poly-right##0 6.2
R199 net@8#11nmos@12_poly-right##0 net@8#6pin@115_polysilicon-1 6.2
R200 net@123#6pin@135_polysilicon-1 net@123#6pin@135_polysilicon-1##0 8.37
R201 net@123#6pin@135_polysilicon-1##0 net@123#6pin@135_polysilicon-1##1 8.37
R202 net@123#6pin@135_polysilicon-1##1 net@123#6pin@135_polysilicon-1##2 8.37
R203 net@123#6pin@135_polysilicon-1##2 net@123#6pin@135_polysilicon-1##3 8.37
R204 net@123#6pin@135_polysilicon-1##3 net@123#2pin@137_polysilicon-1 8.37
R205 S2#14pmos@6_poly-left S2#14pmos@6_poly-left##0 6.2
R206 S2#14pmos@6_poly-left##0 S2#15pin@51_polysilicon-1 6.2
R207 S1#25nmos@10_poly-right S1#25nmos@10_poly-right##0 7.233
R208 S1#25nmos@10_poly-right##0 S1#25nmos@10_poly-right##1 7.233
R209 S1#25nmos@10_poly-right##1 S1#14pin@77_polysilicon-1 7.233
R210 net@1#3pin@15_polysilicon-1 net@1#3pin@15_polysilicon-1##0 8.37
R211 net@1#3pin@15_polysilicon-1##0 net@1#3pin@15_polysilicon-1##1 8.37
R212 net@1#3pin@15_polysilicon-1##1 net@1#3pin@15_polysilicon-1##2 8.37
R213 net@1#3pin@15_polysilicon-1##2 net@1#3pin@15_polysilicon-1##3 8.37
R214 net@1#3pin@15_polysilicon-1##3 net@1#4pin@17_polysilicon-1 8.37
R215 net@123#8nmos@15_poly-right net@123#8nmos@15_poly-right##0 6.2
R216 net@123#8nmos@15_poly-right##0 net@123#2pin@137_polysilicon-1 6.2
R217 S1#26pmos@9_poly-left S1#26pmos@9_poly-left##0 6.2
R218 S1#26pmos@9_poly-left##0 S1#27pin@80_polysilicon-1 6.2
R219 S2#16nmos@17_poly-left S2#16nmos@17_poly-left##0 6.975
R220 S2#16nmos@17_poly-left##0 S2#17pin@131_polysilicon-1 6.975
R221 S2#17pin@131_polysilicon-1 S2#17pin@131_polysilicon-1##0 9.772
R222 S2#17pin@131_polysilicon-1##0 S2#17pin@131_polysilicon-1##1 9.772
R223 S2#17pin@131_polysilicon-1##1 S2#17pin@131_polysilicon-1##2 9.772
R224 S2#17pin@131_polysilicon-1##2 S2#17pin@131_polysilicon-1##3 9.772
R225 S2#17pin@131_polysilicon-1##3 S2#17pin@131_polysilicon-1##4 9.772
R226 S2#17pin@131_polysilicon-1##4 S2#17pin@131_polysilicon-1##5 9.772
R227 S2#17pin@131_polysilicon-1##5 S2#17pin@131_polysilicon-1##6 9.772
R228 S2#17pin@131_polysilicon-1##6 S2#17pin@131_polysilicon-1##7 9.772
R229 S2#17pin@131_polysilicon-1##7 S2#17pin@131_polysilicon-1##8 9.772
R230 S2#17pin@131_polysilicon-1##8 S2#17pin@131_polysilicon-1##9 9.772
R231 S2#17pin@131_polysilicon-1##9 S2#17pin@131_polysilicon-1##10 9.772
R232 S2#17pin@131_polysilicon-1##10 S2#17pin@131_polysilicon-1##11 9.772
R233 S2#17pin@131_polysilicon-1##11 S2#17pin@131_polysilicon-1##12 9.772
R234 S2#17pin@131_polysilicon-1##12 S2#17pin@131_polysilicon-1##13 9.772
R235 S2#17pin@131_polysilicon-1##13 S2#17pin@131_polysilicon-1##14 9.772
R236 S2#17pin@131_polysilicon-1##14 S2#17pin@131_polysilicon-1##15 9.772
R237 S2#17pin@131_polysilicon-1##15 S2#17pin@131_polysilicon-1##16 9.772
R238 S2#17pin@131_polysilicon-1##16 S2#17pin@131_polysilicon-1##17 9.772
R239 S2#17pin@131_polysilicon-1##17 S2#17pin@131_polysilicon-1##18 9.772
R240 S2#17pin@131_polysilicon-1##18 S2#17pin@131_polysilicon-1##19 9.772
R241 S2#17pin@131_polysilicon-1##19 S2#17pin@131_polysilicon-1##20 9.772
R242 S2#17pin@131_polysilicon-1##20 S2#17pin@131_polysilicon-1##21 9.772
R243 S2#17pin@131_polysilicon-1##21 S2#3pin@132_polysilicon-1 9.772
R244 S2 S2##0 8.267
R245 S2##0 S2##1 8.267
R246 S2##1 S2#5pin@123_polysilicon-1 8.267
R247 net@123#9pmos@17_poly-left net@123#10pin@133_polysilicon-1 7.75
R248 S1#28nmos@14_poly-left S1#28nmos@14_poly-left##0 6.975
R249 S1#28nmos@14_poly-left##0 S1#29pin@109_polysilicon-1 6.975
R250 S2#15pin@51_polysilicon-1 S2#15pin@51_polysilicon-1##0 9.896
R251 S2#15pin@51_polysilicon-1##0 S2#15pin@51_polysilicon-1##1 9.896
R252 S2#15pin@51_polysilicon-1##1 S2#15pin@51_polysilicon-1##2 9.896
R253 S2#15pin@51_polysilicon-1##2 S2#15pin@51_polysilicon-1##3 9.896
R254 S2#15pin@51_polysilicon-1##3 S2#15pin@51_polysilicon-1##4 9.896
R255 S2#15pin@51_polysilicon-1##4 S2#15pin@51_polysilicon-1##5 9.896
R256 S2#15pin@51_polysilicon-1##5 S2#15pin@51_polysilicon-1##6 9.896
R257 S2#15pin@51_polysilicon-1##6 S2#15pin@51_polysilicon-1##7 9.896
R258 S2#15pin@51_polysilicon-1##7 S2#15pin@51_polysilicon-1##8 9.896
R259 S2#15pin@51_polysilicon-1##8 S2#15pin@51_polysilicon-1##9 9.896
R260 S2#15pin@51_polysilicon-1##9 S2#15pin@51_polysilicon-1##10 9.896
R261 S2#15pin@51_polysilicon-1##10 S2#15pin@51_polysilicon-1##11 9.896
R262 S2#15pin@51_polysilicon-1##11 S2#18pin@52_polysilicon-1 9.896
R263 net@123#10pin@133_polysilicon-1 net@123#10pin@133_polysilicon-1##0 9.042
R264 net@123#10pin@133_polysilicon-1##0 net@123#10pin@133_polysilicon-1##1 9.042
R265 net@123#10pin@133_polysilicon-1##1 net@123#10pin@133_polysilicon-1##2 9.042
R266 net@123#10pin@133_polysilicon-1##2 net@123#10pin@133_polysilicon-1##3 9.042
R267 net@123#10pin@133_polysilicon-1##3 net@123#10pin@133_polysilicon-1##4 9.042
R268 net@123#10pin@133_polysilicon-1##4 net@123#11pin@134_polysilicon-1 9.042
R269 net@123#11pin@134_polysilicon-1 net@123#11pin@134_polysilicon-1##0 9.3
R270 net@123#11pin@134_polysilicon-1##0 net@123#11pin@134_polysilicon-1##1 9.3
R271 net@123#11pin@134_polysilicon-1##1 net@123#11pin@134_polysilicon-1##2 9.3
R272 net@123#11pin@134_polysilicon-1##2 net@123#11pin@134_polysilicon-1##3 9.3
R273 net@123#11pin@134_polysilicon-1##3 net@123#11pin@134_polysilicon-1##4 9.3
R274 net@123#11pin@134_polysilicon-1##4 net@123#11pin@134_polysilicon-1##5 9.3
R275 net@123#11pin@134_polysilicon-1##5 net@123#11pin@134_polysilicon-1##6 9.3
R276 net@123#11pin@134_polysilicon-1##6 net@123#6pin@135_polysilicon-1 9.3
R277 S1#27pin@80_polysilicon-1 S1#27pin@80_polysilicon-1##0 9.896
R278 S1#27pin@80_polysilicon-1##0 S1#27pin@80_polysilicon-1##1 9.896
R279 S1#27pin@80_polysilicon-1##1 S1#27pin@80_polysilicon-1##2 9.896
R280 S1#27pin@80_polysilicon-1##2 S1#27pin@80_polysilicon-1##3 9.896
R281 S1#27pin@80_polysilicon-1##3 S1#27pin@80_polysilicon-1##4 9.896
R282 S1#27pin@80_polysilicon-1##4 S1#27pin@80_polysilicon-1##5 9.896
R283 S1#27pin@80_polysilicon-1##5 S1#27pin@80_polysilicon-1##6 9.896
R284 S1#27pin@80_polysilicon-1##6 S1#27pin@80_polysilicon-1##7 9.896
R285 S1#27pin@80_polysilicon-1##7 S1#27pin@80_polysilicon-1##8 9.896
R286 S1#27pin@80_polysilicon-1##8 S1#27pin@80_polysilicon-1##9 9.896
R287 S1#27pin@80_polysilicon-1##9 S1#27pin@80_polysilicon-1##10 9.896
R288 S1#27pin@80_polysilicon-1##10 S1#27pin@80_polysilicon-1##11 9.896
R289 S1#27pin@80_polysilicon-1##11 S1#30pin@81_polysilicon-1 9.896
R290 S1#30pin@81_polysilicon-1 S1#30pin@81_polysilicon-1##0 9.521
R291 S1#30pin@81_polysilicon-1##0 S1#30pin@81_polysilicon-1##1 9.521
R292 S1#30pin@81_polysilicon-1##1 S1#30pin@81_polysilicon-1##2 9.521
R293 S1#30pin@81_polysilicon-1##2 S1#30pin@81_polysilicon-1##3 9.521
R294 S1#30pin@81_polysilicon-1##3 S1#30pin@81_polysilicon-1##4 9.521
R295 S1#30pin@81_polysilicon-1##4 S1#30pin@81_polysilicon-1##5 9.521
R296 S1#30pin@81_polysilicon-1##5 S1 9.521
R297 S2#18pin@52_polysilicon-1 S2#18pin@52_polysilicon-1##0 9.521
R298 S2#18pin@52_polysilicon-1##0 S2#18pin@52_polysilicon-1##1 9.521
R299 S2#18pin@52_polysilicon-1##1 S2#18pin@52_polysilicon-1##2 9.521
R300 S2#18pin@52_polysilicon-1##2 S2#18pin@52_polysilicon-1##3 9.521
R301 S2#18pin@52_polysilicon-1##3 S2#18pin@52_polysilicon-1##4 9.521
R302 S2#18pin@52_polysilicon-1##4 S2#18pin@52_polysilicon-1##5 9.521
R303 S2#18pin@52_polysilicon-1##5 S2 9.521
R304 S1#29pin@109_polysilicon-1 S1#29pin@109_polysilicon-1##0 9.772
R305 S1#29pin@109_polysilicon-1##0 S1#29pin@109_polysilicon-1##1 9.772
R306 S1#29pin@109_polysilicon-1##1 S1#29pin@109_polysilicon-1##2 9.772
R307 S1#29pin@109_polysilicon-1##2 S1#29pin@109_polysilicon-1##3 9.772
R308 S1#29pin@109_polysilicon-1##3 S1#29pin@109_polysilicon-1##4 9.772
R309 S1#29pin@109_polysilicon-1##4 S1#29pin@109_polysilicon-1##5 9.772
R310 S1#29pin@109_polysilicon-1##5 S1#29pin@109_polysilicon-1##6 9.772
R311 S1#29pin@109_polysilicon-1##6 S1#29pin@109_polysilicon-1##7 9.772
R312 S1#29pin@109_polysilicon-1##7 S1#29pin@109_polysilicon-1##8 9.772
R313 S1#29pin@109_polysilicon-1##8 S1#29pin@109_polysilicon-1##9 9.772
R314 S1#29pin@109_polysilicon-1##9 S1#29pin@109_polysilicon-1##10 9.772
R315 S1#29pin@109_polysilicon-1##10 S1#29pin@109_polysilicon-1##11 9.772
R316 S1#29pin@109_polysilicon-1##11 S1#29pin@109_polysilicon-1##12 9.772
R317 S1#29pin@109_polysilicon-1##12 S1#29pin@109_polysilicon-1##13 9.772
R318 S1#29pin@109_polysilicon-1##13 S1#29pin@109_polysilicon-1##14 9.772
R319 S1#29pin@109_polysilicon-1##14 S1#29pin@109_polysilicon-1##15 9.772
R320 S1#29pin@109_polysilicon-1##15 S1#29pin@109_polysilicon-1##16 9.772
R321 S1#29pin@109_polysilicon-1##16 S1#29pin@109_polysilicon-1##17 9.772
R322 S1#29pin@109_polysilicon-1##17 S1#29pin@109_polysilicon-1##18 9.772
R323 S1#29pin@109_polysilicon-1##18 S1#29pin@109_polysilicon-1##19 9.772
R324 S1#29pin@109_polysilicon-1##19 S1#29pin@109_polysilicon-1##20 9.772
R325 S1#29pin@109_polysilicon-1##20 S1#29pin@109_polysilicon-1##21 9.772
R326 S1#29pin@109_polysilicon-1##21 S1#16pin@110_polysilicon-1 9.772
R327 S1#14pin@77_polysilicon-1 S1#14pin@77_polysilicon-1##0 5.425
R328 S1#14pin@77_polysilicon-1##0 S1#31pmos@10_poly-right 5.425
R329 S1 S1##0 8.267
R330 S1##0 S1##1 8.267
R331 S1##1 S1#19pin@100_polysilicon-1 8.267
R332 S2#7pin@48_polysilicon-1 S2#7pin@48_polysilicon-1##0 5.425
R333 S2#7pin@48_polysilicon-1##0 S2#20pmos@7_poly-right 5.425
R334 net@270#4pin@173_polysilicon-1 net@270#4pin@173_polysilicon-1##0 8.37
R335 net@270#4pin@173_polysilicon-1##0 net@270#4pin@173_polysilicon-1##1 8.37
R336 net@270#4pin@173_polysilicon-1##1 net@270#4pin@173_polysilicon-1##2 8.37
R337 net@270#4pin@173_polysilicon-1##2 net@270#4pin@173_polysilicon-1##3 8.37
R338 net@270#4pin@173_polysilicon-1##3 net@270#5pin@175_polysilicon-1 8.37
R339 net@270#6nmos@18_poly-right net@270#6nmos@18_poly-right##0 6.2
R340 net@270#6nmos@18_poly-right##0 net@270#5pin@175_polysilicon-1 6.2
R341 S0#0pin@165_polysilicon-1 S0#0pin@165_polysilicon-1##0 9.881
R342 S0#0pin@165_polysilicon-1##0 S0#0pin@165_polysilicon-1##1 9.881
R343 S0#0pin@165_polysilicon-1##1 S0#0pin@165_polysilicon-1##2 9.881
R344 S0#0pin@165_polysilicon-1##2 S0#0pin@165_polysilicon-1##3 9.881
R345 S0#0pin@165_polysilicon-1##3 S0#0pin@165_polysilicon-1##4 9.881
R346 S0#0pin@165_polysilicon-1##4 S0#0pin@165_polysilicon-1##5 9.881
R347 S0#0pin@165_polysilicon-1##5 S0#0pin@165_polysilicon-1##6 9.881
R348 S0#0pin@165_polysilicon-1##6 S0#1pin@170_polysilicon-1 9.881
R349 net@270#5pin@175_polysilicon-1 net@270#5pin@175_polysilicon-1##0 9.042
R350 net@270#5pin@175_polysilicon-1##0 net@270#5pin@175_polysilicon-1##1 9.042
R351 net@270#5pin@175_polysilicon-1##1 net@270#5pin@175_polysilicon-1##2 9.042
R352 net@270#5pin@175_polysilicon-1##2 net@270#5pin@175_polysilicon-1##3 9.042
R353 net@270#5pin@175_polysilicon-1##3 net@270#5pin@175_polysilicon-1##4 9.042
R354 net@270#5pin@175_polysilicon-1##4 net@270 9.042
R355 S0#2nmos@19_poly-right S0#2nmos@19_poly-right##0 7.233
R356 S0#2nmos@19_poly-right##0 S0#2nmos@19_poly-right##1 7.233
R357 S0#2nmos@19_poly-right##1 S0#3pin@160_polysilicon-1 7.233
R358 S0#4pmos@18_poly-left S0#4pmos@18_poly-left##0 6.2
R359 S0#4pmos@18_poly-left##0 S0#5pin@163_polysilicon-1 6.2
R360 S0#5pin@163_polysilicon-1 S0#5pin@163_polysilicon-1##0 9.896
R361 S0#5pin@163_polysilicon-1##0 S0#5pin@163_polysilicon-1##1 9.896
R362 S0#5pin@163_polysilicon-1##1 S0#5pin@163_polysilicon-1##2 9.896
R363 S0#5pin@163_polysilicon-1##2 S0#5pin@163_polysilicon-1##3 9.896
R364 S0#5pin@163_polysilicon-1##3 S0#5pin@163_polysilicon-1##4 9.896
R365 S0#5pin@163_polysilicon-1##4 S0#5pin@163_polysilicon-1##5 9.896
R366 S0#5pin@163_polysilicon-1##5 S0#5pin@163_polysilicon-1##6 9.896
R367 S0#5pin@163_polysilicon-1##6 S0#5pin@163_polysilicon-1##7 9.896
R368 S0#5pin@163_polysilicon-1##7 S0#5pin@163_polysilicon-1##8 9.896
R369 S0#5pin@163_polysilicon-1##8 S0#5pin@163_polysilicon-1##9 9.896
R370 S0#5pin@163_polysilicon-1##9 S0#5pin@163_polysilicon-1##10 9.896
R371 S0#5pin@163_polysilicon-1##10 S0#5pin@163_polysilicon-1##11 9.896
R372 S0#5pin@163_polysilicon-1##11 S0#6pin@164_polysilicon-1 9.896
R373 S0#6pin@164_polysilicon-1 S0#6pin@164_polysilicon-1##0 9.521
R374 S0#6pin@164_polysilicon-1##0 S0#6pin@164_polysilicon-1##1 9.521
R375 S0#6pin@164_polysilicon-1##1 S0#6pin@164_polysilicon-1##2 9.521
R376 S0#6pin@164_polysilicon-1##2 S0#6pin@164_polysilicon-1##3 9.521
R377 S0#6pin@164_polysilicon-1##3 S0#6pin@164_polysilicon-1##4 9.521
R378 S0#6pin@164_polysilicon-1##4 S0#6pin@164_polysilicon-1##5 9.521
R379 S0#6pin@164_polysilicon-1##5 S0#0pin@165_polysilicon-1 9.521
R380 S0#3pin@160_polysilicon-1 S0#3pin@160_polysilicon-1##0 5.425
R381 S0#3pin@160_polysilicon-1##0 S0#8pmos@19_poly-right 5.425
R382 S0#10nmos@20_poly-left S0#10nmos@20_poly-left##0 6.975
R383 S0#10nmos@20_poly-left##0 S0#11pin@169_polysilicon-1 6.975
R384 S0#11pin@169_polysilicon-1 S0#11pin@169_polysilicon-1##0 9.772
R385 S0#11pin@169_polysilicon-1##0 S0#11pin@169_polysilicon-1##1 9.772
R386 S0#11pin@169_polysilicon-1##1 S0#11pin@169_polysilicon-1##2 9.772
R387 S0#11pin@169_polysilicon-1##2 S0#11pin@169_polysilicon-1##3 9.772
R388 S0#11pin@169_polysilicon-1##3 S0#11pin@169_polysilicon-1##4 9.772
R389 S0#11pin@169_polysilicon-1##4 S0#11pin@169_polysilicon-1##5 9.772
R390 S0#11pin@169_polysilicon-1##5 S0#11pin@169_polysilicon-1##6 9.772
R391 S0#11pin@169_polysilicon-1##6 S0#11pin@169_polysilicon-1##7 9.772
R392 S0#11pin@169_polysilicon-1##7 S0#11pin@169_polysilicon-1##8 9.772
R393 S0#11pin@169_polysilicon-1##8 S0#11pin@169_polysilicon-1##9 9.772
R394 S0#11pin@169_polysilicon-1##9 S0#11pin@169_polysilicon-1##10 9.772
R395 S0#11pin@169_polysilicon-1##10 S0#11pin@169_polysilicon-1##11 9.772
R396 S0#11pin@169_polysilicon-1##11 S0#11pin@169_polysilicon-1##12 9.772
R397 S0#11pin@169_polysilicon-1##12 S0#11pin@169_polysilicon-1##13 9.772
R398 S0#11pin@169_polysilicon-1##13 S0#11pin@169_polysilicon-1##14 9.772
R399 S0#11pin@169_polysilicon-1##14 S0#11pin@169_polysilicon-1##15 9.772
R400 S0#11pin@169_polysilicon-1##15 S0#11pin@169_polysilicon-1##16 9.772
R401 S0#11pin@169_polysilicon-1##16 S0#11pin@169_polysilicon-1##17 9.772
R402 S0#11pin@169_polysilicon-1##17 S0#11pin@169_polysilicon-1##18 9.772
R403 S0#11pin@169_polysilicon-1##18 S0#11pin@169_polysilicon-1##19 9.772
R404 S0#11pin@169_polysilicon-1##19 S0#11pin@169_polysilicon-1##20 9.772
R405 S0#11pin@169_polysilicon-1##20 S0#11pin@169_polysilicon-1##21 9.772
R406 S0#11pin@169_polysilicon-1##21 S0#1pin@170_polysilicon-1 9.772
R407 S0#0pin@165_polysilicon-1 S0#0pin@165_polysilicon-1##0 8.267
R408 S0#0pin@165_polysilicon-1##0 S0#0pin@165_polysilicon-1##1 8.267
R409 S0#0pin@165_polysilicon-1##1 S0#3pin@160_polysilicon-1 8.267
R410 net@270#9pmos@20_poly-left net@270#10pin@171_polysilicon-1 7.75
R411 net@1#6nmos@0_poly-right net@1#6nmos@0_poly-right##0 6.2
R412 net@1#6nmos@0_poly-right##0 net@1#4pin@17_polysilicon-1 6.2
R413 net@270#10pin@171_polysilicon-1 net@270#10pin@171_polysilicon-1##0 9.042
R414 net@270#10pin@171_polysilicon-1##0 net@270#10pin@171_polysilicon-1##1 9.042
R415 net@270#10pin@171_polysilicon-1##1 net@270#10pin@171_polysilicon-1##2 9.042
R416 net@270#10pin@171_polysilicon-1##2 net@270#10pin@171_polysilicon-1##3 9.042
R417 net@270#10pin@171_polysilicon-1##3 net@270#10pin@171_polysilicon-1##4 9.042
R418 net@270#10pin@171_polysilicon-1##4 net@270#11pin@172_polysilicon-1 9.042
R419 net@270#11pin@172_polysilicon-1 net@270#11pin@172_polysilicon-1##0 9.3
R420 net@270#11pin@172_polysilicon-1##0 net@270#11pin@172_polysilicon-1##1 9.3
R421 net@270#11pin@172_polysilicon-1##1 net@270#11pin@172_polysilicon-1##2 9.3
R422 net@270#11pin@172_polysilicon-1##2 net@270#11pin@172_polysilicon-1##3 9.3
R423 net@270#11pin@172_polysilicon-1##3 net@270#11pin@172_polysilicon-1##4 9.3
R424 net@270#11pin@172_polysilicon-1##4 net@270#11pin@172_polysilicon-1##5 9.3
R425 net@270#11pin@172_polysilicon-1##5 net@270#11pin@172_polysilicon-1##6 9.3
R426 net@270#11pin@172_polysilicon-1##6 net@270#4pin@173_polysilicon-1 9.3
R427 net@24#4nmos@3_poly-right net@24#4nmos@3_poly-right##0 6.2
R428 net@24#4nmos@3_poly-right##0 net@24#5pin@40_polysilicon-1 6.2
R429 net@80#6pin@60_polysilicon-1 net@80#6pin@60_polysilicon-1##0 8.37
R430 net@80#6pin@60_polysilicon-1##0 net@80#6pin@60_polysilicon-1##1 8.37
R431 net@80#6pin@60_polysilicon-1##1 net@80#6pin@60_polysilicon-1##2 8.37
R432 net@80#6pin@60_polysilicon-1##2 net@80#6pin@60_polysilicon-1##3 8.37
R433 net@80#6pin@60_polysilicon-1##3 net@80 8.37
R434 S0#0pin@165_polysilicon-1 S0 4.29
R435 S1#34nmos@1_poly-right S1#34nmos@1_poly-right##0 7.233
R436 S1#34nmos@1_poly-right##0 S1#34nmos@1_poly-right##1 7.233
R437 S1#34nmos@1_poly-right##1 S1#35pin@2_polysilicon-1 7.233
R438 S1#36nmos@2_poly-left S1#36nmos@2_poly-left##0 6.975
R439 S1#36nmos@2_poly-left##0 S1#37pin@11_polysilicon-1 6.975
R440 S1#37pin@11_polysilicon-1 S1#37pin@11_polysilicon-1##0 9.772
R441 S1#37pin@11_polysilicon-1##0 S1#37pin@11_polysilicon-1##1 9.772
R442 S1#37pin@11_polysilicon-1##1 S1#37pin@11_polysilicon-1##2 9.772
R443 S1#37pin@11_polysilicon-1##2 S1#37pin@11_polysilicon-1##3 9.772
R444 S1#37pin@11_polysilicon-1##3 S1#37pin@11_polysilicon-1##4 9.772
R445 S1#37pin@11_polysilicon-1##4 S1#37pin@11_polysilicon-1##5 9.772
R446 S1#37pin@11_polysilicon-1##5 S1#37pin@11_polysilicon-1##6 9.772
R447 S1#37pin@11_polysilicon-1##6 S1#37pin@11_polysilicon-1##7 9.772
R448 S1#37pin@11_polysilicon-1##7 S1#37pin@11_polysilicon-1##8 9.772
R449 S1#37pin@11_polysilicon-1##8 S1#37pin@11_polysilicon-1##9 9.772
R450 S1#37pin@11_polysilicon-1##9 S1#37pin@11_polysilicon-1##10 9.772
R451 S1#37pin@11_polysilicon-1##10 S1#37pin@11_polysilicon-1##11 9.772
R452 S1#37pin@11_polysilicon-1##11 S1#37pin@11_polysilicon-1##12 9.772
R453 S1#37pin@11_polysilicon-1##12 S1#37pin@11_polysilicon-1##13 9.772
R454 S1#37pin@11_polysilicon-1##13 S1#37pin@11_polysilicon-1##14 9.772
R455 S1#37pin@11_polysilicon-1##14 S1#37pin@11_polysilicon-1##15 9.772
R456 S1#37pin@11_polysilicon-1##15 S1#37pin@11_polysilicon-1##16 9.772
R457 S1#37pin@11_polysilicon-1##16 S1#37pin@11_polysilicon-1##17 9.772
R458 S1#37pin@11_polysilicon-1##17 S1#37pin@11_polysilicon-1##18 9.772
R459 S1#37pin@11_polysilicon-1##18 S1#37pin@11_polysilicon-1##19 9.772
R460 S1#37pin@11_polysilicon-1##19 S1#37pin@11_polysilicon-1##20 9.772
R461 S1#37pin@11_polysilicon-1##20 S1#37pin@11_polysilicon-1##21 9.772
R462 S1#37pin@11_polysilicon-1##21 S1#38pin@12_polysilicon-1 9.772
R463 S1 S1##0 8.267
R464 S1##0 S1##1 8.267
R465 S1##1 S1#35pin@2_polysilicon-1 8.267
R466 net@80#8nmos@6_poly-right net@80#8nmos@6_poly-right##0 6.2
R467 net@80#8nmos@6_poly-right##0 net@80 6.2
R468 S1#39pmos@0_poly-left S1#39pmos@0_poly-left##0 6.2
R469 S1#39pmos@0_poly-left##0 S1#40pin@5_polysilicon-1 6.2
R470 S2#24nmos@8_poly-left S2#24nmos@8_poly-left##0 6.975
R471 S2#24nmos@8_poly-left##0 S2#25pin@56_polysilicon-1 6.975
R472 S2#25pin@56_polysilicon-1 S2#25pin@56_polysilicon-1##0 9.772
R473 S2#25pin@56_polysilicon-1##0 S2#25pin@56_polysilicon-1##1 9.772
R474 S2#25pin@56_polysilicon-1##1 S2#25pin@56_polysilicon-1##2 9.772
R475 S2#25pin@56_polysilicon-1##2 S2#25pin@56_polysilicon-1##3 9.772
R476 S2#25pin@56_polysilicon-1##3 S2#25pin@56_polysilicon-1##4 9.772
R477 S2#25pin@56_polysilicon-1##4 S2#25pin@56_polysilicon-1##5 9.772
R478 S2#25pin@56_polysilicon-1##5 S2#25pin@56_polysilicon-1##6 9.772
R479 S2#25pin@56_polysilicon-1##6 S2#25pin@56_polysilicon-1##7 9.772
R480 S2#25pin@56_polysilicon-1##7 S2#25pin@56_polysilicon-1##8 9.772
R481 S2#25pin@56_polysilicon-1##8 S2#25pin@56_polysilicon-1##9 9.772
R482 S2#25pin@56_polysilicon-1##9 S2#25pin@56_polysilicon-1##10 9.772
R483 S2#25pin@56_polysilicon-1##10 S2#25pin@56_polysilicon-1##11 9.772
R484 S2#25pin@56_polysilicon-1##11 S2#25pin@56_polysilicon-1##12 9.772
R485 S2#25pin@56_polysilicon-1##12 S2#25pin@56_polysilicon-1##13 9.772
R486 S2#25pin@56_polysilicon-1##13 S2#25pin@56_polysilicon-1##14 9.772
R487 S2#25pin@56_polysilicon-1##14 S2#25pin@56_polysilicon-1##15 9.772
R488 S2#25pin@56_polysilicon-1##15 S2#25pin@56_polysilicon-1##16 9.772
R489 S2#25pin@56_polysilicon-1##16 S2#25pin@56_polysilicon-1##17 9.772
R490 S2#25pin@56_polysilicon-1##17 S2#25pin@56_polysilicon-1##18 9.772
R491 S2#25pin@56_polysilicon-1##18 S2#25pin@56_polysilicon-1##19 9.772
R492 S2#25pin@56_polysilicon-1##19 S2#25pin@56_polysilicon-1##20 9.772
R493 S2#25pin@56_polysilicon-1##20 S2#25pin@56_polysilicon-1##21 9.772
R494 S2#25pin@56_polysilicon-1##21 S2#1pin@57_polysilicon-1 9.772
R495 S2 S2##0 8.267
R496 S2##0 S2##1 8.267
R497 S2##1 S2#7pin@48_polysilicon-1 8.267
R498 net@80#9pmos@8_poly-left net@80#10pin@58_polysilicon-1 7.75
R499 S1#41nmos@5_poly-left S1#41nmos@5_poly-left##0 6.975
R500 S1#41nmos@5_poly-left##0 S1#42pin@34_polysilicon-1 6.975
R501 net@80#10pin@58_polysilicon-1 net@80#10pin@58_polysilicon-1##0 9.042
R502 net@80#10pin@58_polysilicon-1##0 net@80#10pin@58_polysilicon-1##1 9.042
R503 net@80#10pin@58_polysilicon-1##1 net@80#10pin@58_polysilicon-1##2 9.042
R504 net@80#10pin@58_polysilicon-1##2 net@80#10pin@58_polysilicon-1##3 9.042
R505 net@80#10pin@58_polysilicon-1##3 net@80#10pin@58_polysilicon-1##4 9.042
R506 net@80#10pin@58_polysilicon-1##4 net@80#11pin@59_polysilicon-1 9.042
R507 net@80#11pin@59_polysilicon-1 net@80#11pin@59_polysilicon-1##0 9.3
R508 net@80#11pin@59_polysilicon-1##0 net@80#11pin@59_polysilicon-1##1 9.3
R509 net@80#11pin@59_polysilicon-1##1 net@80#11pin@59_polysilicon-1##2 9.3
R510 net@80#11pin@59_polysilicon-1##2 net@80#11pin@59_polysilicon-1##3 9.3
R511 net@80#11pin@59_polysilicon-1##3 net@80#11pin@59_polysilicon-1##4 9.3
R512 net@80#11pin@59_polysilicon-1##4 net@80#11pin@59_polysilicon-1##5 9.3
R513 net@80#11pin@59_polysilicon-1##5 net@80#11pin@59_polysilicon-1##6 9.3
R514 net@80#11pin@59_polysilicon-1##6 net@80#6pin@60_polysilicon-1 9.3
R515 net@1#7pmos@2_poly-left net@1#8pin@13_polysilicon-1 7.75
R516 S1#40pin@5_polysilicon-1 S1#40pin@5_polysilicon-1##0 9.896
R517 S1#40pin@5_polysilicon-1##0 S1#40pin@5_polysilicon-1##1 9.896
R518 S1#40pin@5_polysilicon-1##1 S1#40pin@5_polysilicon-1##2 9.896
R519 S1#40pin@5_polysilicon-1##2 S1#40pin@5_polysilicon-1##3 9.896
R520 S1#40pin@5_polysilicon-1##3 S1#40pin@5_polysilicon-1##4 9.896
R521 S1#40pin@5_polysilicon-1##4 S1#40pin@5_polysilicon-1##5 9.896
R522 S1#40pin@5_polysilicon-1##5 S1#40pin@5_polysilicon-1##6 9.896
R523 S1#40pin@5_polysilicon-1##6 S1#40pin@5_polysilicon-1##7 9.896
R524 S1#40pin@5_polysilicon-1##7 S1#40pin@5_polysilicon-1##8 9.896
R525 S1#40pin@5_polysilicon-1##8 S1#40pin@5_polysilicon-1##9 9.896
R526 S1#40pin@5_polysilicon-1##9 S1#40pin@5_polysilicon-1##10 9.896
R527 S1#40pin@5_polysilicon-1##10 S1#40pin@5_polysilicon-1##11 9.896
R528 S1#40pin@5_polysilicon-1##11 S1#43pin@6_polysilicon-1 9.896
R529 S1#43pin@6_polysilicon-1 S1#43pin@6_polysilicon-1##0 9.521
R530 S1#43pin@6_polysilicon-1##0 S1#43pin@6_polysilicon-1##1 9.521
R531 S1#43pin@6_polysilicon-1##1 S1#43pin@6_polysilicon-1##2 9.521
R532 S1#43pin@6_polysilicon-1##2 S1#43pin@6_polysilicon-1##3 9.521
R533 S1#43pin@6_polysilicon-1##3 S1#43pin@6_polysilicon-1##4 9.521
R534 S1#43pin@6_polysilicon-1##4 S1#43pin@6_polysilicon-1##5 9.521
R535 S1#43pin@6_polysilicon-1##5 S1 9.521
R536 S1#42pin@34_polysilicon-1 S1#42pin@34_polysilicon-1##0 9.772
R537 S1#42pin@34_polysilicon-1##0 S1#42pin@34_polysilicon-1##1 9.772
R538 S1#42pin@34_polysilicon-1##1 S1#42pin@34_polysilicon-1##2 9.772
R539 S1#42pin@34_polysilicon-1##2 S1#42pin@34_polysilicon-1##3 9.772
R540 S1#42pin@34_polysilicon-1##3 S1#42pin@34_polysilicon-1##4 9.772
R541 S1#42pin@34_polysilicon-1##4 S1#42pin@34_polysilicon-1##5 9.772
R542 S1#42pin@34_polysilicon-1##5 S1#42pin@34_polysilicon-1##6 9.772
R543 S1#42pin@34_polysilicon-1##6 S1#42pin@34_polysilicon-1##7 9.772
R544 S1#42pin@34_polysilicon-1##7 S1#42pin@34_polysilicon-1##8 9.772
R545 S1#42pin@34_polysilicon-1##8 S1#42pin@34_polysilicon-1##9 9.772
R546 S1#42pin@34_polysilicon-1##9 S1#42pin@34_polysilicon-1##10 9.772
R547 S1#42pin@34_polysilicon-1##10 S1#42pin@34_polysilicon-1##11 9.772
R548 S1#42pin@34_polysilicon-1##11 S1#42pin@34_polysilicon-1##12 9.772
R549 S1#42pin@34_polysilicon-1##12 S1#42pin@34_polysilicon-1##13 9.772
R550 S1#42pin@34_polysilicon-1##13 S1#42pin@34_polysilicon-1##14 9.772
R551 S1#42pin@34_polysilicon-1##14 S1#42pin@34_polysilicon-1##15 9.772
R552 S1#42pin@34_polysilicon-1##15 S1#42pin@34_polysilicon-1##16 9.772
R553 S1#42pin@34_polysilicon-1##16 S1#42pin@34_polysilicon-1##17 9.772
R554 S1#42pin@34_polysilicon-1##17 S1#42pin@34_polysilicon-1##18 9.772
R555 S1#42pin@34_polysilicon-1##18 S1#42pin@34_polysilicon-1##19 9.772
R556 S1#42pin@34_polysilicon-1##19 S1#42pin@34_polysilicon-1##20 9.772
R557 S1#42pin@34_polysilicon-1##20 S1#42pin@34_polysilicon-1##21 9.772
R558 S1#42pin@34_polysilicon-1##21 S1#45pin@35_polysilicon-1 9.772
R559 net@1#8pin@13_polysilicon-1 net@1#8pin@13_polysilicon-1##0 9.042
R560 net@1#8pin@13_polysilicon-1##0 net@1#8pin@13_polysilicon-1##1 9.042
R561 net@1#8pin@13_polysilicon-1##1 net@1#8pin@13_polysilicon-1##2 9.042
R562 net@1#8pin@13_polysilicon-1##2 net@1#8pin@13_polysilicon-1##3 9.042
R563 net@1#8pin@13_polysilicon-1##3 net@1#8pin@13_polysilicon-1##4 9.042
R564 net@1#8pin@13_polysilicon-1##4 net@1#9pin@14_polysilicon-1 9.042
R565 S1#35pin@2_polysilicon-1 S1#35pin@2_polysilicon-1##0 5.425
R566 S1#35pin@2_polysilicon-1##0 S1#46pmos@1_poly-right 5.425
R567 S1 S1##0 8.267
R568 S1##0 S1##1 8.267
R569 S1##1 S1#48pin@25_polysilicon-1 8.267
R570 net@1#9pin@14_polysilicon-1 net@1#9pin@14_polysilicon-1##0 9.3
R571 net@1#9pin@14_polysilicon-1##0 net@1#9pin@14_polysilicon-1##1 9.3
R572 net@1#9pin@14_polysilicon-1##1 net@1#9pin@14_polysilicon-1##2 9.3
R573 net@1#9pin@14_polysilicon-1##2 net@1#9pin@14_polysilicon-1##3 9.3
R574 net@1#9pin@14_polysilicon-1##3 net@1#9pin@14_polysilicon-1##4 9.3
R575 net@1#9pin@14_polysilicon-1##4 net@1#9pin@14_polysilicon-1##5 9.3
R576 net@1#9pin@14_polysilicon-1##5 net@1#9pin@14_polysilicon-1##6 9.3
R577 net@1#9pin@14_polysilicon-1##6 net@1#3pin@15_polysilicon-1 9.3
R578 S1 S1##0 9.881
R579 S1##0 S1##1 9.881
R580 S1##1 S1##2 9.881
R581 S1##2 S1##3 9.881
R582 S1##3 S1##4 9.881
R583 S1##4 S1##5 9.881
R584 S1##5 S1##6 9.881
R585 S1##6 S1#45pin@35_polysilicon-1 9.881
R586 net@24#5pin@40_polysilicon-1 net@24#5pin@40_polysilicon-1##0 9.042
R587 net@24#5pin@40_polysilicon-1##0 net@24#5pin@40_polysilicon-1##1 9.042
R588 net@24#5pin@40_polysilicon-1##1 net@24#5pin@40_polysilicon-1##2 9.042
R589 net@24#5pin@40_polysilicon-1##2 net@24#5pin@40_polysilicon-1##3 9.042
R590 net@24#5pin@40_polysilicon-1##3 net@24#5pin@40_polysilicon-1##4 9.042
R591 net@24#5pin@40_polysilicon-1##4 net@24#6contact@26_metal-1-n-act 9.042
R592 S1 S1##0 9.881
R593 S1##0 S1##1 9.881
R594 S1##1 S1##2 9.881
R595 S1##2 S1##3 9.881
R596 S1##3 S1##4 9.881
R597 S1##4 S1##5 9.881
R598 S1##5 S1##6 9.881
R599 S1##6 S1#38pin@12_polysilicon-1 9.881
R600 S1#50nmos@4_poly-right S1#50nmos@4_poly-right##0 7.233
R601 S1#50nmos@4_poly-right##0 S1#50nmos@4_poly-right##1 7.233
R602 S1#50nmos@4_poly-right##1 S1#48pin@25_polysilicon-1 7.233
R603 S1#51pmos@3_poly-left S1#51pmos@3_poly-left##0 6.2
R604 S1#51pmos@3_poly-left##0 S1#52pin@28_polysilicon-1 6.2
R605 S1#52pin@28_polysilicon-1 S1#52pin@28_polysilicon-1##0 9.896
R606 S1#52pin@28_polysilicon-1##0 S1#52pin@28_polysilicon-1##1 9.896
R607 S1#52pin@28_polysilicon-1##1 S1#52pin@28_polysilicon-1##2 9.896
R608 S1#52pin@28_polysilicon-1##2 S1#52pin@28_polysilicon-1##3 9.896
R609 S1#52pin@28_polysilicon-1##3 S1#52pin@28_polysilicon-1##4 9.896
R610 S1#52pin@28_polysilicon-1##4 S1#52pin@28_polysilicon-1##5 9.896
R611 S1#52pin@28_polysilicon-1##5 S1#52pin@28_polysilicon-1##6 9.896
R612 S1#52pin@28_polysilicon-1##6 S1#52pin@28_polysilicon-1##7 9.896
R613 S1#52pin@28_polysilicon-1##7 S1#52pin@28_polysilicon-1##8 9.896
R614 S1#52pin@28_polysilicon-1##8 S1#52pin@28_polysilicon-1##9 9.896
R615 S1#52pin@28_polysilicon-1##9 S1#52pin@28_polysilicon-1##10 9.896
R616 S1#52pin@28_polysilicon-1##10 S1#52pin@28_polysilicon-1##11 9.896
R617 S1#52pin@28_polysilicon-1##11 S1#53pin@29_polysilicon-1 9.896
R618 S1#53pin@29_polysilicon-1 S1#53pin@29_polysilicon-1##0 9.521
R619 S1#53pin@29_polysilicon-1##0 S1#53pin@29_polysilicon-1##1 9.521
R620 S1#53pin@29_polysilicon-1##1 S1#53pin@29_polysilicon-1##2 9.521
R621 S1#53pin@29_polysilicon-1##2 S1#53pin@29_polysilicon-1##3 9.521
R622 S1#53pin@29_polysilicon-1##3 S1#53pin@29_polysilicon-1##4 9.521
R623 S1#53pin@29_polysilicon-1##4 S1#53pin@29_polysilicon-1##5 9.521
R624 S1#53pin@29_polysilicon-1##5 S1 9.521
R625 S1#48pin@25_polysilicon-1 S1#48pin@25_polysilicon-1##0 5.425
R626 S1#48pin@25_polysilicon-1##0 S1#54pmos@4_poly-right 5.425
R627 net@1#4pin@17_polysilicon-1 net@1#4pin@17_polysilicon-1##0 9.042
R628 net@1#4pin@17_polysilicon-1##0 net@1#4pin@17_polysilicon-1##1 9.042
R629 net@1#4pin@17_polysilicon-1##1 net@1#4pin@17_polysilicon-1##2 9.042
R630 net@1#4pin@17_polysilicon-1##2 net@1#4pin@17_polysilicon-1##3 9.042
R631 net@1#4pin@17_polysilicon-1##3 net@1#4pin@17_polysilicon-1##4 9.042
R632 net@1#4pin@17_polysilicon-1##4 net@1 9.042
R633 net@24#3pin@38_polysilicon-1 net@24#3pin@38_polysilicon-1##0 8.37
R634 net@24#3pin@38_polysilicon-1##0 net@24#3pin@38_polysilicon-1##1 8.37
R635 net@24#3pin@38_polysilicon-1##1 net@24#3pin@38_polysilicon-1##2 8.37
R636 net@24#3pin@38_polysilicon-1##2 net@24#3pin@38_polysilicon-1##3 8.37
R637 net@24#3pin@38_polysilicon-1##3 net@24#5pin@40_polysilicon-1 8.37
R638 net@1000#2pin@212_polysilicon-1 net@1000#2pin@212_polysilicon-1##0 8.37
R639 net@1000#2pin@212_polysilicon-1##0 net@1000#2pin@212_polysilicon-1##1 8.37
R640 net@1000#2pin@212_polysilicon-1##1 net@1000#2pin@212_polysilicon-1##2 8.37
R641 net@1000#2pin@212_polysilicon-1##2 net@1000#2pin@212_polysilicon-1##3 8.37
R642 net@1000#2pin@212_polysilicon-1##3 net@1000#3pin@214_polysilicon-1 8.37
R643 net@1006 net@1006##0 6.2
R644 net@1006##0 net@1006#1pin@334_polysilicon-1 6.2
R645 net@1001#3pmos@30_poly-left net@1001#3pmos@30_poly-left##0 6.2
R646 net@1001#3pmos@30_poly-left##0 net@1001#4pin@277_polysilicon-1 6.2
R647 S2#26nmos@38_poly-left S2#26nmos@38_poly-left##0 6.975
R648 S2#26nmos@38_poly-left##0 S2#27pin@328_polysilicon-1 6.975
R649 S2#27pin@328_polysilicon-1 S2#27pin@328_polysilicon-1##0 9.772
R650 S2#27pin@328_polysilicon-1##0 S2#27pin@328_polysilicon-1##1 9.772
R651 S2#27pin@328_polysilicon-1##1 S2#27pin@328_polysilicon-1##2 9.772
R652 S2#27pin@328_polysilicon-1##2 S2#27pin@328_polysilicon-1##3 9.772
R653 S2#27pin@328_polysilicon-1##3 S2#27pin@328_polysilicon-1##4 9.772
R654 S2#27pin@328_polysilicon-1##4 S2#27pin@328_polysilicon-1##5 9.772
R655 S2#27pin@328_polysilicon-1##5 S2#27pin@328_polysilicon-1##6 9.772
R656 S2#27pin@328_polysilicon-1##6 S2#27pin@328_polysilicon-1##7 9.772
R657 S2#27pin@328_polysilicon-1##7 S2#27pin@328_polysilicon-1##8 9.772
R658 S2#27pin@328_polysilicon-1##8 S2#27pin@328_polysilicon-1##9 9.772
R659 S2#27pin@328_polysilicon-1##9 S2#27pin@328_polysilicon-1##10 9.772
R660 S2#27pin@328_polysilicon-1##10 S2#27pin@328_polysilicon-1##11 9.772
R661 S2#27pin@328_polysilicon-1##11 S2#27pin@328_polysilicon-1##12 9.772
R662 S2#27pin@328_polysilicon-1##12 S2#27pin@328_polysilicon-1##13 9.772
R663 S2#27pin@328_polysilicon-1##13 S2#27pin@328_polysilicon-1##14 9.772
R664 S2#27pin@328_polysilicon-1##14 S2#27pin@328_polysilicon-1##15 9.772
R665 S2#27pin@328_polysilicon-1##15 S2#27pin@328_polysilicon-1##16 9.772
R666 S2#27pin@328_polysilicon-1##16 S2#27pin@328_polysilicon-1##17 9.772
R667 S2#27pin@328_polysilicon-1##17 S2#27pin@328_polysilicon-1##18 9.772
R668 S2#27pin@328_polysilicon-1##18 S2#27pin@328_polysilicon-1##19 9.772
R669 S2#27pin@328_polysilicon-1##19 S2#27pin@328_polysilicon-1##20 9.772
R670 S2#27pin@328_polysilicon-1##20 S2#27pin@328_polysilicon-1##21 9.772
R671 S2#27pin@328_polysilicon-1##21 S2#28pin@329_polysilicon-1 9.772
R672 S2#29contact@299_metal-1-polysilicon-1 S2#29contact@299_metal-1-polysilicon-1##0 8.267
R673 S2#29contact@299_metal-1-polysilicon-1##0 S2#29contact@299_metal-1-polysilicon-1##1 8.267
R674 S2#29contact@299_metal-1-polysilicon-1##1 S2#30pin@320_polysilicon-1 8.267
R675 net@1006#2pmos@38_poly-left net@1006#3pin@330_polysilicon-1 7.75
R676 net@1001#5nmos@35_poly-left net@1001#5nmos@35_poly-left##0 6.975
R677 net@1001#5nmos@35_poly-left##0 net@1001#6pin@306_polysilicon-1 6.975
R678 S2#31pin@248_polysilicon-1 S2#31pin@248_polysilicon-1##0 9.896
R679 S2#31pin@248_polysilicon-1##0 S2#31pin@248_polysilicon-1##1 9.896
R680 S2#31pin@248_polysilicon-1##1 S2#31pin@248_polysilicon-1##2 9.896
R681 S2#31pin@248_polysilicon-1##2 S2#31pin@248_polysilicon-1##3 9.896
R682 S2#31pin@248_polysilicon-1##3 S2#31pin@248_polysilicon-1##4 9.896
R683 S2#31pin@248_polysilicon-1##4 S2#31pin@248_polysilicon-1##5 9.896
R684 S2#31pin@248_polysilicon-1##5 S2#31pin@248_polysilicon-1##6 9.896
R685 S2#31pin@248_polysilicon-1##6 S2#31pin@248_polysilicon-1##7 9.896
R686 S2#31pin@248_polysilicon-1##7 S2#31pin@248_polysilicon-1##8 9.896
R687 S2#31pin@248_polysilicon-1##8 S2#31pin@248_polysilicon-1##9 9.896
R688 S2#31pin@248_polysilicon-1##9 S2#31pin@248_polysilicon-1##10 9.896
R689 S2#31pin@248_polysilicon-1##10 S2#31pin@248_polysilicon-1##11 9.896
R690 S2#31pin@248_polysilicon-1##11 S2#32pin@249_polysilicon-1 9.896
R691 net@1006#3pin@330_polysilicon-1 net@1006#3pin@330_polysilicon-1##0 9.042
R692 net@1006#3pin@330_polysilicon-1##0 net@1006#3pin@330_polysilicon-1##1 9.042
R693 net@1006#3pin@330_polysilicon-1##1 net@1006#3pin@330_polysilicon-1##2 9.042
R694 net@1006#3pin@330_polysilicon-1##2 net@1006#3pin@330_polysilicon-1##3 9.042
R695 net@1006#3pin@330_polysilicon-1##3 net@1006#3pin@330_polysilicon-1##4 9.042
R696 net@1006#3pin@330_polysilicon-1##4 net@1006#4pin@331_polysilicon-1 9.042
R697 net@1006#4pin@331_polysilicon-1 net@1006#4pin@331_polysilicon-1##0 9.3
R698 net@1006#4pin@331_polysilicon-1##0 net@1006#4pin@331_polysilicon-1##1 9.3
R699 net@1006#4pin@331_polysilicon-1##1 net@1006#4pin@331_polysilicon-1##2 9.3
R700 net@1006#4pin@331_polysilicon-1##2 net@1006#4pin@331_polysilicon-1##3 9.3
R701 net@1006#4pin@331_polysilicon-1##3 net@1006#4pin@331_polysilicon-1##4 9.3
R702 net@1006#4pin@331_polysilicon-1##4 net@1006#4pin@331_polysilicon-1##5 9.3
R703 net@1006#4pin@331_polysilicon-1##5 net@1006#4pin@331_polysilicon-1##6 9.3
R704 net@1006#4pin@331_polysilicon-1##6 net@1006#5pin@332_polysilicon-1 9.3
R705 net@1001#4pin@277_polysilicon-1 net@1001#4pin@277_polysilicon-1##0 9.896
R706 net@1001#4pin@277_polysilicon-1##0 net@1001#4pin@277_polysilicon-1##1 9.896
R707 net@1001#4pin@277_polysilicon-1##1 net@1001#4pin@277_polysilicon-1##2 9.896
R708 net@1001#4pin@277_polysilicon-1##2 net@1001#4pin@277_polysilicon-1##3 9.896
R709 net@1001#4pin@277_polysilicon-1##3 net@1001#4pin@277_polysilicon-1##4 9.896
R710 net@1001#4pin@277_polysilicon-1##4 net@1001#4pin@277_polysilicon-1##5 9.896
R711 net@1001#4pin@277_polysilicon-1##5 net@1001#4pin@277_polysilicon-1##6 9.896
R712 net@1001#4pin@277_polysilicon-1##6 net@1001#4pin@277_polysilicon-1##7 9.896
R713 net@1001#4pin@277_polysilicon-1##7 net@1001#4pin@277_polysilicon-1##8 9.896
R714 net@1001#4pin@277_polysilicon-1##8 net@1001#4pin@277_polysilicon-1##9 9.896
R715 net@1001#4pin@277_polysilicon-1##9 net@1001#4pin@277_polysilicon-1##10 9.896
R716 net@1001#4pin@277_polysilicon-1##10 net@1001#4pin@277_polysilicon-1##11 9.896
R717 net@1001#4pin@277_polysilicon-1##11 net@1001#10pin@278_polysilicon-1 9.896
R718 net@1028 net@1028##0 9.042
R719 net@1028##0 net@1028##1 9.042
R720 net@1028##1 net@1028##2 9.042
R721 net@1028##2 net@1028##3 9.042
R722 net@1028##3 net@1028##4 9.042
R723 net@1028##4 net@1028#1pin@309_polysilicon-1 9.042
R724 net@1001#10pin@278_polysilicon-1 net@1001#10pin@278_polysilicon-1##0 9.521
R725 net@1001#10pin@278_polysilicon-1##0 net@1001#10pin@278_polysilicon-1##1 9.521
R726 net@1001#10pin@278_polysilicon-1##1 net@1001#10pin@278_polysilicon-1##2 9.521
R727 net@1001#10pin@278_polysilicon-1##2 net@1001#10pin@278_polysilicon-1##3 9.521
R728 net@1001#10pin@278_polysilicon-1##3 net@1001#10pin@278_polysilicon-1##4 9.521
R729 net@1001#10pin@278_polysilicon-1##4 net@1001#10pin@278_polysilicon-1##5 9.521
R730 net@1001#10pin@278_polysilicon-1##5 net@1001 9.521
R731 S2#32pin@249_polysilicon-1 S2#32pin@249_polysilicon-1##0 9.521
R732 S2#32pin@249_polysilicon-1##0 S2#32pin@249_polysilicon-1##1 9.521
R733 S2#32pin@249_polysilicon-1##1 S2#32pin@249_polysilicon-1##2 9.521
R734 S2#32pin@249_polysilicon-1##2 S2#32pin@249_polysilicon-1##3 9.521
R735 S2#32pin@249_polysilicon-1##3 S2#32pin@249_polysilicon-1##4 9.521
R736 S2#32pin@249_polysilicon-1##4 S2#32pin@249_polysilicon-1##5 9.521
R737 S2#32pin@249_polysilicon-1##5 S2#29contact@299_metal-1-polysilicon-1 9.521
R738 net@1001#6pin@306_polysilicon-1 net@1001#6pin@306_polysilicon-1##0 9.772
R739 net@1001#6pin@306_polysilicon-1##0 net@1001#6pin@306_polysilicon-1##1 9.772
R740 net@1001#6pin@306_polysilicon-1##1 net@1001#6pin@306_polysilicon-1##2 9.772
R741 net@1001#6pin@306_polysilicon-1##2 net@1001#6pin@306_polysilicon-1##3 9.772
R742 net@1001#6pin@306_polysilicon-1##3 net@1001#6pin@306_polysilicon-1##4 9.772
R743 net@1001#6pin@306_polysilicon-1##4 net@1001#6pin@306_polysilicon-1##5 9.772
R744 net@1001#6pin@306_polysilicon-1##5 net@1001#6pin@306_polysilicon-1##6 9.772
R745 net@1001#6pin@306_polysilicon-1##6 net@1001#6pin@306_polysilicon-1##7 9.772
R746 net@1001#6pin@306_polysilicon-1##7 net@1001#6pin@306_polysilicon-1##8 9.772
R747 net@1001#6pin@306_polysilicon-1##8 net@1001#6pin@306_polysilicon-1##9 9.772
R748 net@1001#6pin@306_polysilicon-1##9 net@1001#6pin@306_polysilicon-1##10 9.772
R749 net@1001#6pin@306_polysilicon-1##10 net@1001#6pin@306_polysilicon-1##11 9.772
R750 net@1001#6pin@306_polysilicon-1##11 net@1001#6pin@306_polysilicon-1##12 9.772
R751 net@1001#6pin@306_polysilicon-1##12 net@1001#6pin@306_polysilicon-1##13 9.772
R752 net@1001#6pin@306_polysilicon-1##13 net@1001#6pin@306_polysilicon-1##14 9.772
R753 net@1001#6pin@306_polysilicon-1##14 net@1001#6pin@306_polysilicon-1##15 9.772
R754 net@1001#6pin@306_polysilicon-1##15 net@1001#6pin@306_polysilicon-1##16 9.772
R755 net@1001#6pin@306_polysilicon-1##16 net@1001#6pin@306_polysilicon-1##17 9.772
R756 net@1001#6pin@306_polysilicon-1##17 net@1001#6pin@306_polysilicon-1##18 9.772
R757 net@1001#6pin@306_polysilicon-1##18 net@1001#6pin@306_polysilicon-1##19 9.772
R758 net@1001#6pin@306_polysilicon-1##19 net@1001#6pin@306_polysilicon-1##20 9.772
R759 net@1001#6pin@306_polysilicon-1##20 net@1001#6pin@306_polysilicon-1##21 9.772
R760 net@1001#6pin@306_polysilicon-1##21 net@1001#12pin@307_polysilicon-1 9.772
R761 net@1001#14pin@274_polysilicon-1 net@1001#14pin@274_polysilicon-1##0 5.425
R762 net@1001#14pin@274_polysilicon-1##0 net@1001#15pmos@31_poly-right 5.425
R763 net@1001 net@1001##0 8.267
R764 net@1001##0 net@1001##1 8.267
R765 net@1001##1 net@1001#16pin@297_polysilicon-1 8.267
R766 S2#35pin@245_polysilicon-1 S2#35pin@245_polysilicon-1##0 5.425
R767 S2#35pin@245_polysilicon-1##0 S2#36pmos@28_poly-right 5.425
R768 net@1064 net@1064##0 9.042
R769 net@1064##0 net@1064##1 9.042
R770 net@1064##1 net@1064##2 9.042
R771 net@1064##2 net@1064##3 9.042
R772 net@1064##3 net@1064##4 9.042
R773 net@1064##4 net@1064#1pin@234_polysilicon-1 9.042
R774 net@1064#2pmos@26_poly-left net@1064 7.75
R775 net@1102#4pin@370_polysilicon-1 net@1102#4pin@370_polysilicon-1##0 8.37
R776 net@1102#4pin@370_polysilicon-1##0 net@1102#4pin@370_polysilicon-1##1 8.37
R777 net@1102#4pin@370_polysilicon-1##1 net@1102#4pin@370_polysilicon-1##2 8.37
R778 net@1102#4pin@370_polysilicon-1##2 net@1102#4pin@370_polysilicon-1##3 8.37
R779 net@1102#4pin@370_polysilicon-1##3 net@1102#5pin@372_polysilicon-1 8.37
R780 net@1102#6nmos@39_poly-right net@1102#6nmos@39_poly-right##0 6.2
R781 net@1102#6nmos@39_poly-right##0 net@1102#5pin@372_polysilicon-1 6.2
R782 S0#16pin@362_polysilicon-1 S0#16pin@362_polysilicon-1##0 9.881
R783 S0#16pin@362_polysilicon-1##0 S0#16pin@362_polysilicon-1##1 9.881
R784 S0#16pin@362_polysilicon-1##1 S0#16pin@362_polysilicon-1##2 9.881
R785 S0#16pin@362_polysilicon-1##2 S0#16pin@362_polysilicon-1##3 9.881
R786 S0#16pin@362_polysilicon-1##3 S0#16pin@362_polysilicon-1##4 9.881
R787 S0#16pin@362_polysilicon-1##4 S0#16pin@362_polysilicon-1##5 9.881
R788 S0#16pin@362_polysilicon-1##5 S0#16pin@362_polysilicon-1##6 9.881
R789 S0#16pin@362_polysilicon-1##6 S0#17pin@367_polysilicon-1 9.881
R790 net@1102#5pin@372_polysilicon-1 net@1102#5pin@372_polysilicon-1##0 9.042
R791 net@1102#5pin@372_polysilicon-1##0 net@1102#5pin@372_polysilicon-1##1 9.042
R792 net@1102#5pin@372_polysilicon-1##1 net@1102#5pin@372_polysilicon-1##2 9.042
R793 net@1102#5pin@372_polysilicon-1##2 net@1102#5pin@372_polysilicon-1##3 9.042
R794 net@1102#5pin@372_polysilicon-1##3 net@1102#5pin@372_polysilicon-1##4 9.042
R795 net@1102#5pin@372_polysilicon-1##4 net@1102 9.042
R796 S0#18nmos@40_poly-right S0#18nmos@40_poly-right##0 7.233
R797 S0#18nmos@40_poly-right##0 S0#18nmos@40_poly-right##1 7.233
R798 S0#18nmos@40_poly-right##1 S0#19pin@357_polysilicon-1 7.233
R799 S0#20pmos@39_poly-left S0#20pmos@39_poly-left##0 6.2
R800 S0#20pmos@39_poly-left##0 S0#21pin@360_polysilicon-1 6.2
R801 net@1063#2pin@289_polysilicon-1 net@1063#2pin@289_polysilicon-1##0 9.042
R802 net@1063#2pin@289_polysilicon-1##0 net@1063#2pin@289_polysilicon-1##1 9.042
R803 net@1063#2pin@289_polysilicon-1##1 net@1063#2pin@289_polysilicon-1##2 9.042
R804 net@1063#2pin@289_polysilicon-1##2 net@1063#2pin@289_polysilicon-1##3 9.042
R805 net@1063#2pin@289_polysilicon-1##3 net@1063#2pin@289_polysilicon-1##4 9.042
R806 net@1063#2pin@289_polysilicon-1##4 net@1063 9.042
R807 S0#21pin@360_polysilicon-1 S0#21pin@360_polysilicon-1##0 9.896
R808 S0#21pin@360_polysilicon-1##0 S0#21pin@360_polysilicon-1##1 9.896
R809 S0#21pin@360_polysilicon-1##1 S0#21pin@360_polysilicon-1##2 9.896
R810 S0#21pin@360_polysilicon-1##2 S0#21pin@360_polysilicon-1##3 9.896
R811 S0#21pin@360_polysilicon-1##3 S0#21pin@360_polysilicon-1##4 9.896
R812 S0#21pin@360_polysilicon-1##4 S0#21pin@360_polysilicon-1##5 9.896
R813 S0#21pin@360_polysilicon-1##5 S0#21pin@360_polysilicon-1##6 9.896
R814 S0#21pin@360_polysilicon-1##6 S0#21pin@360_polysilicon-1##7 9.896
R815 S0#21pin@360_polysilicon-1##7 S0#21pin@360_polysilicon-1##8 9.896
R816 S0#21pin@360_polysilicon-1##8 S0#21pin@360_polysilicon-1##9 9.896
R817 S0#21pin@360_polysilicon-1##9 S0#21pin@360_polysilicon-1##10 9.896
R818 S0#21pin@360_polysilicon-1##10 S0#21pin@360_polysilicon-1##11 9.896
R819 S0#21pin@360_polysilicon-1##11 S0#22pin@361_polysilicon-1 9.896
R820 S0#22pin@361_polysilicon-1 S0#22pin@361_polysilicon-1##0 9.521
R821 S0#22pin@361_polysilicon-1##0 S0#22pin@361_polysilicon-1##1 9.521
R822 S0#22pin@361_polysilicon-1##1 S0#22pin@361_polysilicon-1##2 9.521
R823 S0#22pin@361_polysilicon-1##2 S0#22pin@361_polysilicon-1##3 9.521
R824 S0#22pin@361_polysilicon-1##3 S0#22pin@361_polysilicon-1##4 9.521
R825 S0#22pin@361_polysilicon-1##4 S0#22pin@361_polysilicon-1##5 9.521
R826 S0#22pin@361_polysilicon-1##5 S0#16pin@362_polysilicon-1 9.521
R827 S0#19pin@357_polysilicon-1 S0#19pin@357_polysilicon-1##0 5.425
R828 S0#19pin@357_polysilicon-1##0 S0#24pmos@40_poly-right 5.425
R829 net@1028#2pin@310_polysilicon-1 net@1028#2pin@310_polysilicon-1##0 8.37
R830 net@1028#2pin@310_polysilicon-1##0 net@1028#2pin@310_polysilicon-1##1 8.37
R831 net@1028#2pin@310_polysilicon-1##1 net@1028#2pin@310_polysilicon-1##2 8.37
R832 net@1028#2pin@310_polysilicon-1##2 net@1028#2pin@310_polysilicon-1##3 8.37
R833 net@1028#2pin@310_polysilicon-1##3 net@1028#3pin@312_polysilicon-1 8.37
R834 S0#26nmos@41_poly-left S0#26nmos@41_poly-left##0 6.975
R835 S0#26nmos@41_poly-left##0 S0#27pin@366_polysilicon-1 6.975
R836 S0#27pin@366_polysilicon-1 S0#27pin@366_polysilicon-1##0 9.772
R837 S0#27pin@366_polysilicon-1##0 S0#27pin@366_polysilicon-1##1 9.772
R838 S0#27pin@366_polysilicon-1##1 S0#27pin@366_polysilicon-1##2 9.772
R839 S0#27pin@366_polysilicon-1##2 S0#27pin@366_polysilicon-1##3 9.772
R840 S0#27pin@366_polysilicon-1##3 S0#27pin@366_polysilicon-1##4 9.772
R841 S0#27pin@366_polysilicon-1##4 S0#27pin@366_polysilicon-1##5 9.772
R842 S0#27pin@366_polysilicon-1##5 S0#27pin@366_polysilicon-1##6 9.772
R843 S0#27pin@366_polysilicon-1##6 S0#27pin@366_polysilicon-1##7 9.772
R844 S0#27pin@366_polysilicon-1##7 S0#27pin@366_polysilicon-1##8 9.772
R845 S0#27pin@366_polysilicon-1##8 S0#27pin@366_polysilicon-1##9 9.772
R846 S0#27pin@366_polysilicon-1##9 S0#27pin@366_polysilicon-1##10 9.772
R847 S0#27pin@366_polysilicon-1##10 S0#27pin@366_polysilicon-1##11 9.772
R848 S0#27pin@366_polysilicon-1##11 S0#27pin@366_polysilicon-1##12 9.772
R849 S0#27pin@366_polysilicon-1##12 S0#27pin@366_polysilicon-1##13 9.772
R850 S0#27pin@366_polysilicon-1##13 S0#27pin@366_polysilicon-1##14 9.772
R851 S0#27pin@366_polysilicon-1##14 S0#27pin@366_polysilicon-1##15 9.772
R852 S0#27pin@366_polysilicon-1##15 S0#27pin@366_polysilicon-1##16 9.772
R853 S0#27pin@366_polysilicon-1##16 S0#27pin@366_polysilicon-1##17 9.772
R854 S0#27pin@366_polysilicon-1##17 S0#27pin@366_polysilicon-1##18 9.772
R855 S0#27pin@366_polysilicon-1##18 S0#27pin@366_polysilicon-1##19 9.772
R856 S0#27pin@366_polysilicon-1##19 S0#27pin@366_polysilicon-1##20 9.772
R857 S0#27pin@366_polysilicon-1##20 S0#27pin@366_polysilicon-1##21 9.772
R858 S0#27pin@366_polysilicon-1##21 S0#17pin@367_polysilicon-1 9.772
R859 S0#16pin@362_polysilicon-1 S0#16pin@362_polysilicon-1##0 8.267
R860 S0#16pin@362_polysilicon-1##0 S0#16pin@362_polysilicon-1##1 8.267
R861 S0#16pin@362_polysilicon-1##1 S0#19pin@357_polysilicon-1 8.267
R862 net@1102#9pmos@41_poly-left net@1102#10pin@368_polysilicon-1 7.75
R863 net@1000#6nmos@21_poly-right net@1000#6nmos@21_poly-right##0 6.2
R864 net@1000#6nmos@21_poly-right##0 net@1000#3pin@214_polysilicon-1 6.2
R865 net@1102#10pin@368_polysilicon-1 net@1102#10pin@368_polysilicon-1##0 9.042
R866 net@1102#10pin@368_polysilicon-1##0 net@1102#10pin@368_polysilicon-1##1 9.042
R867 net@1102#10pin@368_polysilicon-1##1 net@1102#10pin@368_polysilicon-1##2 9.042
R868 net@1102#10pin@368_polysilicon-1##2 net@1102#10pin@368_polysilicon-1##3 9.042
R869 net@1102#10pin@368_polysilicon-1##3 net@1102#10pin@368_polysilicon-1##4 9.042
R870 net@1102#10pin@368_polysilicon-1##4 net@1102#11pin@369_polysilicon-1 9.042
R871 net@1102#11pin@369_polysilicon-1 net@1102#11pin@369_polysilicon-1##0 9.3
R872 net@1102#11pin@369_polysilicon-1##0 net@1102#11pin@369_polysilicon-1##1 9.3
R873 net@1102#11pin@369_polysilicon-1##1 net@1102#11pin@369_polysilicon-1##2 9.3
R874 net@1102#11pin@369_polysilicon-1##2 net@1102#11pin@369_polysilicon-1##3 9.3
R875 net@1102#11pin@369_polysilicon-1##3 net@1102#11pin@369_polysilicon-1##4 9.3
R876 net@1102#11pin@369_polysilicon-1##4 net@1102#11pin@369_polysilicon-1##5 9.3
R877 net@1102#11pin@369_polysilicon-1##5 net@1102#11pin@369_polysilicon-1##6 9.3
R878 net@1102#11pin@369_polysilicon-1##6 net@1102#4pin@370_polysilicon-1 9.3
R879 net@1064#3nmos@24_poly-right net@1064#3nmos@24_poly-right##0 6.2
R880 net@1064#3nmos@24_poly-right##0 net@1064#4pin@237_polysilicon-1 6.2
R881 net@1028#1pin@309_polysilicon-1 net@1028#1pin@309_polysilicon-1##0 9.3
R882 net@1028#1pin@309_polysilicon-1##0 net@1028#1pin@309_polysilicon-1##1 9.3
R883 net@1028#1pin@309_polysilicon-1##1 net@1028#1pin@309_polysilicon-1##2 9.3
R884 net@1028#1pin@309_polysilicon-1##2 net@1028#1pin@309_polysilicon-1##3 9.3
R885 net@1028#1pin@309_polysilicon-1##3 net@1028#1pin@309_polysilicon-1##4 9.3
R886 net@1028#1pin@309_polysilicon-1##4 net@1028#1pin@309_polysilicon-1##5 9.3
R887 net@1028#1pin@309_polysilicon-1##5 net@1028#1pin@309_polysilicon-1##6 9.3
R888 net@1028#1pin@309_polysilicon-1##6 net@1028#2pin@310_polysilicon-1 9.3
R889 net@1082#5pin@257_polysilicon-1 net@1082#5pin@257_polysilicon-1##0 8.37
R890 net@1082#5pin@257_polysilicon-1##0 net@1082#5pin@257_polysilicon-1##1 8.37
R891 net@1082#5pin@257_polysilicon-1##1 net@1082#5pin@257_polysilicon-1##2 8.37
R892 net@1082#5pin@257_polysilicon-1##2 net@1082#5pin@257_polysilicon-1##3 8.37
R893 net@1082#5pin@257_polysilicon-1##3 net@1082#6pin@259_polysilicon-1 8.37
R894 S0#16pin@362_polysilicon-1 S0#31contact@360_metal-1-metal-2 4.29
R895 net@1001#22nmos@22_poly-right net@1001#22nmos@22_poly-right##0 7.233
R896 net@1001#22nmos@22_poly-right##0 net@1001#22nmos@22_poly-right##1 7.233
R897 net@1001#22nmos@22_poly-right##1 net@1001#23pin@199_polysilicon-1 7.233
R898 net@1001#24nmos@23_poly-left net@1001#24nmos@23_poly-left##0 6.975
R899 net@1001#24nmos@23_poly-left##0 net@1001#25pin@208_polysilicon-1 6.975
R900 net@1001#25pin@208_polysilicon-1 net@1001#25pin@208_polysilicon-1##0 9.772
R901 net@1001#25pin@208_polysilicon-1##0 net@1001#25pin@208_polysilicon-1##1 9.772
R902 net@1001#25pin@208_polysilicon-1##1 net@1001#25pin@208_polysilicon-1##2 9.772
R903 net@1001#25pin@208_polysilicon-1##2 net@1001#25pin@208_polysilicon-1##3 9.772
R904 net@1001#25pin@208_polysilicon-1##3 net@1001#25pin@208_polysilicon-1##4 9.772
R905 net@1001#25pin@208_polysilicon-1##4 net@1001#25pin@208_polysilicon-1##5 9.772
R906 net@1001#25pin@208_polysilicon-1##5 net@1001#25pin@208_polysilicon-1##6 9.772
R907 net@1001#25pin@208_polysilicon-1##6 net@1001#25pin@208_polysilicon-1##7 9.772
R908 net@1001#25pin@208_polysilicon-1##7 net@1001#25pin@208_polysilicon-1##8 9.772
R909 net@1001#25pin@208_polysilicon-1##8 net@1001#25pin@208_polysilicon-1##9 9.772
R910 net@1001#25pin@208_polysilicon-1##9 net@1001#25pin@208_polysilicon-1##10 9.772
R911 net@1001#25pin@208_polysilicon-1##10 net@1001#25pin@208_polysilicon-1##11 9.772
R912 net@1001#25pin@208_polysilicon-1##11 net@1001#25pin@208_polysilicon-1##12 9.772
R913 net@1001#25pin@208_polysilicon-1##12 net@1001#25pin@208_polysilicon-1##13 9.772
R914 net@1001#25pin@208_polysilicon-1##13 net@1001#25pin@208_polysilicon-1##14 9.772
R915 net@1001#25pin@208_polysilicon-1##14 net@1001#25pin@208_polysilicon-1##15 9.772
R916 net@1001#25pin@208_polysilicon-1##15 net@1001#25pin@208_polysilicon-1##16 9.772
R917 net@1001#25pin@208_polysilicon-1##16 net@1001#25pin@208_polysilicon-1##17 9.772
R918 net@1001#25pin@208_polysilicon-1##17 net@1001#25pin@208_polysilicon-1##18 9.772
R919 net@1001#25pin@208_polysilicon-1##18 net@1001#25pin@208_polysilicon-1##19 9.772
R920 net@1001#25pin@208_polysilicon-1##19 net@1001#25pin@208_polysilicon-1##20 9.772
R921 net@1001#25pin@208_polysilicon-1##20 net@1001#25pin@208_polysilicon-1##21 9.772
R922 net@1001#25pin@208_polysilicon-1##21 net@1001#26pin@209_polysilicon-1 9.772
R923 net@1001#16pin@297_polysilicon-1 net@1001#16pin@297_polysilicon-1##0 5.425
R924 net@1001#16pin@297_polysilicon-1##0 net@1001#27pmos@34_poly-right 5.425
R925 net@1063#3pin@287_polysilicon-1 net@1063#3pin@287_polysilicon-1##0 8.37
R926 net@1063#3pin@287_polysilicon-1##0 net@1063#3pin@287_polysilicon-1##1 8.37
R927 net@1063#3pin@287_polysilicon-1##1 net@1063#3pin@287_polysilicon-1##2 8.37
R928 net@1063#3pin@287_polysilicon-1##2 net@1063#3pin@287_polysilicon-1##3 8.37
R929 net@1063#3pin@287_polysilicon-1##3 net@1063#2pin@289_polysilicon-1 8.37
R930 net@1001 net@1001##0 8.267
R931 net@1001##0 net@1001##1 8.267
R932 net@1001##1 net@1001#23pin@199_polysilicon-1 8.267
R933 net@1082#8nmos@27_poly-right net@1082#8nmos@27_poly-right##0 6.2
R934 net@1082#8nmos@27_poly-right##0 net@1082#6pin@259_polysilicon-1 6.2
R935 net@1001#29pmos@21_poly-left net@1001#29pmos@21_poly-left##0 6.2
R936 net@1001#29pmos@21_poly-left##0 net@1001#30pin@202_polysilicon-1 6.2
R937 S2#42nmos@29_poly-left S2#42nmos@29_poly-left##0 6.975
R938 S2#42nmos@29_poly-left##0 S2#43pin@253_polysilicon-1 6.975
R939 S2#43pin@253_polysilicon-1 S2#43pin@253_polysilicon-1##0 9.772
R940 S2#43pin@253_polysilicon-1##0 S2#43pin@253_polysilicon-1##1 9.772
R941 S2#43pin@253_polysilicon-1##1 S2#43pin@253_polysilicon-1##2 9.772
R942 S2#43pin@253_polysilicon-1##2 S2#43pin@253_polysilicon-1##3 9.772
R943 S2#43pin@253_polysilicon-1##3 S2#43pin@253_polysilicon-1##4 9.772
R944 S2#43pin@253_polysilicon-1##4 S2#43pin@253_polysilicon-1##5 9.772
R945 S2#43pin@253_polysilicon-1##5 S2#43pin@253_polysilicon-1##6 9.772
R946 S2#43pin@253_polysilicon-1##6 S2#43pin@253_polysilicon-1##7 9.772
R947 S2#43pin@253_polysilicon-1##7 S2#43pin@253_polysilicon-1##8 9.772
R948 S2#43pin@253_polysilicon-1##8 S2#43pin@253_polysilicon-1##9 9.772
R949 S2#43pin@253_polysilicon-1##9 S2#43pin@253_polysilicon-1##10 9.772
R950 S2#43pin@253_polysilicon-1##10 S2#43pin@253_polysilicon-1##11 9.772
R951 S2#43pin@253_polysilicon-1##11 S2#43pin@253_polysilicon-1##12 9.772
R952 S2#43pin@253_polysilicon-1##12 S2#43pin@253_polysilicon-1##13 9.772
R953 S2#43pin@253_polysilicon-1##13 S2#43pin@253_polysilicon-1##14 9.772
R954 S2#43pin@253_polysilicon-1##14 S2#43pin@253_polysilicon-1##15 9.772
R955 S2#43pin@253_polysilicon-1##15 S2#43pin@253_polysilicon-1##16 9.772
R956 S2#43pin@253_polysilicon-1##16 S2#43pin@253_polysilicon-1##17 9.772
R957 S2#43pin@253_polysilicon-1##17 S2#43pin@253_polysilicon-1##18 9.772
R958 S2#43pin@253_polysilicon-1##18 S2#43pin@253_polysilicon-1##19 9.772
R959 S2#43pin@253_polysilicon-1##19 S2#43pin@253_polysilicon-1##20 9.772
R960 S2#43pin@253_polysilicon-1##20 S2#43pin@253_polysilicon-1##21 9.772
R961 S2#43pin@253_polysilicon-1##21 S2#44pin@254_polysilicon-1 9.772
R962 S2#29contact@299_metal-1-polysilicon-1 S2#29contact@299_metal-1-polysilicon-1##0 8.267
R963 S2#29contact@299_metal-1-polysilicon-1##0 S2#29contact@299_metal-1-polysilicon-1##1 8.267
R964 S2#29contact@299_metal-1-polysilicon-1##1 S2#35pin@245_polysilicon-1 8.267
R965 net@1082#9pmos@29_poly-left net@1082#10pin@255_polysilicon-1 7.75
R966 net@1001#31nmos@26_poly-left net@1001#31nmos@26_poly-left##0 6.975
R967 net@1001#31nmos@26_poly-left##0 net@1001#32pin@231_polysilicon-1 6.975
R968 net@1082#10pin@255_polysilicon-1 net@1082#10pin@255_polysilicon-1##0 9.042
R969 net@1082#10pin@255_polysilicon-1##0 net@1082#10pin@255_polysilicon-1##1 9.042
R970 net@1082#10pin@255_polysilicon-1##1 net@1082#10pin@255_polysilicon-1##2 9.042
R971 net@1082#10pin@255_polysilicon-1##2 net@1082#10pin@255_polysilicon-1##3 9.042
R972 net@1082#10pin@255_polysilicon-1##3 net@1082#10pin@255_polysilicon-1##4 9.042
R973 net@1082#10pin@255_polysilicon-1##4 net@1082#11pin@256_polysilicon-1 9.042
R974 net@1082#11pin@256_polysilicon-1 net@1082#11pin@256_polysilicon-1##0 9.3
R975 net@1082#11pin@256_polysilicon-1##0 net@1082#11pin@256_polysilicon-1##1 9.3
R976 net@1082#11pin@256_polysilicon-1##1 net@1082#11pin@256_polysilicon-1##2 9.3
R977 net@1082#11pin@256_polysilicon-1##2 net@1082#11pin@256_polysilicon-1##3 9.3
R978 net@1082#11pin@256_polysilicon-1##3 net@1082#11pin@256_polysilicon-1##4 9.3
R979 net@1082#11pin@256_polysilicon-1##4 net@1082#11pin@256_polysilicon-1##5 9.3
R980 net@1082#11pin@256_polysilicon-1##5 net@1082#11pin@256_polysilicon-1##6 9.3
R981 net@1082#11pin@256_polysilicon-1##6 net@1082#5pin@257_polysilicon-1 9.3
R982 net@1000#7pmos@23_poly-left net@1000#8pin@210_polysilicon-1 7.75
R983 net@1001#30pin@202_polysilicon-1 net@1001#30pin@202_polysilicon-1##0 9.896
R984 net@1001#30pin@202_polysilicon-1##0 net@1001#30pin@202_polysilicon-1##1 9.896
R985 net@1001#30pin@202_polysilicon-1##1 net@1001#30pin@202_polysilicon-1##2 9.896
R986 net@1001#30pin@202_polysilicon-1##2 net@1001#30pin@202_polysilicon-1##3 9.896
R987 net@1001#30pin@202_polysilicon-1##3 net@1001#30pin@202_polysilicon-1##4 9.896
R988 net@1001#30pin@202_polysilicon-1##4 net@1001#30pin@202_polysilicon-1##5 9.896
R989 net@1001#30pin@202_polysilicon-1##5 net@1001#30pin@202_polysilicon-1##6 9.896
R990 net@1001#30pin@202_polysilicon-1##6 net@1001#30pin@202_polysilicon-1##7 9.896
R991 net@1001#30pin@202_polysilicon-1##7 net@1001#30pin@202_polysilicon-1##8 9.896
R992 net@1001#30pin@202_polysilicon-1##8 net@1001#30pin@202_polysilicon-1##9 9.896
R993 net@1001#30pin@202_polysilicon-1##9 net@1001#30pin@202_polysilicon-1##10 9.896
R994 net@1001#30pin@202_polysilicon-1##10 net@1001#30pin@202_polysilicon-1##11 9.896
R995 net@1001#30pin@202_polysilicon-1##11 net@1001#33pin@203_polysilicon-1 9.896
R996 net@1001#33pin@203_polysilicon-1 net@1001#33pin@203_polysilicon-1##0 9.521
R997 net@1001#33pin@203_polysilicon-1##0 net@1001#33pin@203_polysilicon-1##1 9.521
R998 net@1001#33pin@203_polysilicon-1##1 net@1001#33pin@203_polysilicon-1##2 9.521
R999 net@1001#33pin@203_polysilicon-1##2 net@1001#33pin@203_polysilicon-1##3 9.521
R1000 net@1001#33pin@203_polysilicon-1##3 net@1001#33pin@203_polysilicon-1##4 9.521
R1001 net@1001#33pin@203_polysilicon-1##4 net@1001#33pin@203_polysilicon-1##5 9.521
R1002 net@1001#33pin@203_polysilicon-1##5 net@1001 9.521
R1003 net@1001#32pin@231_polysilicon-1 net@1001#32pin@231_polysilicon-1##0 9.772
R1004 net@1001#32pin@231_polysilicon-1##0 net@1001#32pin@231_polysilicon-1##1 9.772
R1005 net@1001#32pin@231_polysilicon-1##1 net@1001#32pin@231_polysilicon-1##2 9.772
R1006 net@1001#32pin@231_polysilicon-1##2 net@1001#32pin@231_polysilicon-1##3 9.772
R1007 net@1001#32pin@231_polysilicon-1##3 net@1001#32pin@231_polysilicon-1##4 9.772
R1008 net@1001#32pin@231_polysilicon-1##4 net@1001#32pin@231_polysilicon-1##5 9.772
R1009 net@1001#32pin@231_polysilicon-1##5 net@1001#32pin@231_polysilicon-1##6 9.772
R1010 net@1001#32pin@231_polysilicon-1##6 net@1001#32pin@231_polysilicon-1##7 9.772
R1011 net@1001#32pin@231_polysilicon-1##7 net@1001#32pin@231_polysilicon-1##8 9.772
R1012 net@1001#32pin@231_polysilicon-1##8 net@1001#32pin@231_polysilicon-1##9 9.772
R1013 net@1001#32pin@231_polysilicon-1##9 net@1001#32pin@231_polysilicon-1##10 9.772
R1014 net@1001#32pin@231_polysilicon-1##10 net@1001#32pin@231_polysilicon-1##11 9.772
R1015 net@1001#32pin@231_polysilicon-1##11 net@1001#32pin@231_polysilicon-1##12 9.772
R1016 net@1001#32pin@231_polysilicon-1##12 net@1001#32pin@231_polysilicon-1##13 9.772
R1017 net@1001#32pin@231_polysilicon-1##13 net@1001#32pin@231_polysilicon-1##14 9.772
R1018 net@1001#32pin@231_polysilicon-1##14 net@1001#32pin@231_polysilicon-1##15 9.772
R1019 net@1001#32pin@231_polysilicon-1##15 net@1001#32pin@231_polysilicon-1##16 9.772
R1020 net@1001#32pin@231_polysilicon-1##16 net@1001#32pin@231_polysilicon-1##17 9.772
R1021 net@1001#32pin@231_polysilicon-1##17 net@1001#32pin@231_polysilicon-1##18 9.772
R1022 net@1001#32pin@231_polysilicon-1##18 net@1001#32pin@231_polysilicon-1##19 9.772
R1023 net@1001#32pin@231_polysilicon-1##19 net@1001#32pin@231_polysilicon-1##20 9.772
R1024 net@1001#32pin@231_polysilicon-1##20 net@1001#32pin@231_polysilicon-1##21 9.772
R1025 net@1001#32pin@231_polysilicon-1##21 net@1001#35pin@232_polysilicon-1 9.772
R1026 net@1000#8pin@210_polysilicon-1 net@1000#8pin@210_polysilicon-1##0 9.042
R1027 net@1000#8pin@210_polysilicon-1##0 net@1000#8pin@210_polysilicon-1##1 9.042
R1028 net@1000#8pin@210_polysilicon-1##1 net@1000#8pin@210_polysilicon-1##2 9.042
R1029 net@1000#8pin@210_polysilicon-1##2 net@1000#8pin@210_polysilicon-1##3 9.042
R1030 net@1000#8pin@210_polysilicon-1##3 net@1000#8pin@210_polysilicon-1##4 9.042
R1031 net@1000#8pin@210_polysilicon-1##4 net@1000#9pin@211_polysilicon-1 9.042
R1032 net@1001#23pin@199_polysilicon-1 net@1001#23pin@199_polysilicon-1##0 5.425
R1033 net@1001#23pin@199_polysilicon-1##0 net@1001#36pmos@22_poly-right 5.425
R1034 net@1001 net@1001##0 8.267
R1035 net@1001##0 net@1001##1 8.267
R1036 net@1001##1 net@1001#38pin@222_polysilicon-1 8.267
R1037 net@1000#9pin@211_polysilicon-1 net@1000#9pin@211_polysilicon-1##0 9.3
R1038 net@1000#9pin@211_polysilicon-1##0 net@1000#9pin@211_polysilicon-1##1 9.3
R1039 net@1000#9pin@211_polysilicon-1##1 net@1000#9pin@211_polysilicon-1##2 9.3
R1040 net@1000#9pin@211_polysilicon-1##2 net@1000#9pin@211_polysilicon-1##3 9.3
R1041 net@1000#9pin@211_polysilicon-1##3 net@1000#9pin@211_polysilicon-1##4 9.3
R1042 net@1000#9pin@211_polysilicon-1##4 net@1000#9pin@211_polysilicon-1##5 9.3
R1043 net@1000#9pin@211_polysilicon-1##5 net@1000#9pin@211_polysilicon-1##6 9.3
R1044 net@1000#9pin@211_polysilicon-1##6 net@1000#2pin@212_polysilicon-1 9.3
R1045 net@1001 net@1001##0 9.881
R1046 net@1001##0 net@1001##1 9.881
R1047 net@1001##1 net@1001##2 9.881
R1048 net@1001##2 net@1001##3 9.881
R1049 net@1001##3 net@1001##4 9.881
R1050 net@1001##4 net@1001##5 9.881
R1051 net@1001##5 net@1001##6 9.881
R1052 net@1001##6 net@1001#35pin@232_polysilicon-1 9.881
R1053 net@1064#4pin@237_polysilicon-1 net@1064#4pin@237_polysilicon-1##0 9.042
R1054 net@1064#4pin@237_polysilicon-1##0 net@1064#4pin@237_polysilicon-1##1 9.042
R1055 net@1064#4pin@237_polysilicon-1##1 net@1064#4pin@237_polysilicon-1##2 9.042
R1056 net@1064#4pin@237_polysilicon-1##2 net@1064#4pin@237_polysilicon-1##3 9.042
R1057 net@1064#4pin@237_polysilicon-1##3 net@1064#4pin@237_polysilicon-1##4 9.042
R1058 net@1064#4pin@237_polysilicon-1##4 net@1064#5contact@209_metal-1-n-act 9.042
R1059 net@1001 net@1001##0 9.881
R1060 net@1001##0 net@1001##1 9.881
R1061 net@1001##1 net@1001##2 9.881
R1062 net@1001##2 net@1001##3 9.881
R1063 net@1001##3 net@1001##4 9.881
R1064 net@1001##4 net@1001##5 9.881
R1065 net@1001##5 net@1001##6 9.881
R1066 net@1001##6 net@1001#26pin@209_polysilicon-1 9.881
R1067 net@1001#40nmos@25_poly-right net@1001#40nmos@25_poly-right##0 7.233
R1068 net@1001#40nmos@25_poly-right##0 net@1001#40nmos@25_poly-right##1 7.233
R1069 net@1001#40nmos@25_poly-right##1 net@1001#38pin@222_polysilicon-1 7.233
R1070 net@1001#41pmos@24_poly-left net@1001#41pmos@24_poly-left##0 6.2
R1071 net@1001#41pmos@24_poly-left##0 net@1001#42pin@225_polysilicon-1 6.2
R1072 net@1001#42pin@225_polysilicon-1 net@1001#42pin@225_polysilicon-1##0 9.896
R1073 net@1001#42pin@225_polysilicon-1##0 net@1001#42pin@225_polysilicon-1##1 9.896
R1074 net@1001#42pin@225_polysilicon-1##1 net@1001#42pin@225_polysilicon-1##2 9.896
R1075 net@1001#42pin@225_polysilicon-1##2 net@1001#42pin@225_polysilicon-1##3 9.896
R1076 net@1001#42pin@225_polysilicon-1##3 net@1001#42pin@225_polysilicon-1##4 9.896
R1077 net@1001#42pin@225_polysilicon-1##4 net@1001#42pin@225_polysilicon-1##5 9.896
R1078 net@1001#42pin@225_polysilicon-1##5 net@1001#42pin@225_polysilicon-1##6 9.896
R1079 net@1001#42pin@225_polysilicon-1##6 net@1001#42pin@225_polysilicon-1##7 9.896
R1080 net@1001#42pin@225_polysilicon-1##7 net@1001#42pin@225_polysilicon-1##8 9.896
R1081 net@1001#42pin@225_polysilicon-1##8 net@1001#42pin@225_polysilicon-1##9 9.896
R1082 net@1001#42pin@225_polysilicon-1##9 net@1001#42pin@225_polysilicon-1##10 9.896
R1083 net@1001#42pin@225_polysilicon-1##10 net@1001#42pin@225_polysilicon-1##11 9.896
R1084 net@1001#42pin@225_polysilicon-1##11 net@1001#43pin@226_polysilicon-1 9.896
R1085 net@1001#43pin@226_polysilicon-1 net@1001#43pin@226_polysilicon-1##0 9.521
R1086 net@1001#43pin@226_polysilicon-1##0 net@1001#43pin@226_polysilicon-1##1 9.521
R1087 net@1001#43pin@226_polysilicon-1##1 net@1001#43pin@226_polysilicon-1##2 9.521
R1088 net@1001#43pin@226_polysilicon-1##2 net@1001#43pin@226_polysilicon-1##3 9.521
R1089 net@1001#43pin@226_polysilicon-1##3 net@1001#43pin@226_polysilicon-1##4 9.521
R1090 net@1001#43pin@226_polysilicon-1##4 net@1001#43pin@226_polysilicon-1##5 9.521
R1091 net@1001#43pin@226_polysilicon-1##5 net@1001 9.521
R1092 net@1001#38pin@222_polysilicon-1 net@1001#38pin@222_polysilicon-1##0 5.425
R1093 net@1001#38pin@222_polysilicon-1##0 net@1001#44pmos@25_poly-right 5.425
R1094 net@1000#3pin@214_polysilicon-1 net@1000#3pin@214_polysilicon-1##0 9.042
R1095 net@1000#3pin@214_polysilicon-1##0 net@1000#3pin@214_polysilicon-1##1 9.042
R1096 net@1000#3pin@214_polysilicon-1##1 net@1000#3pin@214_polysilicon-1##2 9.042
R1097 net@1000#3pin@214_polysilicon-1##2 net@1000#3pin@214_polysilicon-1##3 9.042
R1098 net@1000#3pin@214_polysilicon-1##3 net@1000#3pin@214_polysilicon-1##4 9.042
R1099 net@1000#3pin@214_polysilicon-1##4 net@1000 9.042
R1100 net@1064#10pin@235_polysilicon-1 net@1064#10pin@235_polysilicon-1##0 8.37
R1101 net@1064#10pin@235_polysilicon-1##0 net@1064#10pin@235_polysilicon-1##1 8.37
R1102 net@1064#10pin@235_polysilicon-1##1 net@1064#10pin@235_polysilicon-1##2 8.37
R1103 net@1064#10pin@235_polysilicon-1##2 net@1064#10pin@235_polysilicon-1##3 8.37
R1104 net@1064#10pin@235_polysilicon-1##3 net@1064#4pin@237_polysilicon-1 8.37
R1105 net@1063#6nmos@30_poly-right net@1063#6nmos@30_poly-right##0 6.2
R1106 net@1063#6nmos@30_poly-right##0 net@1063#2pin@289_polysilicon-1 6.2
R1107 S2#29contact@299_metal-1-polysilicon-1 S2#29contact@299_metal-1-polysilicon-1##0 9.881
R1108 S2#29contact@299_metal-1-polysilicon-1##0 S2#29contact@299_metal-1-polysilicon-1##1 9.881
R1109 S2#29contact@299_metal-1-polysilicon-1##1 S2#29contact@299_metal-1-polysilicon-1##2 9.881
R1110 S2#29contact@299_metal-1-polysilicon-1##2 S2#29contact@299_metal-1-polysilicon-1##3 9.881
R1111 S2#29contact@299_metal-1-polysilicon-1##3 S2#29contact@299_metal-1-polysilicon-1##4 9.881
R1112 S2#29contact@299_metal-1-polysilicon-1##4 S2#29contact@299_metal-1-polysilicon-1##5 9.881
R1113 S2#29contact@299_metal-1-polysilicon-1##5 S2#29contact@299_metal-1-polysilicon-1##6 9.881
R1114 S2#29contact@299_metal-1-polysilicon-1##6 S2#28pin@329_polysilicon-1 9.881
R1115 S2#29contact@299_metal-1-polysilicon-1 S2#29contact@299_metal-1-polysilicon-1##0 9.881
R1116 S2#29contact@299_metal-1-polysilicon-1##0 S2#29contact@299_metal-1-polysilicon-1##1 9.881
R1117 S2#29contact@299_metal-1-polysilicon-1##1 S2#29contact@299_metal-1-polysilicon-1##2 9.881
R1118 S2#29contact@299_metal-1-polysilicon-1##2 S2#29contact@299_metal-1-polysilicon-1##3 9.881
R1119 S2#29contact@299_metal-1-polysilicon-1##3 S2#29contact@299_metal-1-polysilicon-1##4 9.881
R1120 S2#29contact@299_metal-1-polysilicon-1##4 S2#29contact@299_metal-1-polysilicon-1##5 9.881
R1121 S2#29contact@299_metal-1-polysilicon-1##5 S2#29contact@299_metal-1-polysilicon-1##6 9.881
R1122 S2#29contact@299_metal-1-polysilicon-1##6 S2#44pin@254_polysilicon-1 9.881
R1123 net@1001#47nmos@32_poly-left net@1001#47nmos@32_poly-left##0 6.975
R1124 net@1001#47nmos@32_poly-left##0 net@1001#48pin@283_polysilicon-1 6.975
R1125 net@1001#48pin@283_polysilicon-1 net@1001#48pin@283_polysilicon-1##0 9.772
R1126 net@1001#48pin@283_polysilicon-1##0 net@1001#48pin@283_polysilicon-1##1 9.772
R1127 net@1001#48pin@283_polysilicon-1##1 net@1001#48pin@283_polysilicon-1##2 9.772
R1128 net@1001#48pin@283_polysilicon-1##2 net@1001#48pin@283_polysilicon-1##3 9.772
R1129 net@1001#48pin@283_polysilicon-1##3 net@1001#48pin@283_polysilicon-1##4 9.772
R1130 net@1001#48pin@283_polysilicon-1##4 net@1001#48pin@283_polysilicon-1##5 9.772
R1131 net@1001#48pin@283_polysilicon-1##5 net@1001#48pin@283_polysilicon-1##6 9.772
R1132 net@1001#48pin@283_polysilicon-1##6 net@1001#48pin@283_polysilicon-1##7 9.772
R1133 net@1001#48pin@283_polysilicon-1##7 net@1001#48pin@283_polysilicon-1##8 9.772
R1134 net@1001#48pin@283_polysilicon-1##8 net@1001#48pin@283_polysilicon-1##9 9.772
R1135 net@1001#48pin@283_polysilicon-1##9 net@1001#48pin@283_polysilicon-1##10 9.772
R1136 net@1001#48pin@283_polysilicon-1##10 net@1001#48pin@283_polysilicon-1##11 9.772
R1137 net@1001#48pin@283_polysilicon-1##11 net@1001#48pin@283_polysilicon-1##12 9.772
R1138 net@1001#48pin@283_polysilicon-1##12 net@1001#48pin@283_polysilicon-1##13 9.772
R1139 net@1001#48pin@283_polysilicon-1##13 net@1001#48pin@283_polysilicon-1##14 9.772
R1140 net@1001#48pin@283_polysilicon-1##14 net@1001#48pin@283_polysilicon-1##15 9.772
R1141 net@1001#48pin@283_polysilicon-1##15 net@1001#48pin@283_polysilicon-1##16 9.772
R1142 net@1001#48pin@283_polysilicon-1##16 net@1001#48pin@283_polysilicon-1##17 9.772
R1143 net@1001#48pin@283_polysilicon-1##17 net@1001#48pin@283_polysilicon-1##18 9.772
R1144 net@1001#48pin@283_polysilicon-1##18 net@1001#48pin@283_polysilicon-1##19 9.772
R1145 net@1001#48pin@283_polysilicon-1##19 net@1001#48pin@283_polysilicon-1##20 9.772
R1146 net@1001#48pin@283_polysilicon-1##20 net@1001#48pin@283_polysilicon-1##21 9.772
R1147 net@1001#48pin@283_polysilicon-1##21 net@1001#49pin@284_polysilicon-1 9.772
R1148 net@1001 net@1001##0 8.267
R1149 net@1001##0 net@1001##1 8.267
R1150 net@1001##1 net@1001#14pin@274_polysilicon-1 8.267
R1151 net@1063#7pmos@32_poly-left net@1063#8pin@285_polysilicon-1 7.75
R1152 net@1063#8pin@285_polysilicon-1 net@1063#8pin@285_polysilicon-1##0 9.042
R1153 net@1063#8pin@285_polysilicon-1##0 net@1063#8pin@285_polysilicon-1##1 9.042
R1154 net@1063#8pin@285_polysilicon-1##1 net@1063#8pin@285_polysilicon-1##2 9.042
R1155 net@1063#8pin@285_polysilicon-1##2 net@1063#8pin@285_polysilicon-1##3 9.042
R1156 net@1063#8pin@285_polysilicon-1##3 net@1063#8pin@285_polysilicon-1##4 9.042
R1157 net@1063#8pin@285_polysilicon-1##4 net@1063#9pin@286_polysilicon-1 9.042
R1158 net@1063#9pin@286_polysilicon-1 net@1063#9pin@286_polysilicon-1##0 9.3
R1159 net@1063#9pin@286_polysilicon-1##0 net@1063#9pin@286_polysilicon-1##1 9.3
R1160 net@1063#9pin@286_polysilicon-1##1 net@1063#9pin@286_polysilicon-1##2 9.3
R1161 net@1063#9pin@286_polysilicon-1##2 net@1063#9pin@286_polysilicon-1##3 9.3
R1162 net@1063#9pin@286_polysilicon-1##3 net@1063#9pin@286_polysilicon-1##4 9.3
R1163 net@1063#9pin@286_polysilicon-1##4 net@1063#9pin@286_polysilicon-1##5 9.3
R1164 net@1063#9pin@286_polysilicon-1##5 net@1063#9pin@286_polysilicon-1##6 9.3
R1165 net@1063#9pin@286_polysilicon-1##6 net@1063#3pin@287_polysilicon-1 9.3
R1166 net@1028#8pmos@35_poly-left net@1028 7.75
R1167 net@1082#6pin@259_polysilicon-1 net@1082#6pin@259_polysilicon-1##0 9.042
R1168 net@1082#6pin@259_polysilicon-1##0 net@1082#6pin@259_polysilicon-1##1 9.042
R1169 net@1082#6pin@259_polysilicon-1##1 net@1082#6pin@259_polysilicon-1##2 9.042
R1170 net@1082#6pin@259_polysilicon-1##2 net@1082#6pin@259_polysilicon-1##3 9.042
R1171 net@1082#6pin@259_polysilicon-1##3 net@1082#6pin@259_polysilicon-1##4 9.042
R1172 net@1082#6pin@259_polysilicon-1##4 net@1082 9.042
R1173 net@1001 net@1001##0 9.881
R1174 net@1001##0 net@1001##1 9.881
R1175 net@1001##1 net@1001##2 9.881
R1176 net@1001##2 net@1001##3 9.881
R1177 net@1001##3 net@1001##4 9.881
R1178 net@1001##4 net@1001##5 9.881
R1179 net@1001##5 net@1001##6 9.881
R1180 net@1001##6 net@1001#12pin@307_polysilicon-1 9.881
R1181 net@1028#3pin@312_polysilicon-1 net@1028#3pin@312_polysilicon-1##0 9.042
R1182 net@1028#3pin@312_polysilicon-1##0 net@1028#3pin@312_polysilicon-1##1 9.042
R1183 net@1028#3pin@312_polysilicon-1##1 net@1028#3pin@312_polysilicon-1##2 9.042
R1184 net@1028#3pin@312_polysilicon-1##2 net@1028#3pin@312_polysilicon-1##3 9.042
R1185 net@1028#3pin@312_polysilicon-1##3 net@1028#3pin@312_polysilicon-1##4 9.042
R1186 net@1028#3pin@312_polysilicon-1##4 net@1028#4pmos@34_diff-top 9.042
R1187 net@1001 net@1001##0 9.881
R1188 net@1001##0 net@1001##1 9.881
R1189 net@1001##1 net@1001##2 9.881
R1190 net@1001##2 net@1001##3 9.881
R1191 net@1001##3 net@1001##4 9.881
R1192 net@1001##4 net@1001##5 9.881
R1193 net@1001##5 net@1001##6 9.881
R1194 net@1001##6 net@1001#49pin@284_polysilicon-1 9.881
R1195 net@1006#1pin@334_polysilicon-1 net@1006#1pin@334_polysilicon-1##0 9.042
R1196 net@1006#1pin@334_polysilicon-1##0 net@1006#1pin@334_polysilicon-1##1 9.042
R1197 net@1006#1pin@334_polysilicon-1##1 net@1006#1pin@334_polysilicon-1##2 9.042
R1198 net@1006#1pin@334_polysilicon-1##2 net@1006#1pin@334_polysilicon-1##3 9.042
R1199 net@1006#1pin@334_polysilicon-1##3 net@1006#1pin@334_polysilicon-1##4 9.042
R1200 net@1006#1pin@334_polysilicon-1##4 net@1006#6contact@296_metal-1-n-act 9.042
R1201 net@1001#51nmos@34_poly-right net@1001#51nmos@34_poly-right##0 7.233
R1202 net@1001#51nmos@34_poly-right##0 net@1001#51nmos@34_poly-right##1 7.233
R1203 net@1001#51nmos@34_poly-right##1 net@1001#16pin@297_polysilicon-1 7.233
R1204 net@1001#52pmos@33_poly-left net@1001#52pmos@33_poly-left##0 6.2
R1205 net@1001#52pmos@33_poly-left##0 net@1001#53pin@300_polysilicon-1 6.2
R1206 net@1001#53pin@300_polysilicon-1 net@1001#53pin@300_polysilicon-1##0 9.896
R1207 net@1001#53pin@300_polysilicon-1##0 net@1001#53pin@300_polysilicon-1##1 9.896
R1208 net@1001#53pin@300_polysilicon-1##1 net@1001#53pin@300_polysilicon-1##2 9.896
R1209 net@1001#53pin@300_polysilicon-1##2 net@1001#53pin@300_polysilicon-1##3 9.896
R1210 net@1001#53pin@300_polysilicon-1##3 net@1001#53pin@300_polysilicon-1##4 9.896
R1211 net@1001#53pin@300_polysilicon-1##4 net@1001#53pin@300_polysilicon-1##5 9.896
R1212 net@1001#53pin@300_polysilicon-1##5 net@1001#53pin@300_polysilicon-1##6 9.896
R1213 net@1001#53pin@300_polysilicon-1##6 net@1001#53pin@300_polysilicon-1##7 9.896
R1214 net@1001#53pin@300_polysilicon-1##7 net@1001#53pin@300_polysilicon-1##8 9.896
R1215 net@1001#53pin@300_polysilicon-1##8 net@1001#53pin@300_polysilicon-1##9 9.896
R1216 net@1001#53pin@300_polysilicon-1##9 net@1001#53pin@300_polysilicon-1##10 9.896
R1217 net@1001#53pin@300_polysilicon-1##10 net@1001#53pin@300_polysilicon-1##11 9.896
R1218 net@1001#53pin@300_polysilicon-1##11 net@1001#54pin@301_polysilicon-1 9.896
R1219 net@1001#54pin@301_polysilicon-1 net@1001#54pin@301_polysilicon-1##0 9.521
R1220 net@1001#54pin@301_polysilicon-1##0 net@1001#54pin@301_polysilicon-1##1 9.521
R1221 net@1001#54pin@301_polysilicon-1##1 net@1001#54pin@301_polysilicon-1##2 9.521
R1222 net@1001#54pin@301_polysilicon-1##2 net@1001#54pin@301_polysilicon-1##3 9.521
R1223 net@1001#54pin@301_polysilicon-1##3 net@1001#54pin@301_polysilicon-1##4 9.521
R1224 net@1001#54pin@301_polysilicon-1##4 net@1001#54pin@301_polysilicon-1##5 9.521
R1225 net@1001#54pin@301_polysilicon-1##5 net@1001 9.521
R1226 net@1064#1pin@234_polysilicon-1 net@1064#1pin@234_polysilicon-1##0 9.3
R1227 net@1064#1pin@234_polysilicon-1##0 net@1064#1pin@234_polysilicon-1##1 9.3
R1228 net@1064#1pin@234_polysilicon-1##1 net@1064#1pin@234_polysilicon-1##2 9.3
R1229 net@1064#1pin@234_polysilicon-1##2 net@1064#1pin@234_polysilicon-1##3 9.3
R1230 net@1064#1pin@234_polysilicon-1##3 net@1064#1pin@234_polysilicon-1##4 9.3
R1231 net@1064#1pin@234_polysilicon-1##4 net@1064#1pin@234_polysilicon-1##5 9.3
R1232 net@1064#1pin@234_polysilicon-1##5 net@1064#1pin@234_polysilicon-1##6 9.3
R1233 net@1064#1pin@234_polysilicon-1##6 net@1064#10pin@235_polysilicon-1 9.3
R1234 S2#46nmos@37_poly-right S2#46nmos@37_poly-right##0 7.233
R1235 S2#46nmos@37_poly-right##0 S2#46nmos@37_poly-right##1 7.233
R1236 S2#46nmos@37_poly-right##1 S2#30pin@320_polysilicon-1 7.233
R1237 S2#47nmos@28_poly-right S2#47nmos@28_poly-right##0 7.233
R1238 S2#47nmos@28_poly-right##0 S2#47nmos@28_poly-right##1 7.233
R1239 S2#47nmos@28_poly-right##1 S2#35pin@245_polysilicon-1 7.233
R1240 S2#48pmos@36_poly-left S2#48pmos@36_poly-left##0 6.2
R1241 S2#48pmos@36_poly-left##0 S2#49pin@323_polysilicon-1 6.2
R1242 S2#49pin@323_polysilicon-1 S2#49pin@323_polysilicon-1##0 9.896
R1243 S2#49pin@323_polysilicon-1##0 S2#49pin@323_polysilicon-1##1 9.896
R1244 S2#49pin@323_polysilicon-1##1 S2#49pin@323_polysilicon-1##2 9.896
R1245 S2#49pin@323_polysilicon-1##2 S2#49pin@323_polysilicon-1##3 9.896
R1246 S2#49pin@323_polysilicon-1##3 S2#49pin@323_polysilicon-1##4 9.896
R1247 S2#49pin@323_polysilicon-1##4 S2#49pin@323_polysilicon-1##5 9.896
R1248 S2#49pin@323_polysilicon-1##5 S2#49pin@323_polysilicon-1##6 9.896
R1249 S2#49pin@323_polysilicon-1##6 S2#49pin@323_polysilicon-1##7 9.896
R1250 S2#49pin@323_polysilicon-1##7 S2#49pin@323_polysilicon-1##8 9.896
R1251 S2#49pin@323_polysilicon-1##8 S2#49pin@323_polysilicon-1##9 9.896
R1252 S2#49pin@323_polysilicon-1##9 S2#49pin@323_polysilicon-1##10 9.896
R1253 S2#49pin@323_polysilicon-1##10 S2#49pin@323_polysilicon-1##11 9.896
R1254 S2#49pin@323_polysilicon-1##11 S2#50pin@324_polysilicon-1 9.896
R1255 S2#50pin@324_polysilicon-1 S2#50pin@324_polysilicon-1##0 9.521
R1256 S2#50pin@324_polysilicon-1##0 S2#50pin@324_polysilicon-1##1 9.521
R1257 S2#50pin@324_polysilicon-1##1 S2#50pin@324_polysilicon-1##2 9.521
R1258 S2#50pin@324_polysilicon-1##2 S2#50pin@324_polysilicon-1##3 9.521
R1259 S2#50pin@324_polysilicon-1##3 S2#50pin@324_polysilicon-1##4 9.521
R1260 S2#50pin@324_polysilicon-1##4 S2#50pin@324_polysilicon-1##5 9.521
R1261 S2#50pin@324_polysilicon-1##5 S2#29contact@299_metal-1-polysilicon-1 9.521
R1262 S2#30pin@320_polysilicon-1 S2#30pin@320_polysilicon-1##0 5.425
R1263 S2#30pin@320_polysilicon-1##0 S2#51pmos@37_poly-right 5.425
R1264 net@1028#10nmos@33_poly-right net@1028#10nmos@33_poly-right##0 6.2
R1265 net@1028#10nmos@33_poly-right##0 net@1028#3pin@312_polysilicon-1 6.2
R1266 net@1006#5pin@332_polysilicon-1 net@1006#5pin@332_polysilicon-1##0 8.37
R1267 net@1006#5pin@332_polysilicon-1##0 net@1006#5pin@332_polysilicon-1##1 8.37
R1268 net@1006#5pin@332_polysilicon-1##1 net@1006#5pin@332_polysilicon-1##2 8.37
R1269 net@1006#5pin@332_polysilicon-1##2 net@1006#5pin@332_polysilicon-1##3 8.37
R1270 net@1006#5pin@332_polysilicon-1##3 net@1006#1pin@334_polysilicon-1 8.37
R1271 S2#52pmos@27_poly-left S2#52pmos@27_poly-left##0 6.2
R1272 S2#52pmos@27_poly-left##0 S2#31pin@248_polysilicon-1 6.2
R1273 net@1001#56nmos@31_poly-right net@1001#56nmos@31_poly-right##0 7.233
R1274 net@1001#56nmos@31_poly-right##0 net@1001#56nmos@31_poly-right##1 7.233
R1275 net@1001#56nmos@31_poly-right##1 net@1001#14pin@274_polysilicon-1 7.233
R1276 net@1511#4pin@416_polysilicon-1 net@1511#4pin@416_polysilicon-1##0 8.37
R1277 net@1511#4pin@416_polysilicon-1##0 net@1511#4pin@416_polysilicon-1##1 8.37
R1278 net@1511#4pin@416_polysilicon-1##1 net@1511#4pin@416_polysilicon-1##2 8.37
R1279 net@1511#4pin@416_polysilicon-1##2 net@1511#4pin@416_polysilicon-1##3 8.37
R1280 net@1511#4pin@416_polysilicon-1##3 net@1511#5pin@418_polysilicon-1 8.37
R1281 net@1511#6nmos@42_poly-right net@1511#6nmos@42_poly-right##0 6.2
R1282 net@1511#6nmos@42_poly-right##0 net@1511#5pin@418_polysilicon-1 6.2
R1283 S3 S3##0 9.881
R1284 S3##0 S3##1 9.881
R1285 S3##1 S3##2 9.881
R1286 S3##2 S3##3 9.881
R1287 S3##3 S3##4 9.881
R1288 S3##4 S3##5 9.881
R1289 S3##5 S3##6 9.881
R1290 S3##6 S3#1pin@413_polysilicon-1 9.881
R1291 net@1511#5pin@418_polysilicon-1 net@1511#5pin@418_polysilicon-1##0 9.042
R1292 net@1511#5pin@418_polysilicon-1##0 net@1511#5pin@418_polysilicon-1##1 9.042
R1293 net@1511#5pin@418_polysilicon-1##1 net@1511#5pin@418_polysilicon-1##2 9.042
R1294 net@1511#5pin@418_polysilicon-1##2 net@1511#5pin@418_polysilicon-1##3 9.042
R1295 net@1511#5pin@418_polysilicon-1##3 net@1511#5pin@418_polysilicon-1##4 9.042
R1296 net@1511#5pin@418_polysilicon-1##4 net@1511 9.042
R1297 S3#2nmos@43_poly-right S3#2nmos@43_poly-right##0 7.233
R1298 S3#2nmos@43_poly-right##0 S3#2nmos@43_poly-right##1 7.233
R1299 S3#2nmos@43_poly-right##1 S3#3pin@403_polysilicon-1 7.233
R1300 S3#4pmos@42_poly-left S3#4pmos@42_poly-left##0 6.2
R1301 S3#4pmos@42_poly-left##0 S3#5pin@406_polysilicon-1 6.2
R1302 S3#5pin@406_polysilicon-1 S3#5pin@406_polysilicon-1##0 9.896
R1303 S3#5pin@406_polysilicon-1##0 S3#5pin@406_polysilicon-1##1 9.896
R1304 S3#5pin@406_polysilicon-1##1 S3#5pin@406_polysilicon-1##2 9.896
R1305 S3#5pin@406_polysilicon-1##2 S3#5pin@406_polysilicon-1##3 9.896
R1306 S3#5pin@406_polysilicon-1##3 S3#5pin@406_polysilicon-1##4 9.896
R1307 S3#5pin@406_polysilicon-1##4 S3#5pin@406_polysilicon-1##5 9.896
R1308 S3#5pin@406_polysilicon-1##5 S3#5pin@406_polysilicon-1##6 9.896
R1309 S3#5pin@406_polysilicon-1##6 S3#5pin@406_polysilicon-1##7 9.896
R1310 S3#5pin@406_polysilicon-1##7 S3#5pin@406_polysilicon-1##8 9.896
R1311 S3#5pin@406_polysilicon-1##8 S3#5pin@406_polysilicon-1##9 9.896
R1312 S3#5pin@406_polysilicon-1##9 S3#5pin@406_polysilicon-1##10 9.896
R1313 S3#5pin@406_polysilicon-1##10 S3#5pin@406_polysilicon-1##11 9.896
R1314 S3#5pin@406_polysilicon-1##11 S3#6pin@407_polysilicon-1 9.896
R1315 S3#6pin@407_polysilicon-1 S3#6pin@407_polysilicon-1##0 9.521
R1316 S3#6pin@407_polysilicon-1##0 S3#6pin@407_polysilicon-1##1 9.521
R1317 S3#6pin@407_polysilicon-1##1 S3#6pin@407_polysilicon-1##2 9.521
R1318 S3#6pin@407_polysilicon-1##2 S3#6pin@407_polysilicon-1##3 9.521
R1319 S3#6pin@407_polysilicon-1##3 S3#6pin@407_polysilicon-1##4 9.521
R1320 S3#6pin@407_polysilicon-1##4 S3#6pin@407_polysilicon-1##5 9.521
R1321 S3#6pin@407_polysilicon-1##5 S3 9.521
R1322 S3#3pin@403_polysilicon-1 S3#3pin@403_polysilicon-1##0 5.425
R1323 S3#3pin@403_polysilicon-1##0 S3#8pmos@43_poly-right 5.425
R1324 S3#10nmos@44_poly-left S3#10nmos@44_poly-left##0 6.975
R1325 S3#10nmos@44_poly-left##0 S3#11pin@412_polysilicon-1 6.975
R1326 S3#11pin@412_polysilicon-1 S3#11pin@412_polysilicon-1##0 9.772
R1327 S3#11pin@412_polysilicon-1##0 S3#11pin@412_polysilicon-1##1 9.772
R1328 S3#11pin@412_polysilicon-1##1 S3#11pin@412_polysilicon-1##2 9.772
R1329 S3#11pin@412_polysilicon-1##2 S3#11pin@412_polysilicon-1##3 9.772
R1330 S3#11pin@412_polysilicon-1##3 S3#11pin@412_polysilicon-1##4 9.772
R1331 S3#11pin@412_polysilicon-1##4 S3#11pin@412_polysilicon-1##5 9.772
R1332 S3#11pin@412_polysilicon-1##5 S3#11pin@412_polysilicon-1##6 9.772
R1333 S3#11pin@412_polysilicon-1##6 S3#11pin@412_polysilicon-1##7 9.772
R1334 S3#11pin@412_polysilicon-1##7 S3#11pin@412_polysilicon-1##8 9.772
R1335 S3#11pin@412_polysilicon-1##8 S3#11pin@412_polysilicon-1##9 9.772
R1336 S3#11pin@412_polysilicon-1##9 S3#11pin@412_polysilicon-1##10 9.772
R1337 S3#11pin@412_polysilicon-1##10 S3#11pin@412_polysilicon-1##11 9.772
R1338 S3#11pin@412_polysilicon-1##11 S3#11pin@412_polysilicon-1##12 9.772
R1339 S3#11pin@412_polysilicon-1##12 S3#11pin@412_polysilicon-1##13 9.772
R1340 S3#11pin@412_polysilicon-1##13 S3#11pin@412_polysilicon-1##14 9.772
R1341 S3#11pin@412_polysilicon-1##14 S3#11pin@412_polysilicon-1##15 9.772
R1342 S3#11pin@412_polysilicon-1##15 S3#11pin@412_polysilicon-1##16 9.772
R1343 S3#11pin@412_polysilicon-1##16 S3#11pin@412_polysilicon-1##17 9.772
R1344 S3#11pin@412_polysilicon-1##17 S3#11pin@412_polysilicon-1##18 9.772
R1345 S3#11pin@412_polysilicon-1##18 S3#11pin@412_polysilicon-1##19 9.772
R1346 S3#11pin@412_polysilicon-1##19 S3#11pin@412_polysilicon-1##20 9.772
R1347 S3#11pin@412_polysilicon-1##20 S3#11pin@412_polysilicon-1##21 9.772
R1348 S3#11pin@412_polysilicon-1##21 S3#1pin@413_polysilicon-1 9.772
R1349 S3 S3##0 8.267
R1350 S3##0 S3##1 8.267
R1351 S3##1 S3#3pin@403_polysilicon-1 8.267
R1352 net@1511#9pmos@44_poly-left net@1511#10pin@414_polysilicon-1 7.75
R1353 net@1511#10pin@414_polysilicon-1 net@1511#10pin@414_polysilicon-1##0 9.042
R1354 net@1511#10pin@414_polysilicon-1##0 net@1511#10pin@414_polysilicon-1##1 9.042
R1355 net@1511#10pin@414_polysilicon-1##1 net@1511#10pin@414_polysilicon-1##2 9.042
R1356 net@1511#10pin@414_polysilicon-1##2 net@1511#10pin@414_polysilicon-1##3 9.042
R1357 net@1511#10pin@414_polysilicon-1##3 net@1511#10pin@414_polysilicon-1##4 9.042
R1358 net@1511#10pin@414_polysilicon-1##4 net@1511#11pin@415_polysilicon-1 9.042
R1359 net@1511#11pin@415_polysilicon-1 net@1511#11pin@415_polysilicon-1##0 9.3
R1360 net@1511#11pin@415_polysilicon-1##0 net@1511#11pin@415_polysilicon-1##1 9.3
R1361 net@1511#11pin@415_polysilicon-1##1 net@1511#11pin@415_polysilicon-1##2 9.3
R1362 net@1511#11pin@415_polysilicon-1##2 net@1511#11pin@415_polysilicon-1##3 9.3
R1363 net@1511#11pin@415_polysilicon-1##3 net@1511#11pin@415_polysilicon-1##4 9.3
R1364 net@1511#11pin@415_polysilicon-1##4 net@1511#11pin@415_polysilicon-1##5 9.3
R1365 net@1511#11pin@415_polysilicon-1##5 net@1511#11pin@415_polysilicon-1##6 9.3
R1366 net@1511#11pin@415_polysilicon-1##6 net@1511#4pin@416_polysilicon-1 9.3
R1367 S0 S0#31contact@360_metal-1-metal-2 6.669
R1368 S2 S2#29contact@299_metal-1-polysilicon-1 4.394

* Spice Code nodes in cell cell 'MUX_16_1_TG_2_2{lay}'
VDD VDD 0 DC 3.3
VGND GND 0 DC 0
Vin16 S2  0 PULSE  (3.3 0 0 1u 1u 400u 800u)
Vin17 S1  0 PULSE  (3.3 0 0 1u 1u 800u 1600u)
Vin18 S0  0 PULSE  (3.3 0 0 1u 1u 1600u 3200u)
Vin19 S3  0 PULSE  (3.3 0 0 1u 1u 3200u 6400u)
Vin0  I0  0 pulse 0 3.3 0u   1u 1u 100u 6400u
Vin1  I1  0 pulse 0 3.3 400u 1u 1u 100u 6400u
Vin2  I2  0 pulse 0 3.3 800u 1u 1u 100u 6400u
Vin3  I3  0 pulse 0 3.3 1200u 1u 1u 100u 6400u
Vin4  I4  0 pulse 0 3.3 1600u 1u 1u 100u 6400u
Vin5  I5  0 pulse 0 3.3 2000u 1u 1u 100u 6400u
Vin6  I6  0 pulse 0 3.3 2400u 1u 1u 100u 6400u
Vin7  I7  0 pulse 0 3.3 2800u 1u 1u 100u 6400u
Vin8  I8  0 pulse 0 3.3 3200u 1u 1u 100u 6400u
Vin9  I9  0 pulse 0 3.3 3600u 1u 1u 100u 6400u
Vin10 I10 0 pulse 0 3.3 4000u 1u 1u 100u 6400u
Vin11 I11 0 pulse 0 3.3 4400u 1u 1u 100u 6400u
Vin12 I12 0 pulse 0 3.3 4800u 1u 1u 100u 6400u
Vin13 I13 0 pulse 0 3.3 5200u 1u 1u 100u 6400u
Vin14 I14 0 pulse 0 3.3 5600u 1u 1u 100u 6400u
Vin15 I15 0 pulse 0 3.3 6000u 1u 1u 100u 6400u
cload out 0 250fF
.TRAN 0 6400u
.include C:\Electric\C5_models.txt
.END
