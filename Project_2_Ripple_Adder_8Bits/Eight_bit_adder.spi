*** SPICE deck for cell Eight_bit_adder{lay} from library Proj2
*** Created on Wed Mar 18, 2020 20:18:53
*** Last revised on Thu Mar 19, 2020 01:03:47
*** Written on Thu Mar 19, 2020 01:03:49 by Electric VLSI Design System, version 9.07
*** Layout tech: mocmos, foundry MOSIS
*** UC SPICE *** , MIN_RESIST 4.0, MIN_CAPAC 0.1FF
***    P-Active:	areacap=0.9FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    N-Active:	areacap=0.9FF/um^2,	edgecap=0.0FF/um,	res=3.0ohms/sq
***    Polysilicon-1:	areacap=0.1467FF/um^2,	edgecap=0.0608FF/um,	res=6.2ohms/sq
***    Polysilicon-2:	areacap=1.0FF/um^2,	edgecap=0.0FF/um,	res=50.0ohms/sq
***    Transistor-Poly:	areacap=0.09FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    Poly-Cut:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=2.2ohms/sq
***    Active-Cut:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    Metal-1:	areacap=0.1209FF/um^2,	edgecap=0.1104FF/um,	res=0.078ohms/sq
***    Via1:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=1.0ohms/sq
***    Metal-2:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via2:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.9ohms/sq
***    Metal-3:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via3:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-4:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via4:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-5:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via5:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-6:	areacap=0.0423FF/um^2,	edgecap=0.1273FF/um,	res=0.036ohms/sq
***    Hi-Res:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=1.0ohms/sq

*** TOP LEVEL CELL: Eight_bit_adder{lay}
Mnmos@40 net@676#2contact@256_metal-1-polysilicon-1 A0#15nmos@40_poly-right net@560 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@41 net@817 net@562#11nmos@41_poly-right net@676#2contact@256_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@42 gnd B0#14nmos@42_poly-left net@817 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@43 net@560 net@684#9nmos@43_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@44 net@684#2contact@231_metal-1-metal-2 B0#9nmos@44_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@45 net@562#2pin@166_metal-1 A0#14nmos@45_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@46 XOR1_to_NAND1#1contact@309_metal-1-metal-2 net@676#4nmos@46_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@47 net@576#2contact@295_metal-1-polysilicon-1 XOR1_to_NAND1#26nmos@47_poly-right net@566 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@48 net@638 net@564#11nmos@48_poly-right net@576#2contact@295_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@49 gnd Cin#9nmos@49_poly-left net@638 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@50 net@566 net@577#9nmos@50_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@51 net@577#2contact@270_metal-1-metal-2 Cin#5nmos@51_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@52 net@564#2pin@192_metal-1 XOR1_to_NAND1#24nmos@52_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@53 Sum0 net@576#4nmos@53_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@54 net@674 XOR1_to_NAND1#27nmos@54_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@55 NAND1_to_NAND3#4nmos@55_diff-bottom Cin#16nmos@55_poly-right net@674 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@56 net@706 A0#17nmos@56_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@57 NAND2_to_Nand3#4nmos@57_diff-bottom B0#11nmos@57_poly-right net@706 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@58 net@737 NAND2_to_Nand3#11nmos@58_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@59 Cin_to_XOR2___NAND2#1contact@534_metal-1-metal-2 NAND1_to_NAND3#14nmos@59_poly-right net@737 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@60 net@1307#2contact@491_metal-1-polysilicon-1 A1#18nmos@60_poly-right net@1207 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@61 net@1420 net@1209#11nmos@61_poly-right net@1307#2contact@491_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@62 gnd B1#17nmos@62_poly-left net@1420 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@63 net@1207 net@1314#9nmos@63_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@64 net@1314#2contact@466_metal-1-metal-2 B1#12nmos@64_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@65 net@1209#2pin@342_metal-1 A1#17nmos@65_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@66 XOR1_to_NAND2#1contact@544_metal-1-metal-2 net@1307#4nmos@66_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@67 net@1220#2contact@530_metal-1-polysilicon-1 XOR1_to_NAND2#26nmos@67_poly-right net@1212 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@68 net@1271 net@1211#11nmos@68_poly-right net@1220#2contact@530_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@69 gnd Cin_to_XOR2___NAND2#18nmos@69_poly-left net@1271 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@70 net@1212 net@1221#9nmos@70_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@71 net@1221#2contact@505_metal-1-metal-2 Cin_to_XOR2___NAND2#14nmos@71_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@72 net@1211#2pin@367_metal-1 XOR1_to_NAND2#24nmos@72_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@73 Sum1 net@1220#4nmos@73_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@74 net@1305 XOR1_to_NAND2#27nmos@74_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@75 NAND1_to_NAND4#4nmos@75_diff-bottom Cin_to_XOR2___NAND2#25nmos@75_poly-right net@1305 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@76 net@1332 A1#20nmos@76_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@77 NAND2_to_Nand4#4nmos@77_diff-bottom B1#14nmos@77_poly-right net@1332 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@78 net@1356 NAND2_to_Nand4#11nmos@78_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@79 Cin_to_XOR2___NAND3#1contact@646_metal-1-metal-2 NAND1_to_NAND4#14nmos@79_poly-right net@1356 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@80 net@1907#2contact@603_metal-1-polysilicon-1 A2#17nmos@80_poly-right net@1807 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@81 net@2020 net@1809#11nmos@81_poly-right net@1907#2contact@603_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@82 gnd B2#16nmos@82_poly-left net@2020 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@83 net@1807 net@1914#9nmos@83_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@84 net@1914#2contact@579_metal-1-metal-2 B2#11nmos@84_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@85 net@1809#2pin@536_metal-1 A2#16nmos@85_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@86 XOR1_to_NAND3#1contact@656_metal-1-metal-2 net@1907#4nmos@86_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@87 net@1820#2contact@642_metal-1-polysilicon-1 XOR1_to_NAND3#26nmos@87_poly-right net@1812 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@88 net@1871 net@1811#11nmos@88_poly-right net@1820#2contact@642_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@89 gnd Cin_to_XOR2___NAND3#18nmos@89_poly-left net@1871 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@90 net@1812 net@1821#9nmos@90_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@91 net@1821#2contact@617_metal-1-metal-2 Cin_to_XOR2___NAND3#14nmos@91_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@92 net@1811#2pin@561_metal-1 XOR1_to_NAND3#24nmos@92_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@93 Sum2 net@1820#4nmos@93_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@94 net@1905 XOR1_to_NAND3#27nmos@94_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@95 NAND1_to_NAND5#4nmos@95_diff-bottom Cin_to_XOR2___NAND3#25nmos@95_poly-right net@1905 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@96 net@1932 A2#19nmos@96_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@97 NAND2_to_Nand5#4nmos@97_diff-bottom B2#13nmos@97_poly-right net@1932 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@98 net@1956 NAND2_to_Nand5#11nmos@98_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@99 Cin_to_XOR2___NAND4#1contact@756_metal-1-metal-2 NAND1_to_NAND5#14nmos@99_poly-right net@1956 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@100 net@2204#2contact@713_metal-1-polysilicon-1 A3#17nmos@100_poly-right net@2104 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@101 net@2317 net@2106#11nmos@101_poly-right net@2204#2contact@713_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@102 gnd B3#16nmos@102_poly-left net@2317 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@103 net@2104 net@2211#9nmos@103_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@104 net@2211#2contact@689_metal-1-metal-2 B3#11nmos@104_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@105 net@2106#2pin@631_metal-1 A3#16nmos@105_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@106 XOR1_to_NAND4#1contact@766_metal-1-metal-2 net@2204#4nmos@106_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@107 net@2117#2contact@752_metal-1-polysilicon-1 XOR1_to_NAND4#26nmos@107_poly-right net@2109 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@108 net@2168 net@2108#11nmos@108_poly-right net@2117#2contact@752_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@109 gnd Cin_to_XOR2___NAND4#18nmos@109_poly-left net@2168 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@110 net@2109 net@2118#9nmos@110_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@111 net@2118#2contact@727_metal-1-metal-2 Cin_to_XOR2___NAND4#14nmos@111_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@112 net@2108#2pin@656_metal-1 XOR1_to_NAND4#24nmos@112_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@113 Sum3 net@2117#4nmos@113_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@114 net@2202 XOR1_to_NAND4#27nmos@114_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@115 NAND1_to_NAND6#4nmos@115_diff-bottom Cin_to_XOR2___NAND4#25nmos@115_poly-right net@2202 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@116 net@2229 A3#19nmos@116_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@117 NAND2_to_Nand6#4nmos@117_diff-bottom B3#13nmos@117_poly-right net@2229 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@118 net@2253 NAND2_to_Nand6#11nmos@118_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@119 Cin_to_XOR2___NAND5#1contact@865_metal-1-metal-2 NAND1_to_NAND6#14nmos@119_poly-right net@2253 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@120 net@2490#2contact@822_metal-1-polysilicon-1 A4#17nmos@120_poly-right net@2390 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@121 net@2603 net@2392#11nmos@121_poly-right net@2490#2contact@822_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@122 gnd B4#16nmos@122_poly-left net@2603 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@123 net@2390 net@2497#9nmos@123_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@124 net@2497#2contact@798_metal-1-metal-2 B4#11nmos@124_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@125 net@2392#2pin@717_metal-1 A4#16nmos@125_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@126 XOR1_to_NAND5#1contact@875_metal-1-metal-2 net@2490#4nmos@126_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@127 net@2403#2contact@861_metal-1-polysilicon-1 XOR1_to_NAND5#26nmos@127_poly-right net@2395 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@128 net@2454 net@2394#11nmos@128_poly-right net@2403#2contact@861_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@129 gnd Cin_to_XOR2___NAND5#18nmos@129_poly-left net@2454 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@130 net@2395 net@2404#9nmos@130_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@131 net@2404#2contact@836_metal-1-metal-2 Cin_to_XOR2___NAND5#14nmos@131_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@132 net@2394#2pin@742_metal-1 XOR1_to_NAND5#24nmos@132_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@133 Sum4 net@2403#4nmos@133_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@134 net@2488 XOR1_to_NAND5#27nmos@134_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@135 NAND1_to_NAND7#4nmos@135_diff-bottom Cin_to_XOR2___NAND5#25nmos@135_poly-right net@2488 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@136 net@2515 A4#19nmos@136_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@137 NAND2_to_Nand7#4nmos@137_diff-bottom B4#13nmos@137_poly-right net@2515 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@138 net@2539 NAND2_to_Nand7#11nmos@138_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@139 Cout#2nmos@139_diff-bottom NAND1_to_NAND7#14nmos@139_poly-right net@2539 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mpmos@40 vdd A0#10pmos@40_poly-left net@800 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@41 net@800 net@562#7pmos@41_poly-left net@676 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@42 net@676 B0#16pmos@42_poly-right net@800 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@43 net@800 net@684#14pmos@43_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@44 vdd B0#15pmos@44_poly-right net@684 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@45 vdd A0#3pmos@45_poly-right net@562#5pmos@45_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@46 vdd net@676#12pmos@46_poly-right XOR1_to_NAND1#22pmos@46_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@47 vdd XOR1_to_NAND1#9pmos@47_poly-left net@621 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@48 net@621 net@564#7pmos@48_poly-left net@576 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@49 net@576 Cin#18pmos@49_poly-right net@621 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@50 net@621 net@577#14pmos@50_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@51 vdd Cin#17pmos@51_poly-right net@577 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@52 vdd XOR1_to_NAND1#4pmos@52_poly-right net@564#5pmos@52_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@53 vdd net@576#12pmos@53_poly-right Sum0#4pmos@53_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@54 vdd XOR1_to_NAND1#16pmos@54_poly-right NAND1_to_NAND3 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@55 NAND1_to_NAND3 Cin#20pmos@55_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@56 vdd A0#9pmos@56_poly-right NAND2_to_Nand3 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@57 NAND2_to_Nand3 B0#18pmos@57_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@58 vdd NAND2_to_Nand3#10pmos@58_poly-right Cin_to_XOR2___NAND2#1contact@534_metal-1-metal-2 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@59 Cin_to_XOR2___NAND2#1contact@534_metal-1-metal-2 NAND1_to_NAND3#11pmos@59_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@60 vdd A1#13pmos@60_poly-left net@1404 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@61 net@1404 net@1209#7pmos@61_poly-left net@1307 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@62 net@1307 B1#19pmos@62_poly-right net@1404 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@63 net@1404 net@1314#14pmos@63_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@64 vdd B1#18pmos@64_poly-right net@1314 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@65 vdd A1#5pmos@65_poly-right net@1209#5pmos@65_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@66 vdd net@1307#12pmos@66_poly-right XOR1_to_NAND2#22pmos@66_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@67 vdd XOR1_to_NAND2#9pmos@67_poly-left net@1255 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@68 net@1255 net@1211#7pmos@68_poly-left net@1220 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@69 net@1220 Cin_to_XOR2___NAND2#27pmos@69_poly-right net@1255 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@70 net@1255 net@1221#14pmos@70_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@71 vdd Cin_to_XOR2___NAND2#26pmos@71_poly-right net@1221 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@72 vdd XOR1_to_NAND2#4pmos@72_poly-right net@1211#5pmos@72_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@73 vdd net@1220#12pmos@73_poly-right Sum1#4pmos@73_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@74 vdd XOR1_to_NAND2#16pmos@74_poly-right NAND1_to_NAND4 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@75 NAND1_to_NAND4 Cin_to_XOR2___NAND2#29pmos@75_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@76 vdd A1#12pmos@76_poly-right NAND2_to_Nand4 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@77 NAND2_to_Nand4 B1#21pmos@77_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@78 vdd NAND2_to_Nand4#10pmos@78_poly-right Cin_to_XOR2___NAND3#1contact@646_metal-1-metal-2 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@79 Cin_to_XOR2___NAND3#1contact@646_metal-1-metal-2 NAND1_to_NAND4#11pmos@79_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@80 vdd A2#12pmos@80_poly-left net@2004 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@81 net@2004 net@1809#7pmos@81_poly-left net@1907 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@82 net@1907 B2#18pmos@82_poly-right net@2004 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@83 net@2004 net@1914#14pmos@83_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@84 vdd B2#17pmos@84_poly-right net@1914 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@85 vdd A2#4pmos@85_poly-right net@1809#5pmos@85_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@86 vdd net@1907#12pmos@86_poly-right XOR1_to_NAND3#22pmos@86_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@87 vdd XOR1_to_NAND3#9pmos@87_poly-left net@1855 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@88 net@1855 net@1811#7pmos@88_poly-left net@1820 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@89 net@1820 Cin_to_XOR2___NAND3#27pmos@89_poly-right net@1855 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@90 net@1855 net@1821#14pmos@90_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@91 vdd Cin_to_XOR2___NAND3#26pmos@91_poly-right net@1821 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@92 vdd XOR1_to_NAND3#4pmos@92_poly-right net@1811#5pmos@92_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@93 vdd net@1820#12pmos@93_poly-right Sum2#4pmos@93_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@94 vdd XOR1_to_NAND3#16pmos@94_poly-right NAND1_to_NAND5 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@95 NAND1_to_NAND5 Cin_to_XOR2___NAND3#29pmos@95_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@96 vdd A2#11pmos@96_poly-right NAND2_to_Nand5 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@97 NAND2_to_Nand5 B2#20pmos@97_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@98 vdd NAND2_to_Nand5#10pmos@98_poly-right Cin_to_XOR2___NAND4#1contact@756_metal-1-metal-2 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@99 Cin_to_XOR2___NAND4#1contact@756_metal-1-metal-2 NAND1_to_NAND5#11pmos@99_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@100 vdd A3#12pmos@100_poly-left net@2301 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@101 net@2301 net@2106#7pmos@101_poly-left net@2204 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@102 net@2204 B3#18pmos@102_poly-right net@2301 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@103 net@2301 net@2211#14pmos@103_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@104 vdd B3#17pmos@104_poly-right net@2211 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@105 vdd A3#4pmos@105_poly-right net@2106#5pmos@105_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@106 vdd net@2204#12pmos@106_poly-right XOR1_to_NAND4#22pmos@106_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@107 vdd XOR1_to_NAND4#9pmos@107_poly-left net@2152 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@108 net@2152 net@2108#7pmos@108_poly-left net@2117 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@109 net@2117 Cin_to_XOR2___NAND4#27pmos@109_poly-right net@2152 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@110 net@2152 net@2118#14pmos@110_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@111 vdd Cin_to_XOR2___NAND4#26pmos@111_poly-right net@2118 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@112 vdd XOR1_to_NAND4#4pmos@112_poly-right net@2108#5pmos@112_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@113 vdd net@2117#12pmos@113_poly-right Sum3#4pmos@113_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@114 vdd XOR1_to_NAND4#16pmos@114_poly-right NAND1_to_NAND6 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@115 NAND1_to_NAND6 Cin_to_XOR2___NAND4#29pmos@115_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@116 vdd A3#11pmos@116_poly-right NAND2_to_Nand6 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@117 NAND2_to_Nand6 B3#20pmos@117_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@118 vdd NAND2_to_Nand6#10pmos@118_poly-right Cin_to_XOR2___NAND5#1contact@865_metal-1-metal-2 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@119 Cin_to_XOR2___NAND5#1contact@865_metal-1-metal-2 NAND1_to_NAND6#11pmos@119_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@120 vdd A4#12pmos@120_poly-left net@2587 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@121 net@2587 net@2392#7pmos@121_poly-left net@2490 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@122 net@2490 B4#18pmos@122_poly-right net@2587 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@123 net@2587 net@2497#14pmos@123_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@124 vdd B4#17pmos@124_poly-right net@2497 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@125 vdd A4#4pmos@125_poly-right net@2392#5pmos@125_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@126 vdd net@2490#12pmos@126_poly-right XOR1_to_NAND5#22pmos@126_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@127 vdd XOR1_to_NAND5#9pmos@127_poly-left net@2438 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@128 net@2438 net@2394#7pmos@128_poly-left net@2403 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@129 net@2403 Cin_to_XOR2___NAND5#27pmos@129_poly-right net@2438 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@130 net@2438 net@2404#14pmos@130_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@131 vdd Cin_to_XOR2___NAND5#26pmos@131_poly-right net@2404 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@132 vdd XOR1_to_NAND5#4pmos@132_poly-right net@2394#5pmos@132_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@133 vdd net@2403#12pmos@133_poly-right Sum4#4pmos@133_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@134 vdd XOR1_to_NAND5#16pmos@134_poly-right NAND1_to_NAND7 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@135 NAND1_to_NAND7 Cin_to_XOR2___NAND5#29pmos@135_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@136 vdd A4#11pmos@136_poly-right NAND2_to_Nand7 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@137 NAND2_to_Nand7 B4#20pmos@137_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@138 vdd NAND2_to_Nand7#10pmos@138_poly-right Cout vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@139 Cout NAND1_to_NAND7#11pmos@139_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
** Extracted Parasitic Capacitors ***
C0 net@560 0 3.833fF
C1 net@676 0 4.502fF
C2 net@800 0 1.741fF
C3 net@676#2contact@256_metal-1-polysilicon-1 0 7.287fF
C4 net@684#2contact@231_metal-1-metal-2 0 8.905fF
C5 net@684 0 4.589fF
C6 B0 0 10.065fF
C7 A0 0 11.542fF
C8 net@562#2pin@166_metal-1 0 5.84fF
C9 net@562#5pmos@45_diff-top 0 4.602fF
C10 XOR1_to_NAND1#1contact@309_metal-1-metal-2 0 22.356fF
C11 XOR1_to_NAND1#22pmos@46_diff-top 0 4.651fF
C12 net@566 0 3.833fF
C13 net@576 0 4.452fF
C14 net@621 0 1.741fF
C15 net@576#2contact@295_metal-1-polysilicon-1 0 7.187fF
C16 net@577#2contact@270_metal-1-metal-2 0 8.905fF
C17 net@577 0 4.589fF
C18 Cin#0pin@206_metal-2 0 11.38fF
C19 net@564#2pin@192_metal-1 0 5.84fF
C20 net@564#5pmos@52_diff-top 0 4.602fF
C21 Sum0 0 12.444fF
C22 Sum0#4pmos@53_diff-top 0 4.614fF
C23 Cin 0 3.389fF
C24 NAND1_to_NAND3 0 9.146fF
C25 NAND1_to_NAND3#4nmos@55_diff-bottom 0 4.614fF
C26 XOR1_to_NAND1 0 3.919fF
C27 Cin#11contact@308_metal-1-metal-2 0 4.06fF
C28 NAND2_to_Nand3 0 6.989fF
C29 NAND2_to_Nand3#4nmos@57_diff-bottom 0 4.229fF
C30 A0#0contact@317_metal-1-metal-2 0 7.684fF
C31 B0#0contact@318_metal-1-metal-2 0 5.6fF
C32 Cin_to_XOR2___NAND2#1contact@534_metal-1-metal-2 0 14.582fF
C33 B1 0 5.383fF
C34 B2 0 16.009fF
C35 B3 0 15.542fF
C36 B4 0 16.971fF
C37 B5 0 5.543fF
C38 B6 0 5.543fF
C39 B7 0 5.543fF
C40 A6 0 5.543fF
C41 A5 0 5.543fF
C42 A4 0 16.995fF
C43 A3 0 15.571fF
C44 A2 0 16.113fF
C45 A1 0 12.184fF
C46 net@1207 0 3.833fF
C47 net@1307 0 4.502fF
C48 net@1404 0 1.741fF
C49 net@1307#2contact@491_metal-1-polysilicon-1 0 7.287fF
C50 net@1314#2contact@466_metal-1-metal-2 0 8.905fF
C51 net@1314 0 4.589fF
C52 B1#0pin@508_metal-2 0 18.272fF
C53 A1#1pin@517_metal-2 0 18.539fF
C54 net@1209#2pin@342_metal-1 0 5.84fF
C55 net@1209#5pmos@65_diff-top 0 4.602fF
C56 XOR1_to_NAND2#1contact@544_metal-1-metal-2 0 22.356fF
C57 XOR1_to_NAND2#22pmos@66_diff-top 0 4.651fF
C58 net@1212 0 3.833fF
C59 net@1220 0 4.452fF
C60 net@1255 0 1.741fF
C61 net@1220#2contact@530_metal-1-polysilicon-1 0 7.187fF
C62 net@1221#2contact@505_metal-1-metal-2 0 8.905fF
C63 net@1221 0 4.589fF
C64 Cin_to_XOR2___NAND2 0 11.38fF
C65 net@1211#2pin@367_metal-1 0 5.84fF
C66 net@1211#5pmos@72_diff-top 0 4.602fF
C67 Sum1 0 12.047fF
C68 Sum1#4pmos@73_diff-top 0 4.614fF
C69 NAND1_to_NAND4 0 9.146fF
C70 NAND1_to_NAND4#4nmos@75_diff-bottom 0 4.614fF
C71 XOR1_to_NAND2 0 3.919fF
C72 Cin_to_XOR2___NAND2#20contact@543_metal-1-metal-2 0 4.06fF
C73 NAND2_to_Nand4 0 6.989fF
C74 NAND2_to_Nand4#4nmos@77_diff-bottom 0 4.229fF
C75 A1#2contact@552_metal-1-metal-2 0 7.684fF
C76 B1#2contact@553_metal-1-metal-2 0 5.6fF
C77 Cin_to_XOR2___NAND3#1contact@646_metal-1-metal-2 0 14.582fF
C78 A7 0 5.543fF
C79 net@1807 0 3.833fF
C80 net@1907 0 4.502fF
C81 net@2004 0 1.741fF
C82 net@1907#2contact@603_metal-1-polysilicon-1 0 7.287fF
C83 net@1914#2contact@579_metal-1-metal-2 0 8.905fF
C84 net@1914 0 4.589fF
C85 B2#1pin@588_metal-2 0 21.389fF
C86 A2#1pin@586_metal-2 0 22.844fF
C87 net@1809#2pin@536_metal-1 0 5.84fF
C88 net@1809#5pmos@85_diff-top 0 4.602fF
C89 XOR1_to_NAND3#1contact@656_metal-1-metal-2 0 22.356fF
C90 XOR1_to_NAND3#22pmos@86_diff-top 0 4.651fF
C91 net@1812 0 3.833fF
C92 net@1820 0 4.452fF
C93 net@1855 0 1.741fF
C94 net@1820#2contact@642_metal-1-polysilicon-1 0 7.187fF
C95 net@1821#2contact@617_metal-1-metal-2 0 8.905fF
C96 net@1821 0 4.589fF
C97 Cin_to_XOR2___NAND3 0 11.38fF
C98 net@1811#2pin@561_metal-1 0 5.84fF
C99 net@1811#5pmos@92_diff-top 0 4.602fF
C100 Sum2 0 12.083fF
C101 Sum2#4pmos@93_diff-top 0 4.614fF
C102 NAND1_to_NAND5 0 9.146fF
C103 NAND1_to_NAND5#4nmos@95_diff-bottom 0 4.614fF
C104 XOR1_to_NAND3 0 3.919fF
C105 Cin_to_XOR2___NAND3#20contact@655_metal-1-metal-2 0 4.06fF
C106 NAND2_to_Nand5 0 6.989fF
C107 NAND2_to_Nand5#4nmos@97_diff-bottom 0 4.229fF
C108 A2#0contact@664_metal-1-metal-2 0 7.684fF
C109 B2#0contact@665_metal-1-metal-2 0 5.6fF
C110 Cin_to_XOR2___NAND4#1contact@756_metal-1-metal-2 0 14.582fF
C111 net@2104 0 3.833fF
C112 net@2204 0 4.502fF
C113 net@2301 0 1.741fF
C114 net@2204#2contact@713_metal-1-polysilicon-1 0 7.287fF
C115 net@2211#2contact@689_metal-1-metal-2 0 8.905fF
C116 net@2211 0 4.589fF
C117 B3#1pin@683_metal-2 0 21.131fF
C118 A3#1pin@681_metal-2 0 22.678fF
C119 net@2106#2pin@631_metal-1 0 5.84fF
C120 net@2106#5pmos@105_diff-top 0 4.602fF
C121 XOR1_to_NAND4#1contact@766_metal-1-metal-2 0 22.356fF
C122 XOR1_to_NAND4#22pmos@106_diff-top 0 4.651fF
C123 net@2109 0 3.833fF
C124 net@2117 0 4.452fF
C125 net@2152 0 1.741fF
C126 net@2117#2contact@752_metal-1-polysilicon-1 0 7.187fF
C127 net@2118#2contact@727_metal-1-metal-2 0 8.905fF
C128 net@2118 0 4.589fF
C129 Cin_to_XOR2___NAND4 0 11.38fF
C130 net@2108#2pin@656_metal-1 0 5.84fF
C131 net@2108#5pmos@112_diff-top 0 4.602fF
C132 Sum3 0 12.047fF
C133 Sum3#4pmos@113_diff-top 0 4.614fF
C134 NAND1_to_NAND6 0 9.146fF
C135 NAND1_to_NAND6#4nmos@115_diff-bottom 0 4.614fF
C136 XOR1_to_NAND4 0 3.919fF
C137 Cin_to_XOR2___NAND4#20contact@765_metal-1-metal-2 0 4.06fF
C138 NAND2_to_Nand6 0 6.989fF
C139 NAND2_to_Nand6#4nmos@117_diff-bottom 0 4.229fF
C140 A3#0contact@774_metal-1-metal-2 0 7.684fF
C141 B3#0contact@775_metal-1-metal-2 0 5.6fF
C142 Cin_to_XOR2___NAND5#1contact@865_metal-1-metal-2 0 14.582fF
C143 net@2390 0 3.833fF
C144 net@2490 0 4.502fF
C145 net@2587 0 1.741fF
C146 net@2490#2contact@822_metal-1-polysilicon-1 0 7.287fF
C147 net@2497#2contact@798_metal-1-metal-2 0 8.905fF
C148 net@2497 0 4.589fF
C149 B4#1pin@769_metal-2 0 22.79fF
C150 A4#1pin@767_metal-2 0 24.333fF
C151 net@2392#2pin@717_metal-1 0 5.84fF
C152 net@2392#5pmos@125_diff-top 0 4.602fF
C153 XOR1_to_NAND5#1contact@875_metal-1-metal-2 0 22.356fF
C154 XOR1_to_NAND5#22pmos@126_diff-top 0 4.651fF
C155 net@2395 0 3.833fF
C156 net@2403 0 4.452fF
C157 net@2438 0 1.741fF
C158 net@2403#2contact@861_metal-1-polysilicon-1 0 7.187fF
C159 net@2404#2contact@836_metal-1-metal-2 0 8.905fF
C160 net@2404 0 4.589fF
C161 Cin_to_XOR2___NAND5 0 11.38fF
C162 net@2394#2pin@742_metal-1 0 5.84fF
C163 net@2394#5pmos@132_diff-top 0 4.602fF
C164 Sum4 0 12.083fF
C165 Sum4#4pmos@133_diff-top 0 4.614fF
C166 NAND1_to_NAND7 0 9.146fF
C167 NAND1_to_NAND7#4nmos@135_diff-bottom 0 4.614fF
C168 XOR1_to_NAND5 0 3.919fF
C169 Cin_to_XOR2___NAND5#20contact@874_metal-1-metal-2 0 4.06fF
C170 NAND2_to_Nand7 0 6.989fF
C171 NAND2_to_Nand7#4nmos@137_diff-bottom 0 4.229fF
C172 A4#0contact@883_metal-1-metal-2 0 7.684fF
C173 B4#0contact@884_metal-1-metal-2 0 5.6fF
C174 Cout 0 6.218fF
C175 Cout#2nmos@139_diff-bottom 0 4.229fF
C176 B0#14nmos@42_poly-left 0 0.135fF
C177 net@684#9nmos@43_poly-left 0 0.178fF
C178 Cin#9nmos@49_poly-left 0 0.135fF
C179 net@577#9nmos@50_poly-left 0 0.178fF
C180 B1#17nmos@62_poly-left 0 0.135fF
C181 net@1314#9nmos@63_poly-left 0 0.178fF
C182 Cin_to_XOR2___NAND2#18nmos@69_poly-left 0 0.135fF
C183 net@1221#9nmos@70_poly-left 0 0.178fF
C184 B2#16nmos@82_poly-left 0 0.135fF
C185 net@1914#9nmos@83_poly-left 0 0.178fF
C186 Cin_to_XOR2___NAND3#18nmos@89_poly-left 0 0.135fF
C187 net@1821#9nmos@90_poly-left 0 0.178fF
C188 B3#16nmos@102_poly-left 0 0.135fF
C189 net@2211#9nmos@103_poly-left 0 0.178fF
C190 Cin_to_XOR2___NAND4#18nmos@109_poly-left 0 0.135fF
C191 net@2118#9nmos@110_poly-left 0 0.178fF
C192 B4#16nmos@122_poly-left 0 0.135fF
C193 net@2497#9nmos@123_poly-left 0 0.178fF
C194 Cin_to_XOR2___NAND5#18nmos@129_poly-left 0 0.135fF
C195 net@2404#9nmos@130_poly-left 0 0.178fF
C196 net@562 0 0.143fF
C197 B0#12pin@157_polysilicon-1 0 0.132fF
C198 A0#11pin@164_polysilicon-1 0 0.12fF
C199 A0#13pin@165_polysilicon-1 0 0.106fF
C200 B0#10pin@167_polysilicon-1 0 0.203fF
C201 net@676#5pin@169_polysilicon-1 0 0.221fF
C202 B0#13pin@174_polysilicon-1 0 0.175fF
C203 net@562#1pin@176_polysilicon-1 0 0.187fF
C204 A0#2pin@177_polysilicon-1 0 0.199fF
C205 net@564 0 0.143fF
C206 Cin#7pin@183_polysilicon-1 0 0.132fF
C207 XOR1_to_NAND1#10pin@190_polysilicon-1 0 0.12fF
C208 XOR1_to_NAND1#12pin@191_polysilicon-1 0 0.106fF
C209 Cin#6pin@193_polysilicon-1 0 0.203fF
C210 net@576#5pin@195_polysilicon-1 0 0.236fF
C211 Cin#8pin@200_polysilicon-1 0 0.175fF
C212 net@564#1pin@202_polysilicon-1 0 0.187fF
C213 XOR1_to_NAND1#3pin@203_polysilicon-1 0 0.199fF
C214 XOR1_to_NAND1#14pin@207_polysilicon-1 0 0.184fF
C215 Cin#14pin@212_polysilicon-1 0 0.244fF
C216 A0#8pin@215_polysilicon-1 0 0.224fF
C217 B0#8pin@220_polysilicon-1 0 0.237fF
C218 NAND2_to_Nand3#9pin@224_polysilicon-1 0 0.224fF
C219 NAND1_to_NAND3#12pin@229_polysilicon-1 0 0.103fF
C220 net@1209 0 0.143fF
C221 B1#15pin@333_polysilicon-1 0 0.132fF
C222 A1#14pin@340_polysilicon-1 0 0.12fF
C223 A1#16pin@341_polysilicon-1 0 0.106fF
C224 B1#13pin@343_polysilicon-1 0 0.203fF
C225 net@1307#5pin@345_polysilicon-1 0 0.221fF
C226 B1#16pin@350_polysilicon-1 0 0.175fF
C227 net@1209#1pin@352_polysilicon-1 0 0.187fF
C228 A1#4pin@353_polysilicon-1 0 0.199fF
C229 net@1211 0 0.143fF
C230 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1 0 0.132fF
C231 XOR1_to_NAND2#10pin@365_polysilicon-1 0 0.12fF
C232 XOR1_to_NAND2#12pin@366_polysilicon-1 0 0.106fF
C233 Cin_to_XOR2___NAND2#15pin@368_polysilicon-1 0 0.203fF
C234 net@1220#5pin@370_polysilicon-1 0 0.236fF
C235 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1 0 0.175fF
C236 net@1211#1pin@377_polysilicon-1 0 0.187fF
C237 XOR1_to_NAND2#3pin@378_polysilicon-1 0 0.199fF
C238 XOR1_to_NAND2#14pin@382_polysilicon-1 0 0.184fF
C239 Cin_to_XOR2___NAND2#23pin@386_polysilicon-1 0 0.244fF
C240 A1#11pin@389_polysilicon-1 0 0.224fF
C241 B1#11pin@393_polysilicon-1 0 0.237fF
C242 NAND2_to_Nand4#9pin@395_polysilicon-1 0 0.224fF
C243 NAND1_to_NAND4#12pin@399_polysilicon-1 0 0.103fF
C244 net@1809 0 0.143fF
C245 B2#14pin@527_polysilicon-1 0 0.132fF
C246 A2#13pin@534_polysilicon-1 0 0.12fF
C247 A2#15pin@535_polysilicon-1 0 0.106fF
C248 B2#12pin@537_polysilicon-1 0 0.203fF
C249 net@1907#5pin@539_polysilicon-1 0 0.221fF
C250 B2#15pin@544_polysilicon-1 0 0.175fF
C251 net@1809#1pin@546_polysilicon-1 0 0.187fF
C252 A2#3pin@547_polysilicon-1 0 0.199fF
C253 net@1811 0 0.143fF
C254 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1 0 0.132fF
C255 XOR1_to_NAND3#10pin@559_polysilicon-1 0 0.12fF
C256 XOR1_to_NAND3#12pin@560_polysilicon-1 0 0.106fF
C257 Cin_to_XOR2___NAND3#15pin@562_polysilicon-1 0 0.203fF
C258 net@1820#5pin@564_polysilicon-1 0 0.236fF
C259 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1 0 0.175fF
C260 net@1811#1pin@571_polysilicon-1 0 0.187fF
C261 XOR1_to_NAND3#3pin@572_polysilicon-1 0 0.199fF
C262 XOR1_to_NAND3#14pin@576_polysilicon-1 0 0.184fF
C263 Cin_to_XOR2___NAND3#23pin@580_polysilicon-1 0 0.244fF
C264 A2#10pin@583_polysilicon-1 0 0.224fF
C265 B2#10pin@587_polysilicon-1 0 0.237fF
C266 NAND2_to_Nand5#9pin@589_polysilicon-1 0 0.224fF
C267 NAND1_to_NAND5#12pin@593_polysilicon-1 0 0.103fF
C268 net@2106 0 0.143fF
C269 B3#14pin@622_polysilicon-1 0 0.132fF
C270 A3#13pin@629_polysilicon-1 0 0.12fF
C271 A3#15pin@630_polysilicon-1 0 0.106fF
C272 B3#12pin@632_polysilicon-1 0 0.203fF
C273 net@2204#5pin@634_polysilicon-1 0 0.221fF
C274 B3#15pin@639_polysilicon-1 0 0.175fF
C275 net@2106#1pin@641_polysilicon-1 0 0.187fF
C276 A3#3pin@642_polysilicon-1 0 0.199fF
C277 net@2108 0 0.143fF
C278 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1 0 0.132fF
C279 XOR1_to_NAND4#10pin@654_polysilicon-1 0 0.12fF
C280 XOR1_to_NAND4#12pin@655_polysilicon-1 0 0.106fF
C281 Cin_to_XOR2___NAND4#15pin@657_polysilicon-1 0 0.203fF
C282 net@2117#5pin@659_polysilicon-1 0 0.236fF
C283 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1 0 0.175fF
C284 net@2108#1pin@666_polysilicon-1 0 0.187fF
C285 XOR1_to_NAND4#3pin@667_polysilicon-1 0 0.199fF
C286 XOR1_to_NAND4#14pin@671_polysilicon-1 0 0.184fF
C287 Cin_to_XOR2___NAND4#23pin@675_polysilicon-1 0 0.244fF
C288 A3#10pin@678_polysilicon-1 0 0.224fF
C289 B3#10pin@682_polysilicon-1 0 0.237fF
C290 NAND2_to_Nand6#9pin@684_polysilicon-1 0 0.224fF
C291 NAND1_to_NAND6#12pin@688_polysilicon-1 0 0.103fF
C292 net@2392 0 0.143fF
C293 B4#14pin@708_polysilicon-1 0 0.132fF
C294 A4#13pin@715_polysilicon-1 0 0.12fF
C295 A4#15pin@716_polysilicon-1 0 0.106fF
C296 B4#12pin@718_polysilicon-1 0 0.203fF
C297 net@2490#5pin@720_polysilicon-1 0 0.221fF
C298 B4#15pin@725_polysilicon-1 0 0.175fF
C299 net@2392#1pin@727_polysilicon-1 0 0.187fF
C300 A4#3pin@728_polysilicon-1 0 0.199fF
C301 net@2394 0 0.143fF
C302 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1 0 0.132fF
C303 XOR1_to_NAND5#10pin@740_polysilicon-1 0 0.12fF
C304 XOR1_to_NAND5#12pin@741_polysilicon-1 0 0.106fF
C305 Cin_to_XOR2___NAND5#15pin@743_polysilicon-1 0 0.203fF
C306 net@2403#5pin@745_polysilicon-1 0 0.236fF
C307 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1 0 0.175fF
C308 net@2394#1pin@752_polysilicon-1 0 0.187fF
C309 XOR1_to_NAND5#3pin@753_polysilicon-1 0 0.199fF
C310 XOR1_to_NAND5#14pin@757_polysilicon-1 0 0.184fF
C311 Cin_to_XOR2___NAND5#23pin@761_polysilicon-1 0 0.244fF
C312 A4#10pin@764_polysilicon-1 0 0.224fF
C313 B4#10pin@768_polysilicon-1 0 0.237fF
C314 NAND2_to_Nand7#9pin@770_polysilicon-1 0 0.224fF
C315 NAND1_to_NAND7#12pin@774_polysilicon-1 0 0.103fF
C316 A0#10pmos@40_poly-left 0 0.158fF
C317 net@562#7pmos@41_poly-left 0 0.145fF
C318 XOR1_to_NAND1#9pmos@47_poly-left 0 0.158fF
C319 net@564#7pmos@48_poly-left 0 0.145fF
C320 NAND1_to_NAND3#11pmos@59_poly-right 0 0.13fF
C321 A1#13pmos@60_poly-left 0 0.158fF
C322 net@1209#7pmos@61_poly-left 0 0.145fF
C323 XOR1_to_NAND2#9pmos@67_poly-left 0 0.158fF
C324 net@1211#7pmos@68_poly-left 0 0.145fF
C325 NAND1_to_NAND4#11pmos@79_poly-right 0 0.13fF
C326 A2#12pmos@80_poly-left 0 0.158fF
C327 net@1809#7pmos@81_poly-left 0 0.145fF
C328 XOR1_to_NAND3#9pmos@87_poly-left 0 0.158fF
C329 net@1811#7pmos@88_poly-left 0 0.145fF
C330 NAND1_to_NAND5#11pmos@99_poly-right 0 0.13fF
C331 A3#12pmos@100_poly-left 0 0.158fF
C332 net@2106#7pmos@101_poly-left 0 0.145fF
C333 XOR1_to_NAND4#9pmos@107_poly-left 0 0.158fF
C334 net@2108#7pmos@108_poly-left 0 0.145fF
C335 NAND1_to_NAND6#11pmos@119_poly-right 0 0.13fF
C336 A4#12pmos@120_poly-left 0 0.158fF
C337 net@2392#7pmos@121_poly-left 0 0.145fF
C338 XOR1_to_NAND5#9pmos@127_poly-left 0 0.158fF
C339 net@2394#7pmos@128_poly-left 0 0.145fF
C340 NAND1_to_NAND7#11pmos@139_poly-right 0 0.13fF
** Extracted Parasitic Resistors ***
R0 A1 A1#1pin@517_metal-2 8.255
R1 A0#0contact@317_metal-1-metal-2 A0 9.49
R2 A1#2contact@552_metal-1-metal-2 A1#1pin@517_metal-2 9.49
R3 A2#0contact@664_metal-1-metal-2 A2#1pin@586_metal-2 9.49
R4 A3#0contact@774_metal-1-metal-2 A3#1pin@681_metal-2 9.49
R5 A4#0contact@883_metal-1-metal-2 A4#1pin@767_metal-2 9.49
R6 B0#0contact@318_metal-1-metal-2 B0#0contact@318_metal-1-metal-2##0 5.161
C341 B0#0contact@318_metal-1-metal-2##0 0 5.536fF
R7 B0#0contact@318_metal-1-metal-2##0 B0 5.161
R8 B1#2contact@553_metal-1-metal-2 B1#2contact@553_metal-1-metal-2##0 5.161
C342 B1#2contact@553_metal-1-metal-2##0 0 5.536fF
R9 B1#2contact@553_metal-1-metal-2##0 B1#0pin@508_metal-2 5.161
R10 B2#0contact@665_metal-1-metal-2 B2#0contact@665_metal-1-metal-2##0 5.161
C343 B2#0contact@665_metal-1-metal-2##0 0 5.536fF
R11 B2#0contact@665_metal-1-metal-2##0 B2#1pin@588_metal-2 5.161
R12 B3#0contact@775_metal-1-metal-2 B3#0contact@775_metal-1-metal-2##0 5.161
C344 B3#0contact@775_metal-1-metal-2##0 0 5.536fF
R13 B3#0contact@775_metal-1-metal-2##0 B3#1pin@683_metal-2 5.161
R14 B4#0contact@884_metal-1-metal-2 B4#0contact@884_metal-1-metal-2##0 5.161
C345 B4#0contact@884_metal-1-metal-2##0 0 5.536fF
R15 B4#0contact@884_metal-1-metal-2##0 B4#1pin@769_metal-2 5.161
R16 Cin#0pin@206_metal-2 Cin 4.212
R17 Cin_to_XOR2___NAND2 Cin_to_XOR2___NAND2#1contact@534_metal-1-metal-2 4.212
R18 Cin_to_XOR2___NAND3 Cin_to_XOR2___NAND3#1contact@646_metal-1-metal-2 4.212
R19 Cin_to_XOR2___NAND4 Cin_to_XOR2___NAND4#1contact@756_metal-1-metal-2 4.212
R20 Cin_to_XOR2___NAND5 Cin_to_XOR2___NAND5#1contact@865_metal-1-metal-2 4.212
R21 XOR1_to_NAND1 XOR1_to_NAND1#1contact@309_metal-1-metal-2 4.42
R22 XOR1_to_NAND2 XOR1_to_NAND2#1contact@544_metal-1-metal-2 4.42
R23 XOR1_to_NAND3 XOR1_to_NAND3#1contact@656_metal-1-metal-2 4.42
R24 XOR1_to_NAND4 XOR1_to_NAND4#1contact@766_metal-1-metal-2 4.42
R25 XOR1_to_NAND5 XOR1_to_NAND5#1contact@875_metal-1-metal-2 4.42
R26 net@562 net@562##0 9.92
R27 net@562##0 net@562##1 9.92
R28 net@562##1 net@562##2 9.92
R29 net@562##2 net@562##3 9.92
R30 net@562##3 net@562##4 9.92
R31 net@562##4 net@562##5 9.92
R32 net@562##5 net@562##6 9.92
R33 net@562##6 net@562##7 9.92
R34 net@562##7 net@562##8 9.92
R35 net@562##8 net@562##9 9.92
R36 net@562##9 net@562##10 9.92
R37 net@562##10 net@562##11 9.92
R38 net@562##11 net@562##12 9.92
R39 net@562##12 net@562##13 9.92
R40 net@562##13 net@562##14 9.92
R41 net@562##14 net@562##15 9.92
R42 net@562##15 net@562##16 9.92
R43 net@562##16 net@562##17 9.92
R44 net@562##17 net@562##18 9.92
R45 net@562##18 net@562#1pin@176_polysilicon-1 9.92
R46 net@564 net@564##0 9.92
R47 net@564##0 net@564##1 9.92
R48 net@564##1 net@564##2 9.92
R49 net@564##2 net@564##3 9.92
R50 net@564##3 net@564##4 9.92
R51 net@564##4 net@564##5 9.92
R52 net@564##5 net@564##6 9.92
R53 net@564##6 net@564##7 9.92
R54 net@564##7 net@564##8 9.92
R55 net@564##8 net@564##9 9.92
R56 net@564##9 net@564##10 9.92
R57 net@564##10 net@564##11 9.92
R58 net@564##11 net@564##12 9.92
R59 net@564##12 net@564##13 9.92
R60 net@564##13 net@564##14 9.92
R61 net@564##14 net@564##15 9.92
R62 net@564##15 net@564##16 9.92
R63 net@564##16 net@564##17 9.92
R64 net@564##17 net@564##18 9.92
R65 net@564##18 net@564#1pin@202_polysilicon-1 9.92
R66 XOR1_to_NAND1#3pin@203_polysilicon-1 XOR1_to_NAND1#3pin@203_polysilicon-1##0 6.2
R67 XOR1_to_NAND1#3pin@203_polysilicon-1##0 XOR1_to_NAND1#4pmos@52_poly-right 6.2
R68 XOR1_to_NAND1#3pin@203_polysilicon-1 XOR1_to_NAND1#3pin@203_polysilicon-1##0 8.138
R69 XOR1_to_NAND1#3pin@203_polysilicon-1##0 XOR1_to_NAND1#3pin@203_polysilicon-1##1 8.138
R70 XOR1_to_NAND1#3pin@203_polysilicon-1##1 XOR1_to_NAND1#3pin@203_polysilicon-1##2 8.138
R71 XOR1_to_NAND1#3pin@203_polysilicon-1##2 XOR1_to_NAND1#1contact@309_metal-1-metal-2 8.138
R72 Cin#5nmos@51_poly-right Cin#5nmos@51_poly-right##0 5.425
R73 Cin#5nmos@51_poly-right##0 Cin#6pin@193_polysilicon-1 5.425
R74 Cin#0pin@206_metal-2 Cin#0pin@206_metal-2##0 8.99
R75 Cin#0pin@206_metal-2##0 Cin#0pin@206_metal-2##1 8.99
R76 Cin#0pin@206_metal-2##1 Cin#0pin@206_metal-2##2 8.99
R77 Cin#0pin@206_metal-2##2 Cin#0pin@206_metal-2##3 8.99
R78 Cin#0pin@206_metal-2##3 Cin#6pin@193_polysilicon-1 8.99
R79 A0#2pin@177_polysilicon-1 A0#2pin@177_polysilicon-1##0 6.2
R80 A0#2pin@177_polysilicon-1##0 A0#3pmos@45_poly-right 6.2
R81 XOR1_to_NAND1#9pmos@47_poly-left XOR1_to_NAND1#9pmos@47_poly-left##0 8.138
R82 XOR1_to_NAND1#9pmos@47_poly-left##0 XOR1_to_NAND1#9pmos@47_poly-left##1 8.138
R83 XOR1_to_NAND1#9pmos@47_poly-left##1 XOR1_to_NAND1#9pmos@47_poly-left##2 8.138
R84 XOR1_to_NAND1#9pmos@47_poly-left##2 XOR1_to_NAND1#10pin@190_polysilicon-1 8.138
R85 Cin#7pin@183_polysilicon-1 Cin#7pin@183_polysilicon-1##0 9.843
R86 Cin#7pin@183_polysilicon-1##0 Cin#7pin@183_polysilicon-1##1 9.843
R87 Cin#7pin@183_polysilicon-1##1 Cin#7pin@183_polysilicon-1##2 9.843
R88 Cin#7pin@183_polysilicon-1##2 Cin#7pin@183_polysilicon-1##3 9.843
R89 Cin#7pin@183_polysilicon-1##3 Cin#7pin@183_polysilicon-1##4 9.843
R90 Cin#7pin@183_polysilicon-1##4 Cin#7pin@183_polysilicon-1##5 9.843
R91 Cin#7pin@183_polysilicon-1##5 Cin#7pin@183_polysilicon-1##6 9.843
R92 Cin#7pin@183_polysilicon-1##6 Cin#7pin@183_polysilicon-1##7 9.843
R93 Cin#7pin@183_polysilicon-1##7 Cin#7pin@183_polysilicon-1##8 9.843
R94 Cin#7pin@183_polysilicon-1##8 Cin#7pin@183_polysilicon-1##9 9.843
R95 Cin#7pin@183_polysilicon-1##9 Cin#7pin@183_polysilicon-1##10 9.843
R96 Cin#7pin@183_polysilicon-1##10 Cin#7pin@183_polysilicon-1##11 9.843
R97 Cin#7pin@183_polysilicon-1##11 Cin#7pin@183_polysilicon-1##12 9.843
R98 Cin#7pin@183_polysilicon-1##12 Cin#7pin@183_polysilicon-1##13 9.843
R99 Cin#7pin@183_polysilicon-1##13 Cin#7pin@183_polysilicon-1##14 9.843
R100 Cin#7pin@183_polysilicon-1##14 Cin#7pin@183_polysilicon-1##15 9.843
R101 Cin#7pin@183_polysilicon-1##15 Cin#7pin@183_polysilicon-1##16 9.843
R102 Cin#7pin@183_polysilicon-1##16 Cin#7pin@183_polysilicon-1##17 9.843
R103 Cin#7pin@183_polysilicon-1##17 Cin#7pin@183_polysilicon-1##18 9.843
R104 Cin#7pin@183_polysilicon-1##18 Cin#8pin@200_polysilicon-1 9.843
R105 net@576#4nmos@53_poly-right net@576#4nmos@53_poly-right##0 9.3
R106 net@576#4nmos@53_poly-right##0 net@576#4nmos@53_poly-right##1 9.3
R107 net@576#4nmos@53_poly-right##1 net@576#5pin@195_polysilicon-1 9.3
R108 net@576#2contact@295_metal-1-polysilicon-1 net@576#2contact@295_metal-1-polysilicon-1##0 8.99
R109 net@576#2contact@295_metal-1-polysilicon-1##0 net@576#2contact@295_metal-1-polysilicon-1##1 8.99
R110 net@576#2contact@295_metal-1-polysilicon-1##1 net@576#2contact@295_metal-1-polysilicon-1##2 8.99
R111 net@576#2contact@295_metal-1-polysilicon-1##2 net@576#2contact@295_metal-1-polysilicon-1##3 8.99
R112 net@576#2contact@295_metal-1-polysilicon-1##3 net@576#5pin@195_polysilicon-1 8.99
R113 A0#2pin@177_polysilicon-1 A0#2pin@177_polysilicon-1##0 8.138
R114 A0#2pin@177_polysilicon-1##0 A0#2pin@177_polysilicon-1##1 8.138
R115 A0#2pin@177_polysilicon-1##1 A0#2pin@177_polysilicon-1##2 8.138
R116 A0#2pin@177_polysilicon-1##2 A0 8.138
R117 XOR1_to_NAND1#1contact@309_metal-1-metal-2 XOR1_to_NAND1#1contact@309_metal-1-metal-2##0 6.717
R118 XOR1_to_NAND1#1contact@309_metal-1-metal-2##0 XOR1_to_NAND1#1contact@309_metal-1-metal-2##1 6.717
R119 XOR1_to_NAND1#1contact@309_metal-1-metal-2##1 XOR1_to_NAND1#12pin@191_polysilicon-1 6.717
R120 XOR1_to_NAND1#10pin@190_polysilicon-1 XOR1_to_NAND1#10pin@190_polysilicon-1##0 7.75
R121 XOR1_to_NAND1#10pin@190_polysilicon-1##0 XOR1_to_NAND1#10pin@190_polysilicon-1##1 7.75
R122 XOR1_to_NAND1#10pin@190_polysilicon-1##1 XOR1_to_NAND1#12pin@191_polysilicon-1 7.75
R123 Cin#8pin@200_polysilicon-1 Cin#8pin@200_polysilicon-1##0 9.743
R124 Cin#8pin@200_polysilicon-1##0 Cin#8pin@200_polysilicon-1##1 9.743
R125 Cin#8pin@200_polysilicon-1##1 Cin#8pin@200_polysilicon-1##2 9.743
R126 Cin#8pin@200_polysilicon-1##2 Cin#8pin@200_polysilicon-1##3 9.743
R127 Cin#8pin@200_polysilicon-1##3 Cin#8pin@200_polysilicon-1##4 9.743
R128 Cin#8pin@200_polysilicon-1##4 Cin#8pin@200_polysilicon-1##5 9.743
R129 Cin#8pin@200_polysilicon-1##5 Cin#0pin@206_metal-2 9.743
R130 net@564#7pmos@48_poly-left net@564#7pmos@48_poly-left##0 7.75
R131 net@564#7pmos@48_poly-left##0 net@564 7.75
R132 Cin#9nmos@49_poly-left Cin#9nmos@49_poly-left##0 6.2
R133 Cin#9nmos@49_poly-left##0 Cin#7pin@183_polysilicon-1 6.2
R134 net@577#9nmos@50_poly-left net@577#9nmos@50_poly-left##0 8.37
R135 net@577#9nmos@50_poly-left##0 net@577#9nmos@50_poly-left##1 8.37
R136 net@577#9nmos@50_poly-left##1 net@577#9nmos@50_poly-left##2 8.37
R137 net@577#9nmos@50_poly-left##2 net@577#9nmos@50_poly-left##3 8.37
R138 net@577#9nmos@50_poly-left##3 net@577#2contact@270_metal-1-metal-2 8.37
R139 XOR1_to_NAND1 XOR1_to_NAND1##0 6.717
R140 XOR1_to_NAND1##0 XOR1_to_NAND1##1 6.717
R141 XOR1_to_NAND1##1 XOR1_to_NAND1#14pin@207_polysilicon-1 6.717
R142 XOR1_to_NAND1#16pmos@54_poly-right XOR1_to_NAND1#16pmos@54_poly-right##0 6.2
R143 XOR1_to_NAND1#16pmos@54_poly-right##0 XOR1_to_NAND1#14pin@207_polysilicon-1 6.2
R144 Cin#14pin@212_polysilicon-1 Cin#14pin@212_polysilicon-1##0 9.688
R145 Cin#14pin@212_polysilicon-1##0 Cin#14pin@212_polysilicon-1##1 9.688
R146 Cin#14pin@212_polysilicon-1##1 Cin#14pin@212_polysilicon-1##2 9.688
R147 Cin#14pin@212_polysilicon-1##2 Cin#11contact@308_metal-1-metal-2 9.688
R148 Cin#11contact@308_metal-1-metal-2 Cin#0pin@206_metal-2 4.953
R149 A0#0contact@317_metal-1-metal-2 A0#0contact@317_metal-1-metal-2##0 6.717
R150 A0#0contact@317_metal-1-metal-2##0 A0#0contact@317_metal-1-metal-2##1 6.717
R151 A0#0contact@317_metal-1-metal-2##1 A0#8pin@215_polysilicon-1 6.717
R152 A0#9pmos@56_poly-right A0#9pmos@56_poly-right##0 9.558
R153 A0#9pmos@56_poly-right##0 A0#9pmos@56_poly-right##1 9.558
R154 A0#9pmos@56_poly-right##1 A0#9pmos@56_poly-right##2 9.558
R155 A0#9pmos@56_poly-right##2 A0#9pmos@56_poly-right##3 9.558
R156 A0#9pmos@56_poly-right##3 A0#9pmos@56_poly-right##4 9.558
R157 A0#9pmos@56_poly-right##4 A0#8pin@215_polysilicon-1 9.558
R158 B0#8pin@220_polysilicon-1 B0#8pin@220_polysilicon-1##0 8.138
R159 B0#8pin@220_polysilicon-1##0 B0#8pin@220_polysilicon-1##1 8.138
R160 B0#8pin@220_polysilicon-1##1 B0#8pin@220_polysilicon-1##2 8.138
R161 B0#8pin@220_polysilicon-1##2 B0#0contact@318_metal-1-metal-2 8.138
R162 B0#9nmos@44_poly-right B0#9nmos@44_poly-right##0 5.425
R163 B0#9nmos@44_poly-right##0 B0#10pin@167_polysilicon-1 5.425
R164 NAND2_to_Nand3 NAND2_to_Nand3##0 6.717
R165 NAND2_to_Nand3##0 NAND2_to_Nand3##1 6.717
R166 NAND2_to_Nand3##1 NAND2_to_Nand3#9pin@224_polysilicon-1 6.717
R167 NAND2_to_Nand3#10pmos@58_poly-right NAND2_to_Nand3#10pmos@58_poly-right##0 9.558
R168 NAND2_to_Nand3#10pmos@58_poly-right##0 NAND2_to_Nand3#10pmos@58_poly-right##1 9.558
R169 NAND2_to_Nand3#10pmos@58_poly-right##1 NAND2_to_Nand3#10pmos@58_poly-right##2 9.558
R170 NAND2_to_Nand3#10pmos@58_poly-right##2 NAND2_to_Nand3#10pmos@58_poly-right##3 9.558
R171 NAND2_to_Nand3#10pmos@58_poly-right##3 NAND2_to_Nand3#10pmos@58_poly-right##4 9.558
R172 NAND2_to_Nand3#10pmos@58_poly-right##4 NAND2_to_Nand3#9pin@224_polysilicon-1 9.558
R173 B0 B0##0 8.99
R174 B0##0 B0##1 8.99
R175 B0##1 B0##2 8.99
R176 B0##2 B0##3 8.99
R177 B0##3 B0#10pin@167_polysilicon-1 8.99
R178 NAND1_to_NAND3#11pmos@59_poly-right NAND1_to_NAND3#11pmos@59_poly-right##0 5.425
R179 NAND1_to_NAND3#11pmos@59_poly-right##0 NAND1_to_NAND3#12pin@229_polysilicon-1 5.425
R180 NAND1_to_NAND3#12pin@229_polysilicon-1 NAND1_to_NAND3#12pin@229_polysilicon-1##0 9.3
R181 NAND1_to_NAND3#12pin@229_polysilicon-1##0 NAND1_to_NAND3#12pin@229_polysilicon-1##1 9.3
R182 NAND1_to_NAND3#12pin@229_polysilicon-1##1 NAND1_to_NAND3 9.3
R183 Cin#16nmos@55_poly-right Cin#16nmos@55_poly-right##0 8.636
R184 Cin#16nmos@55_poly-right##0 Cin#16nmos@55_poly-right##1 8.636
R185 Cin#16nmos@55_poly-right##1 Cin#16nmos@55_poly-right##2 8.636
R186 Cin#16nmos@55_poly-right##2 Cin#16nmos@55_poly-right##3 8.636
R187 Cin#16nmos@55_poly-right##3 Cin#16nmos@55_poly-right##4 8.636
R188 Cin#16nmos@55_poly-right##4 Cin#16nmos@55_poly-right##5 8.636
R189 Cin#16nmos@55_poly-right##5 Cin#14pin@212_polysilicon-1 8.636
R190 B0#11nmos@57_poly-right B0#11nmos@57_poly-right##0 8.956
R191 B0#11nmos@57_poly-right##0 B0#11nmos@57_poly-right##1 8.956
R192 B0#11nmos@57_poly-right##1 B0#11nmos@57_poly-right##2 8.956
R193 B0#11nmos@57_poly-right##2 B0#11nmos@57_poly-right##3 8.956
R194 B0#11nmos@57_poly-right##3 B0#11nmos@57_poly-right##4 8.956
R195 B0#11nmos@57_poly-right##4 B0#11nmos@57_poly-right##5 8.956
R196 B0#11nmos@57_poly-right##5 B0#11nmos@57_poly-right##6 8.956
R197 B0#11nmos@57_poly-right##6 B0#11nmos@57_poly-right##7 8.956
R198 B0#11nmos@57_poly-right##7 B0#8pin@220_polysilicon-1 8.956
R199 A0#10pmos@40_poly-left A0#10pmos@40_poly-left##0 8.138
R200 A0#10pmos@40_poly-left##0 A0#10pmos@40_poly-left##1 8.138
R201 A0#10pmos@40_poly-left##1 A0#10pmos@40_poly-left##2 8.138
R202 A0#10pmos@40_poly-left##2 A0#11pin@164_polysilicon-1 8.138
R203 B0#12pin@157_polysilicon-1 B0#12pin@157_polysilicon-1##0 9.843
R204 B0#12pin@157_polysilicon-1##0 B0#12pin@157_polysilicon-1##1 9.843
R205 B0#12pin@157_polysilicon-1##1 B0#12pin@157_polysilicon-1##2 9.843
R206 B0#12pin@157_polysilicon-1##2 B0#12pin@157_polysilicon-1##3 9.843
R207 B0#12pin@157_polysilicon-1##3 B0#12pin@157_polysilicon-1##4 9.843
R208 B0#12pin@157_polysilicon-1##4 B0#12pin@157_polysilicon-1##5 9.843
R209 B0#12pin@157_polysilicon-1##5 B0#12pin@157_polysilicon-1##6 9.843
R210 B0#12pin@157_polysilicon-1##6 B0#12pin@157_polysilicon-1##7 9.843
R211 B0#12pin@157_polysilicon-1##7 B0#12pin@157_polysilicon-1##8 9.843
R212 B0#12pin@157_polysilicon-1##8 B0#12pin@157_polysilicon-1##9 9.843
R213 B0#12pin@157_polysilicon-1##9 B0#12pin@157_polysilicon-1##10 9.843
R214 B0#12pin@157_polysilicon-1##10 B0#12pin@157_polysilicon-1##11 9.843
R215 B0#12pin@157_polysilicon-1##11 B0#12pin@157_polysilicon-1##12 9.843
R216 B0#12pin@157_polysilicon-1##12 B0#12pin@157_polysilicon-1##13 9.843
R217 B0#12pin@157_polysilicon-1##13 B0#12pin@157_polysilicon-1##14 9.843
R218 B0#12pin@157_polysilicon-1##14 B0#12pin@157_polysilicon-1##15 9.843
R219 B0#12pin@157_polysilicon-1##15 B0#12pin@157_polysilicon-1##16 9.843
R220 B0#12pin@157_polysilicon-1##16 B0#12pin@157_polysilicon-1##17 9.843
R221 B0#12pin@157_polysilicon-1##17 B0#12pin@157_polysilicon-1##18 9.843
R222 B0#12pin@157_polysilicon-1##18 B0#13pin@174_polysilicon-1 9.843
R223 net@676#4nmos@46_poly-right net@676#4nmos@46_poly-right##0 7.233
R224 net@676#4nmos@46_poly-right##0 net@676#4nmos@46_poly-right##1 7.233
R225 net@676#4nmos@46_poly-right##1 net@676#5pin@169_polysilicon-1 7.233
R226 net@676#2contact@256_metal-1-polysilicon-1 net@676#2contact@256_metal-1-polysilicon-1##0 8.99
R227 net@676#2contact@256_metal-1-polysilicon-1##0 net@676#2contact@256_metal-1-polysilicon-1##1 8.99
R228 net@676#2contact@256_metal-1-polysilicon-1##1 net@676#2contact@256_metal-1-polysilicon-1##2 8.99
R229 net@676#2contact@256_metal-1-polysilicon-1##2 net@676#2contact@256_metal-1-polysilicon-1##3 8.99
R230 net@676#2contact@256_metal-1-polysilicon-1##3 net@676#5pin@169_polysilicon-1 8.99
R231 A0 A0##0 6.717
R232 A0##0 A0##1 6.717
R233 A0##1 A0#13pin@165_polysilicon-1 6.717
R234 A0#11pin@164_polysilicon-1 A0#11pin@164_polysilicon-1##0 7.75
R235 A0#11pin@164_polysilicon-1##0 A0#11pin@164_polysilicon-1##1 7.75
R236 A0#11pin@164_polysilicon-1##1 A0#13pin@165_polysilicon-1 7.75
R237 B0#13pin@174_polysilicon-1 B0#13pin@174_polysilicon-1##0 9.743
R238 B0#13pin@174_polysilicon-1##0 B0#13pin@174_polysilicon-1##1 9.743
R239 B0#13pin@174_polysilicon-1##1 B0#13pin@174_polysilicon-1##2 9.743
R240 B0#13pin@174_polysilicon-1##2 B0#13pin@174_polysilicon-1##3 9.743
R241 B0#13pin@174_polysilicon-1##3 B0#13pin@174_polysilicon-1##4 9.743
R242 B0#13pin@174_polysilicon-1##4 B0#13pin@174_polysilicon-1##5 9.743
R243 B0#13pin@174_polysilicon-1##5 B0 9.743
R244 net@562#7pmos@41_poly-left net@562#7pmos@41_poly-left##0 7.75
R245 net@562#7pmos@41_poly-left##0 net@562 7.75
R246 B0#14nmos@42_poly-left B0#14nmos@42_poly-left##0 6.2
R247 B0#14nmos@42_poly-left##0 B0#12pin@157_polysilicon-1 6.2
R248 net@684#9nmos@43_poly-left net@684#9nmos@43_poly-left##0 8.37
R249 net@684#9nmos@43_poly-left##0 net@684#9nmos@43_poly-left##1 8.37
R250 net@684#9nmos@43_poly-left##1 net@684#9nmos@43_poly-left##2 8.37
R251 net@684#9nmos@43_poly-left##2 net@684#9nmos@43_poly-left##3 8.37
R252 net@684#9nmos@43_poly-left##3 net@684#2contact@231_metal-1-metal-2 8.37
R253 A0#2pin@177_polysilicon-1 A0#2pin@177_polysilicon-1##0 9.881
R254 A0#2pin@177_polysilicon-1##0 A0#2pin@177_polysilicon-1##1 9.881
R255 A0#2pin@177_polysilicon-1##1 A0#2pin@177_polysilicon-1##2 9.881
R256 A0#2pin@177_polysilicon-1##2 A0#2pin@177_polysilicon-1##3 9.881
R257 A0#2pin@177_polysilicon-1##3 A0#2pin@177_polysilicon-1##4 9.881
R258 A0#2pin@177_polysilicon-1##4 A0#2pin@177_polysilicon-1##5 9.881
R259 A0#2pin@177_polysilicon-1##5 A0#2pin@177_polysilicon-1##6 9.881
R260 A0#2pin@177_polysilicon-1##6 A0#2pin@177_polysilicon-1##7 9.881
R261 A0#2pin@177_polysilicon-1##7 A0#2pin@177_polysilicon-1##8 9.881
R262 A0#2pin@177_polysilicon-1##8 A0#2pin@177_polysilicon-1##9 9.881
R263 A0#2pin@177_polysilicon-1##9 A0#2pin@177_polysilicon-1##10 9.881
R264 A0#2pin@177_polysilicon-1##10 A0#2pin@177_polysilicon-1##11 9.881
R265 A0#2pin@177_polysilicon-1##11 A0#2pin@177_polysilicon-1##12 9.881
R266 A0#2pin@177_polysilicon-1##12 A0#2pin@177_polysilicon-1##13 9.881
R267 A0#2pin@177_polysilicon-1##13 A0#2pin@177_polysilicon-1##14 9.881
R268 A0#2pin@177_polysilicon-1##14 A0#2pin@177_polysilicon-1##15 9.881
R269 A0#2pin@177_polysilicon-1##15 A0#2pin@177_polysilicon-1##16 9.881
R270 A0#2pin@177_polysilicon-1##16 A0#2pin@177_polysilicon-1##17 9.881
R271 A0#2pin@177_polysilicon-1##17 A0#2pin@177_polysilicon-1##18 9.881
R272 A0#2pin@177_polysilicon-1##18 A0#2pin@177_polysilicon-1##19 9.881
R273 A0#2pin@177_polysilicon-1##19 A0#2pin@177_polysilicon-1##20 9.881
R274 A0#2pin@177_polysilicon-1##20 A0#2pin@177_polysilicon-1##21 9.881
R275 A0#2pin@177_polysilicon-1##21 A0#2pin@177_polysilicon-1##22 9.881
R276 A0#2pin@177_polysilicon-1##22 A0#2pin@177_polysilicon-1##23 9.881
R277 A0#2pin@177_polysilicon-1##23 A0#2pin@177_polysilicon-1##24 9.881
R278 A0#2pin@177_polysilicon-1##24 A0#2pin@177_polysilicon-1##25 9.881
R279 A0#2pin@177_polysilicon-1##25 A0#2pin@177_polysilicon-1##26 9.881
R280 A0#2pin@177_polysilicon-1##26 A0#2pin@177_polysilicon-1##27 9.881
R281 A0#2pin@177_polysilicon-1##27 A0#2pin@177_polysilicon-1##28 9.881
R282 A0#2pin@177_polysilicon-1##28 A0#2pin@177_polysilicon-1##29 9.881
R283 A0#2pin@177_polysilicon-1##29 A0#2pin@177_polysilicon-1##30 9.881
R284 A0#2pin@177_polysilicon-1##30 A0#2pin@177_polysilicon-1##31 9.881
R285 A0#2pin@177_polysilicon-1##31 A0#2pin@177_polysilicon-1##32 9.881
R286 A0#2pin@177_polysilicon-1##32 A0#2pin@177_polysilicon-1##33 9.881
R287 A0#2pin@177_polysilicon-1##33 A0#2pin@177_polysilicon-1##34 9.881
R288 A0#2pin@177_polysilicon-1##34 A0#2pin@177_polysilicon-1##35 9.881
R289 A0#2pin@177_polysilicon-1##35 A0#2pin@177_polysilicon-1##36 9.881
R290 A0#2pin@177_polysilicon-1##36 A0#2pin@177_polysilicon-1##37 9.881
R291 A0#2pin@177_polysilicon-1##37 A0#2pin@177_polysilicon-1##38 9.881
R292 A0#2pin@177_polysilicon-1##38 A0#2pin@177_polysilicon-1##39 9.881
R293 A0#2pin@177_polysilicon-1##39 A0#2pin@177_polysilicon-1##40 9.881
R294 A0#2pin@177_polysilicon-1##40 A0#2pin@177_polysilicon-1##41 9.881
R295 A0#2pin@177_polysilicon-1##41 A0#2pin@177_polysilicon-1##42 9.881
R296 A0#2pin@177_polysilicon-1##42 A0#2pin@177_polysilicon-1##43 9.881
R297 A0#2pin@177_polysilicon-1##43 A0#2pin@177_polysilicon-1##44 9.881
R298 A0#2pin@177_polysilicon-1##44 A0#2pin@177_polysilicon-1##45 9.881
R299 A0#2pin@177_polysilicon-1##45 A0#2pin@177_polysilicon-1##46 9.881
R300 A0#2pin@177_polysilicon-1##46 A0#2pin@177_polysilicon-1##47 9.881
R301 A0#2pin@177_polysilicon-1##47 A0#2pin@177_polysilicon-1##48 9.881
R302 A0#2pin@177_polysilicon-1##48 A0#2pin@177_polysilicon-1##49 9.881
R303 A0#2pin@177_polysilicon-1##49 A0#2pin@177_polysilicon-1##50 9.881
R304 A0#2pin@177_polysilicon-1##50 A0#2pin@177_polysilicon-1##51 9.881
R305 A0#2pin@177_polysilicon-1##51 A0#2pin@177_polysilicon-1##52 9.881
R306 A0#2pin@177_polysilicon-1##52 A0#2pin@177_polysilicon-1##53 9.881
R307 A0#2pin@177_polysilicon-1##53 A0#2pin@177_polysilicon-1##54 9.881
R308 A0#2pin@177_polysilicon-1##54 A0#14nmos@45_poly-right 9.881
R309 net@562#5pmos@45_diff-top net@562#2pin@166_metal-1 4.81
R310 net@562#1pin@176_polysilicon-1 net@562#1pin@176_polysilicon-1##0 9.85
R311 net@562#1pin@176_polysilicon-1##0 net@562#1pin@176_polysilicon-1##1 9.85
R312 net@562#1pin@176_polysilicon-1##1 net@562#1pin@176_polysilicon-1##2 9.85
R313 net@562#1pin@176_polysilicon-1##2 net@562#1pin@176_polysilicon-1##3 9.85
R314 net@562#1pin@176_polysilicon-1##3 net@562#1pin@176_polysilicon-1##4 9.85
R315 net@562#1pin@176_polysilicon-1##4 net@562#1pin@176_polysilicon-1##5 9.85
R316 net@562#1pin@176_polysilicon-1##5 net@562#1pin@176_polysilicon-1##6 9.85
R317 net@562#1pin@176_polysilicon-1##6 net@562#1pin@176_polysilicon-1##7 9.85
R318 net@562#1pin@176_polysilicon-1##7 net@562#1pin@176_polysilicon-1##8 9.85
R319 net@562#1pin@176_polysilicon-1##8 net@562#1pin@176_polysilicon-1##9 9.85
R320 net@562#1pin@176_polysilicon-1##9 net@562#1pin@176_polysilicon-1##10 9.85
R321 net@562#1pin@176_polysilicon-1##10 net@562#1pin@176_polysilicon-1##11 9.85
R322 net@562#1pin@176_polysilicon-1##11 net@562#1pin@176_polysilicon-1##12 9.85
R323 net@562#1pin@176_polysilicon-1##12 net@562#1pin@176_polysilicon-1##13 9.85
R324 net@562#1pin@176_polysilicon-1##13 net@562#1pin@176_polysilicon-1##14 9.85
R325 net@562#1pin@176_polysilicon-1##14 net@562#1pin@176_polysilicon-1##15 9.85
R326 net@562#1pin@176_polysilicon-1##15 net@562#1pin@176_polysilicon-1##16 9.85
R327 net@562#1pin@176_polysilicon-1##16 net@562#1pin@176_polysilicon-1##17 9.85
R328 net@562#1pin@176_polysilicon-1##17 net@562#1pin@176_polysilicon-1##18 9.85
R329 net@562#1pin@176_polysilicon-1##18 net@562#1pin@176_polysilicon-1##19 9.85
R330 net@562#1pin@176_polysilicon-1##19 net@562#1pin@176_polysilicon-1##20 9.85
R331 net@562#1pin@176_polysilicon-1##20 net@562#1pin@176_polysilicon-1##21 9.85
R332 net@562#1pin@176_polysilicon-1##21 net@562#1pin@176_polysilicon-1##22 9.85
R333 net@562#1pin@176_polysilicon-1##22 net@562#1pin@176_polysilicon-1##23 9.85
R334 net@562#1pin@176_polysilicon-1##23 net@562#1pin@176_polysilicon-1##24 9.85
R335 net@562#1pin@176_polysilicon-1##24 net@562#1pin@176_polysilicon-1##25 9.85
R336 net@562#1pin@176_polysilicon-1##25 net@562#1pin@176_polysilicon-1##26 9.85
R337 net@562#1pin@176_polysilicon-1##26 net@562#1pin@176_polysilicon-1##27 9.85
R338 net@562#1pin@176_polysilicon-1##27 net@562#1pin@176_polysilicon-1##28 9.85
R339 net@562#1pin@176_polysilicon-1##28 net@562#1pin@176_polysilicon-1##29 9.85
R340 net@562#1pin@176_polysilicon-1##29 net@562#1pin@176_polysilicon-1##30 9.85
R341 net@562#1pin@176_polysilicon-1##30 net@562#1pin@176_polysilicon-1##31 9.85
R342 net@562#1pin@176_polysilicon-1##31 net@562#1pin@176_polysilicon-1##32 9.85
R343 net@562#1pin@176_polysilicon-1##32 net@562#1pin@176_polysilicon-1##33 9.85
R344 net@562#1pin@176_polysilicon-1##33 net@562#1pin@176_polysilicon-1##34 9.85
R345 net@562#1pin@176_polysilicon-1##34 net@562#1pin@176_polysilicon-1##35 9.85
R346 net@562#1pin@176_polysilicon-1##35 net@562#1pin@176_polysilicon-1##36 9.85
R347 net@562#1pin@176_polysilicon-1##36 net@562#1pin@176_polysilicon-1##37 9.85
R348 net@562#1pin@176_polysilicon-1##37 net@562#1pin@176_polysilicon-1##38 9.85
R349 net@562#1pin@176_polysilicon-1##38 net@562#1pin@176_polysilicon-1##39 9.85
R350 net@562#1pin@176_polysilicon-1##39 net@562#1pin@176_polysilicon-1##40 9.85
R351 net@562#1pin@176_polysilicon-1##40 net@562#1pin@176_polysilicon-1##41 9.85
R352 net@562#1pin@176_polysilicon-1##41 net@562#1pin@176_polysilicon-1##42 9.85
R353 net@562#1pin@176_polysilicon-1##42 net@562#1pin@176_polysilicon-1##43 9.85
R354 net@562#1pin@176_polysilicon-1##43 net@562#1pin@176_polysilicon-1##44 9.85
R355 net@562#1pin@176_polysilicon-1##44 net@562#1pin@176_polysilicon-1##45 9.85
R356 net@562#1pin@176_polysilicon-1##45 net@562#1pin@176_polysilicon-1##46 9.85
R357 net@562#1pin@176_polysilicon-1##46 net@562#1pin@176_polysilicon-1##47 9.85
R358 net@562#1pin@176_polysilicon-1##47 net@562#1pin@176_polysilicon-1##48 9.85
R359 net@562#1pin@176_polysilicon-1##48 net@562#1pin@176_polysilicon-1##49 9.85
R360 net@562#1pin@176_polysilicon-1##49 net@562#1pin@176_polysilicon-1##50 9.85
R361 net@562#1pin@176_polysilicon-1##50 net@562#1pin@176_polysilicon-1##51 9.85
R362 net@562#1pin@176_polysilicon-1##51 net@562#1pin@176_polysilicon-1##52 9.85
R363 net@562#1pin@176_polysilicon-1##52 net@562#1pin@176_polysilicon-1##53 9.85
R364 net@562#1pin@176_polysilicon-1##53 net@562#1pin@176_polysilicon-1##54 9.85
R365 net@562#1pin@176_polysilicon-1##54 net@562#1pin@176_polysilicon-1##55 9.85
R366 net@562#1pin@176_polysilicon-1##55 net@562#1pin@176_polysilicon-1##56 9.85
R367 net@562#1pin@176_polysilicon-1##56 net@562#1pin@176_polysilicon-1##57 9.85
R368 net@562#1pin@176_polysilicon-1##57 net@562#1pin@176_polysilicon-1##58 9.85
R369 net@562#1pin@176_polysilicon-1##58 net@562#1pin@176_polysilicon-1##59 9.85
R370 net@562#1pin@176_polysilicon-1##59 net@562#1pin@176_polysilicon-1##60 9.85
R371 net@562#1pin@176_polysilicon-1##60 net@562#2pin@166_metal-1 9.85
R372 B0#15pmos@44_poly-right B0#15pmos@44_poly-right##0 9.854
R373 B0#15pmos@44_poly-right##0 B0#15pmos@44_poly-right##1 9.854
R374 B0#15pmos@44_poly-right##1 B0#15pmos@44_poly-right##2 9.854
R375 B0#15pmos@44_poly-right##2 B0#15pmos@44_poly-right##3 9.854
R376 B0#15pmos@44_poly-right##3 B0#15pmos@44_poly-right##4 9.854
R377 B0#15pmos@44_poly-right##4 B0#15pmos@44_poly-right##5 9.854
R378 B0#15pmos@44_poly-right##5 B0#15pmos@44_poly-right##6 9.854
R379 B0#15pmos@44_poly-right##6 B0#15pmos@44_poly-right##7 9.854
R380 B0#15pmos@44_poly-right##7 B0#15pmos@44_poly-right##8 9.854
R381 B0#15pmos@44_poly-right##8 B0#15pmos@44_poly-right##9 9.854
R382 B0#15pmos@44_poly-right##9 B0#15pmos@44_poly-right##10 9.854
R383 B0#15pmos@44_poly-right##10 B0#15pmos@44_poly-right##11 9.854
R384 B0#15pmos@44_poly-right##11 B0#15pmos@44_poly-right##12 9.854
R385 B0#15pmos@44_poly-right##12 B0#15pmos@44_poly-right##13 9.854
R386 B0#15pmos@44_poly-right##13 B0#15pmos@44_poly-right##14 9.854
R387 B0#15pmos@44_poly-right##14 B0#15pmos@44_poly-right##15 9.854
R388 B0#15pmos@44_poly-right##15 B0#15pmos@44_poly-right##16 9.854
R389 B0#15pmos@44_poly-right##16 B0#15pmos@44_poly-right##17 9.854
R390 B0#15pmos@44_poly-right##17 B0#15pmos@44_poly-right##18 9.854
R391 B0#15pmos@44_poly-right##18 B0#15pmos@44_poly-right##19 9.854
R392 B0#15pmos@44_poly-right##19 B0#15pmos@44_poly-right##20 9.854
R393 B0#15pmos@44_poly-right##20 B0#15pmos@44_poly-right##21 9.854
R394 B0#15pmos@44_poly-right##21 B0#15pmos@44_poly-right##22 9.854
R395 B0#15pmos@44_poly-right##22 B0#15pmos@44_poly-right##23 9.854
R396 B0#15pmos@44_poly-right##23 B0#15pmos@44_poly-right##24 9.854
R397 B0#15pmos@44_poly-right##24 B0#15pmos@44_poly-right##25 9.854
R398 B0#15pmos@44_poly-right##25 B0#15pmos@44_poly-right##26 9.854
R399 B0#15pmos@44_poly-right##26 B0#15pmos@44_poly-right##27 9.854
R400 B0#15pmos@44_poly-right##27 B0#15pmos@44_poly-right##28 9.854
R401 B0#15pmos@44_poly-right##28 B0#15pmos@44_poly-right##29 9.854
R402 B0#15pmos@44_poly-right##29 B0#15pmos@44_poly-right##30 9.854
R403 B0#15pmos@44_poly-right##30 B0#15pmos@44_poly-right##31 9.854
R404 B0#15pmos@44_poly-right##31 B0#15pmos@44_poly-right##32 9.854
R405 B0#15pmos@44_poly-right##32 B0#15pmos@44_poly-right##33 9.854
R406 B0#15pmos@44_poly-right##33 B0#15pmos@44_poly-right##34 9.854
R407 B0#15pmos@44_poly-right##34 B0#15pmos@44_poly-right##35 9.854
R408 B0#15pmos@44_poly-right##35 B0#15pmos@44_poly-right##36 9.854
R409 B0#15pmos@44_poly-right##36 B0#15pmos@44_poly-right##37 9.854
R410 B0#15pmos@44_poly-right##37 B0#15pmos@44_poly-right##38 9.854
R411 B0#15pmos@44_poly-right##38 B0#15pmos@44_poly-right##39 9.854
R412 B0#15pmos@44_poly-right##39 B0#15pmos@44_poly-right##40 9.854
R413 B0#15pmos@44_poly-right##40 B0#15pmos@44_poly-right##41 9.854
R414 B0#15pmos@44_poly-right##41 B0#15pmos@44_poly-right##42 9.854
R415 B0#15pmos@44_poly-right##42 B0#15pmos@44_poly-right##43 9.854
R416 B0#15pmos@44_poly-right##43 B0#15pmos@44_poly-right##44 9.854
R417 B0#15pmos@44_poly-right##44 B0#15pmos@44_poly-right##45 9.854
R418 B0#15pmos@44_poly-right##45 B0#15pmos@44_poly-right##46 9.854
R419 B0#15pmos@44_poly-right##46 B0#15pmos@44_poly-right##47 9.854
R420 B0#15pmos@44_poly-right##47 B0#15pmos@44_poly-right##48 9.854
R421 B0#15pmos@44_poly-right##48 B0#15pmos@44_poly-right##49 9.854
R422 B0#15pmos@44_poly-right##49 B0#15pmos@44_poly-right##50 9.854
R423 B0#15pmos@44_poly-right##50 B0#15pmos@44_poly-right##51 9.854
R424 B0#15pmos@44_poly-right##51 B0#15pmos@44_poly-right##52 9.854
R425 B0#15pmos@44_poly-right##52 B0#15pmos@44_poly-right##53 9.854
R426 B0#15pmos@44_poly-right##53 B0#15pmos@44_poly-right##54 9.854
R427 B0#15pmos@44_poly-right##54 B0#10pin@167_polysilicon-1 9.854
R428 net@684 net@684#2contact@231_metal-1-metal-2 4.797
R429 A0#15nmos@40_poly-right A0#15nmos@40_poly-right##0 9.871
R430 A0#15nmos@40_poly-right##0 A0#15nmos@40_poly-right##1 9.871
R431 A0#15nmos@40_poly-right##1 A0#15nmos@40_poly-right##2 9.871
R432 A0#15nmos@40_poly-right##2 A0#15nmos@40_poly-right##3 9.871
R433 A0#15nmos@40_poly-right##3 A0#15nmos@40_poly-right##4 9.871
R434 A0#15nmos@40_poly-right##4 A0#15nmos@40_poly-right##5 9.871
R435 A0#15nmos@40_poly-right##5 A0#15nmos@40_poly-right##6 9.871
R436 A0#15nmos@40_poly-right##6 A0#15nmos@40_poly-right##7 9.871
R437 A0#15nmos@40_poly-right##7 A0#15nmos@40_poly-right##8 9.871
R438 A0#15nmos@40_poly-right##8 A0#15nmos@40_poly-right##9 9.871
R439 A0#15nmos@40_poly-right##9 A0#15nmos@40_poly-right##10 9.871
R440 A0#15nmos@40_poly-right##10 A0#15nmos@40_poly-right##11 9.871
R441 A0#15nmos@40_poly-right##11 A0#15nmos@40_poly-right##12 9.871
R442 A0#15nmos@40_poly-right##12 A0#15nmos@40_poly-right##13 9.871
R443 A0#15nmos@40_poly-right##13 A0#15nmos@40_poly-right##14 9.871
R444 A0#15nmos@40_poly-right##14 A0#15nmos@40_poly-right##15 9.871
R445 A0#15nmos@40_poly-right##15 A0#15nmos@40_poly-right##16 9.871
R446 A0#15nmos@40_poly-right##16 A0#15nmos@40_poly-right##17 9.871
R447 A0#15nmos@40_poly-right##17 A0#15nmos@40_poly-right##18 9.871
R448 A0#15nmos@40_poly-right##18 A0#15nmos@40_poly-right##19 9.871
R449 A0#15nmos@40_poly-right##19 A0#15nmos@40_poly-right##20 9.871
R450 A0#15nmos@40_poly-right##20 A0#15nmos@40_poly-right##21 9.871
R451 A0#15nmos@40_poly-right##21 A0#15nmos@40_poly-right##22 9.871
R452 A0#15nmos@40_poly-right##22 A0#15nmos@40_poly-right##23 9.871
R453 A0#15nmos@40_poly-right##23 A0#15nmos@40_poly-right##24 9.871
R454 A0#15nmos@40_poly-right##24 A0#15nmos@40_poly-right##25 9.871
R455 A0#15nmos@40_poly-right##25 A0#15nmos@40_poly-right##26 9.871
R456 A0#15nmos@40_poly-right##26 A0#15nmos@40_poly-right##27 9.871
R457 A0#15nmos@40_poly-right##27 A0#15nmos@40_poly-right##28 9.871
R458 A0#15nmos@40_poly-right##28 A0#15nmos@40_poly-right##29 9.871
R459 A0#15nmos@40_poly-right##29 A0#15nmos@40_poly-right##30 9.871
R460 A0#15nmos@40_poly-right##30 A0#15nmos@40_poly-right##31 9.871
R461 A0#15nmos@40_poly-right##31 A0#15nmos@40_poly-right##32 9.871
R462 A0#15nmos@40_poly-right##32 A0#15nmos@40_poly-right##33 9.871
R463 A0#15nmos@40_poly-right##33 A0#15nmos@40_poly-right##34 9.871
R464 A0#15nmos@40_poly-right##34 A0#15nmos@40_poly-right##35 9.871
R465 A0#15nmos@40_poly-right##35 A0#15nmos@40_poly-right##36 9.871
R466 A0#15nmos@40_poly-right##36 A0#15nmos@40_poly-right##37 9.871
R467 A0#15nmos@40_poly-right##37 A0#15nmos@40_poly-right##38 9.871
R468 A0#15nmos@40_poly-right##38 A0#15nmos@40_poly-right##39 9.871
R469 A0#15nmos@40_poly-right##39 A0#15nmos@40_poly-right##40 9.871
R470 A0#15nmos@40_poly-right##40 A0#15nmos@40_poly-right##41 9.871
R471 A0#15nmos@40_poly-right##41 A0#15nmos@40_poly-right##42 9.871
R472 A0#15nmos@40_poly-right##42 A0#15nmos@40_poly-right##43 9.871
R473 A0#15nmos@40_poly-right##43 A0#15nmos@40_poly-right##44 9.871
R474 A0#15nmos@40_poly-right##44 A0#15nmos@40_poly-right##45 9.871
R475 A0#15nmos@40_poly-right##45 A0#15nmos@40_poly-right##46 9.871
R476 A0#15nmos@40_poly-right##46 A0#15nmos@40_poly-right##47 9.871
R477 A0#15nmos@40_poly-right##47 A0#15nmos@40_poly-right##48 9.871
R478 A0#15nmos@40_poly-right##48 A0#15nmos@40_poly-right##49 9.871
R479 A0#15nmos@40_poly-right##49 A0#15nmos@40_poly-right##50 9.871
R480 A0#15nmos@40_poly-right##50 A0#15nmos@40_poly-right##51 9.871
R481 A0#15nmos@40_poly-right##51 A0#15nmos@40_poly-right##52 9.871
R482 A0#15nmos@40_poly-right##52 A0#15nmos@40_poly-right##53 9.871
R483 A0#15nmos@40_poly-right##53 A0#15nmos@40_poly-right##54 9.871
R484 A0#15nmos@40_poly-right##54 A0#15nmos@40_poly-right##55 9.871
R485 A0#15nmos@40_poly-right##55 A0#10pmos@40_poly-left 9.871
R486 net@562#7pmos@41_poly-left net@562#7pmos@41_poly-left##0 9.871
R487 net@562#7pmos@41_poly-left##0 net@562#7pmos@41_poly-left##1 9.871
R488 net@562#7pmos@41_poly-left##1 net@562#7pmos@41_poly-left##2 9.871
R489 net@562#7pmos@41_poly-left##2 net@562#7pmos@41_poly-left##3 9.871
R490 net@562#7pmos@41_poly-left##3 net@562#7pmos@41_poly-left##4 9.871
R491 net@562#7pmos@41_poly-left##4 net@562#7pmos@41_poly-left##5 9.871
R492 net@562#7pmos@41_poly-left##5 net@562#7pmos@41_poly-left##6 9.871
R493 net@562#7pmos@41_poly-left##6 net@562#7pmos@41_poly-left##7 9.871
R494 net@562#7pmos@41_poly-left##7 net@562#7pmos@41_poly-left##8 9.871
R495 net@562#7pmos@41_poly-left##8 net@562#7pmos@41_poly-left##9 9.871
R496 net@562#7pmos@41_poly-left##9 net@562#7pmos@41_poly-left##10 9.871
R497 net@562#7pmos@41_poly-left##10 net@562#7pmos@41_poly-left##11 9.871
R498 net@562#7pmos@41_poly-left##11 net@562#7pmos@41_poly-left##12 9.871
R499 net@562#7pmos@41_poly-left##12 net@562#7pmos@41_poly-left##13 9.871
R500 net@562#7pmos@41_poly-left##13 net@562#7pmos@41_poly-left##14 9.871
R501 net@562#7pmos@41_poly-left##14 net@562#7pmos@41_poly-left##15 9.871
R502 net@562#7pmos@41_poly-left##15 net@562#7pmos@41_poly-left##16 9.871
R503 net@562#7pmos@41_poly-left##16 net@562#7pmos@41_poly-left##17 9.871
R504 net@562#7pmos@41_poly-left##17 net@562#7pmos@41_poly-left##18 9.871
R505 net@562#7pmos@41_poly-left##18 net@562#7pmos@41_poly-left##19 9.871
R506 net@562#7pmos@41_poly-left##19 net@562#7pmos@41_poly-left##20 9.871
R507 net@562#7pmos@41_poly-left##20 net@562#7pmos@41_poly-left##21 9.871
R508 net@562#7pmos@41_poly-left##21 net@562#7pmos@41_poly-left##22 9.871
R509 net@562#7pmos@41_poly-left##22 net@562#7pmos@41_poly-left##23 9.871
R510 net@562#7pmos@41_poly-left##23 net@562#7pmos@41_poly-left##24 9.871
R511 net@562#7pmos@41_poly-left##24 net@562#7pmos@41_poly-left##25 9.871
R512 net@562#7pmos@41_poly-left##25 net@562#7pmos@41_poly-left##26 9.871
R513 net@562#7pmos@41_poly-left##26 net@562#7pmos@41_poly-left##27 9.871
R514 net@562#7pmos@41_poly-left##27 net@562#7pmos@41_poly-left##28 9.871
R515 net@562#7pmos@41_poly-left##28 net@562#7pmos@41_poly-left##29 9.871
R516 net@562#7pmos@41_poly-left##29 net@562#7pmos@41_poly-left##30 9.871
R517 net@562#7pmos@41_poly-left##30 net@562#7pmos@41_poly-left##31 9.871
R518 net@562#7pmos@41_poly-left##31 net@562#7pmos@41_poly-left##32 9.871
R519 net@562#7pmos@41_poly-left##32 net@562#7pmos@41_poly-left##33 9.871
R520 net@562#7pmos@41_poly-left##33 net@562#7pmos@41_poly-left##34 9.871
R521 net@562#7pmos@41_poly-left##34 net@562#7pmos@41_poly-left##35 9.871
R522 net@562#7pmos@41_poly-left##35 net@562#7pmos@41_poly-left##36 9.871
R523 net@562#7pmos@41_poly-left##36 net@562#7pmos@41_poly-left##37 9.871
R524 net@562#7pmos@41_poly-left##37 net@562#7pmos@41_poly-left##38 9.871
R525 net@562#7pmos@41_poly-left##38 net@562#7pmos@41_poly-left##39 9.871
R526 net@562#7pmos@41_poly-left##39 net@562#7pmos@41_poly-left##40 9.871
R527 net@562#7pmos@41_poly-left##40 net@562#7pmos@41_poly-left##41 9.871
R528 net@562#7pmos@41_poly-left##41 net@562#7pmos@41_poly-left##42 9.871
R529 net@562#7pmos@41_poly-left##42 net@562#7pmos@41_poly-left##43 9.871
R530 net@562#7pmos@41_poly-left##43 net@562#7pmos@41_poly-left##44 9.871
R531 net@562#7pmos@41_poly-left##44 net@562#7pmos@41_poly-left##45 9.871
R532 net@562#7pmos@41_poly-left##45 net@562#7pmos@41_poly-left##46 9.871
R533 net@562#7pmos@41_poly-left##46 net@562#7pmos@41_poly-left##47 9.871
R534 net@562#7pmos@41_poly-left##47 net@562#7pmos@41_poly-left##48 9.871
R535 net@562#7pmos@41_poly-left##48 net@562#7pmos@41_poly-left##49 9.871
R536 net@562#7pmos@41_poly-left##49 net@562#7pmos@41_poly-left##50 9.871
R537 net@562#7pmos@41_poly-left##50 net@562#7pmos@41_poly-left##51 9.871
R538 net@562#7pmos@41_poly-left##51 net@562#7pmos@41_poly-left##52 9.871
R539 net@562#7pmos@41_poly-left##52 net@562#7pmos@41_poly-left##53 9.871
R540 net@562#7pmos@41_poly-left##53 net@562#7pmos@41_poly-left##54 9.871
R541 net@562#7pmos@41_poly-left##54 net@562#7pmos@41_poly-left##55 9.871
R542 net@562#7pmos@41_poly-left##55 net@562#11nmos@41_poly-right 9.871
R543 B0#16pmos@42_poly-right B0#16pmos@42_poly-right##0 9.871
R544 B0#16pmos@42_poly-right##0 B0#16pmos@42_poly-right##1 9.871
R545 B0#16pmos@42_poly-right##1 B0#16pmos@42_poly-right##2 9.871
R546 B0#16pmos@42_poly-right##2 B0#16pmos@42_poly-right##3 9.871
R547 B0#16pmos@42_poly-right##3 B0#16pmos@42_poly-right##4 9.871
R548 B0#16pmos@42_poly-right##4 B0#16pmos@42_poly-right##5 9.871
R549 B0#16pmos@42_poly-right##5 B0#16pmos@42_poly-right##6 9.871
R550 B0#16pmos@42_poly-right##6 B0#16pmos@42_poly-right##7 9.871
R551 B0#16pmos@42_poly-right##7 B0#16pmos@42_poly-right##8 9.871
R552 B0#16pmos@42_poly-right##8 B0#16pmos@42_poly-right##9 9.871
R553 B0#16pmos@42_poly-right##9 B0#16pmos@42_poly-right##10 9.871
R554 B0#16pmos@42_poly-right##10 B0#16pmos@42_poly-right##11 9.871
R555 B0#16pmos@42_poly-right##11 B0#16pmos@42_poly-right##12 9.871
R556 B0#16pmos@42_poly-right##12 B0#16pmos@42_poly-right##13 9.871
R557 B0#16pmos@42_poly-right##13 B0#16pmos@42_poly-right##14 9.871
R558 B0#16pmos@42_poly-right##14 B0#16pmos@42_poly-right##15 9.871
R559 B0#16pmos@42_poly-right##15 B0#16pmos@42_poly-right##16 9.871
R560 B0#16pmos@42_poly-right##16 B0#16pmos@42_poly-right##17 9.871
R561 B0#16pmos@42_poly-right##17 B0#16pmos@42_poly-right##18 9.871
R562 B0#16pmos@42_poly-right##18 B0#16pmos@42_poly-right##19 9.871
R563 B0#16pmos@42_poly-right##19 B0#16pmos@42_poly-right##20 9.871
R564 B0#16pmos@42_poly-right##20 B0#16pmos@42_poly-right##21 9.871
R565 B0#16pmos@42_poly-right##21 B0#16pmos@42_poly-right##22 9.871
R566 B0#16pmos@42_poly-right##22 B0#16pmos@42_poly-right##23 9.871
R567 B0#16pmos@42_poly-right##23 B0#16pmos@42_poly-right##24 9.871
R568 B0#16pmos@42_poly-right##24 B0#16pmos@42_poly-right##25 9.871
R569 B0#16pmos@42_poly-right##25 B0#16pmos@42_poly-right##26 9.871
R570 B0#16pmos@42_poly-right##26 B0#16pmos@42_poly-right##27 9.871
R571 B0#16pmos@42_poly-right##27 B0#16pmos@42_poly-right##28 9.871
R572 B0#16pmos@42_poly-right##28 B0#16pmos@42_poly-right##29 9.871
R573 B0#16pmos@42_poly-right##29 B0#16pmos@42_poly-right##30 9.871
R574 B0#16pmos@42_poly-right##30 B0#16pmos@42_poly-right##31 9.871
R575 B0#16pmos@42_poly-right##31 B0#16pmos@42_poly-right##32 9.871
R576 B0#16pmos@42_poly-right##32 B0#16pmos@42_poly-right##33 9.871
R577 B0#16pmos@42_poly-right##33 B0#16pmos@42_poly-right##34 9.871
R578 B0#16pmos@42_poly-right##34 B0#16pmos@42_poly-right##35 9.871
R579 B0#16pmos@42_poly-right##35 B0#16pmos@42_poly-right##36 9.871
R580 B0#16pmos@42_poly-right##36 B0#16pmos@42_poly-right##37 9.871
R581 B0#16pmos@42_poly-right##37 B0#16pmos@42_poly-right##38 9.871
R582 B0#16pmos@42_poly-right##38 B0#16pmos@42_poly-right##39 9.871
R583 B0#16pmos@42_poly-right##39 B0#16pmos@42_poly-right##40 9.871
R584 B0#16pmos@42_poly-right##40 B0#16pmos@42_poly-right##41 9.871
R585 B0#16pmos@42_poly-right##41 B0#16pmos@42_poly-right##42 9.871
R586 B0#16pmos@42_poly-right##42 B0#16pmos@42_poly-right##43 9.871
R587 B0#16pmos@42_poly-right##43 B0#16pmos@42_poly-right##44 9.871
R588 B0#16pmos@42_poly-right##44 B0#16pmos@42_poly-right##45 9.871
R589 B0#16pmos@42_poly-right##45 B0#16pmos@42_poly-right##46 9.871
R590 B0#16pmos@42_poly-right##46 B0#16pmos@42_poly-right##47 9.871
R591 B0#16pmos@42_poly-right##47 B0#16pmos@42_poly-right##48 9.871
R592 B0#16pmos@42_poly-right##48 B0#16pmos@42_poly-right##49 9.871
R593 B0#16pmos@42_poly-right##49 B0#16pmos@42_poly-right##50 9.871
R594 B0#16pmos@42_poly-right##50 B0#16pmos@42_poly-right##51 9.871
R595 B0#16pmos@42_poly-right##51 B0#16pmos@42_poly-right##52 9.871
R596 B0#16pmos@42_poly-right##52 B0#16pmos@42_poly-right##53 9.871
R597 B0#16pmos@42_poly-right##53 B0#16pmos@42_poly-right##54 9.871
R598 B0#16pmos@42_poly-right##54 B0#16pmos@42_poly-right##55 9.871
R599 B0#16pmos@42_poly-right##55 B0#14nmos@42_poly-left 9.871
R600 net@684#14pmos@43_poly-right net@684#14pmos@43_poly-right##0 9.871
R601 net@684#14pmos@43_poly-right##0 net@684#14pmos@43_poly-right##1 9.871
R602 net@684#14pmos@43_poly-right##1 net@684#14pmos@43_poly-right##2 9.871
R603 net@684#14pmos@43_poly-right##2 net@684#14pmos@43_poly-right##3 9.871
R604 net@684#14pmos@43_poly-right##3 net@684#14pmos@43_poly-right##4 9.871
R605 net@684#14pmos@43_poly-right##4 net@684#14pmos@43_poly-right##5 9.871
R606 net@684#14pmos@43_poly-right##5 net@684#14pmos@43_poly-right##6 9.871
R607 net@684#14pmos@43_poly-right##6 net@684#14pmos@43_poly-right##7 9.871
R608 net@684#14pmos@43_poly-right##7 net@684#14pmos@43_poly-right##8 9.871
R609 net@684#14pmos@43_poly-right##8 net@684#14pmos@43_poly-right##9 9.871
R610 net@684#14pmos@43_poly-right##9 net@684#14pmos@43_poly-right##10 9.871
R611 net@684#14pmos@43_poly-right##10 net@684#14pmos@43_poly-right##11 9.871
R612 net@684#14pmos@43_poly-right##11 net@684#14pmos@43_poly-right##12 9.871
R613 net@684#14pmos@43_poly-right##12 net@684#14pmos@43_poly-right##13 9.871
R614 net@684#14pmos@43_poly-right##13 net@684#14pmos@43_poly-right##14 9.871
R615 net@684#14pmos@43_poly-right##14 net@684#14pmos@43_poly-right##15 9.871
R616 net@684#14pmos@43_poly-right##15 net@684#14pmos@43_poly-right##16 9.871
R617 net@684#14pmos@43_poly-right##16 net@684#14pmos@43_poly-right##17 9.871
R618 net@684#14pmos@43_poly-right##17 net@684#14pmos@43_poly-right##18 9.871
R619 net@684#14pmos@43_poly-right##18 net@684#14pmos@43_poly-right##19 9.871
R620 net@684#14pmos@43_poly-right##19 net@684#14pmos@43_poly-right##20 9.871
R621 net@684#14pmos@43_poly-right##20 net@684#14pmos@43_poly-right##21 9.871
R622 net@684#14pmos@43_poly-right##21 net@684#14pmos@43_poly-right##22 9.871
R623 net@684#14pmos@43_poly-right##22 net@684#14pmos@43_poly-right##23 9.871
R624 net@684#14pmos@43_poly-right##23 net@684#14pmos@43_poly-right##24 9.871
R625 net@684#14pmos@43_poly-right##24 net@684#14pmos@43_poly-right##25 9.871
R626 net@684#14pmos@43_poly-right##25 net@684#14pmos@43_poly-right##26 9.871
R627 net@684#14pmos@43_poly-right##26 net@684#14pmos@43_poly-right##27 9.871
R628 net@684#14pmos@43_poly-right##27 net@684#14pmos@43_poly-right##28 9.871
R629 net@684#14pmos@43_poly-right##28 net@684#14pmos@43_poly-right##29 9.871
R630 net@684#14pmos@43_poly-right##29 net@684#14pmos@43_poly-right##30 9.871
R631 net@684#14pmos@43_poly-right##30 net@684#14pmos@43_poly-right##31 9.871
R632 net@684#14pmos@43_poly-right##31 net@684#14pmos@43_poly-right##32 9.871
R633 net@684#14pmos@43_poly-right##32 net@684#14pmos@43_poly-right##33 9.871
R634 net@684#14pmos@43_poly-right##33 net@684#14pmos@43_poly-right##34 9.871
R635 net@684#14pmos@43_poly-right##34 net@684#14pmos@43_poly-right##35 9.871
R636 net@684#14pmos@43_poly-right##35 net@684#14pmos@43_poly-right##36 9.871
R637 net@684#14pmos@43_poly-right##36 net@684#14pmos@43_poly-right##37 9.871
R638 net@684#14pmos@43_poly-right##37 net@684#14pmos@43_poly-right##38 9.871
R639 net@684#14pmos@43_poly-right##38 net@684#14pmos@43_poly-right##39 9.871
R640 net@684#14pmos@43_poly-right##39 net@684#14pmos@43_poly-right##40 9.871
R641 net@684#14pmos@43_poly-right##40 net@684#14pmos@43_poly-right##41 9.871
R642 net@684#14pmos@43_poly-right##41 net@684#14pmos@43_poly-right##42 9.871
R643 net@684#14pmos@43_poly-right##42 net@684#14pmos@43_poly-right##43 9.871
R644 net@684#14pmos@43_poly-right##43 net@684#14pmos@43_poly-right##44 9.871
R645 net@684#14pmos@43_poly-right##44 net@684#14pmos@43_poly-right##45 9.871
R646 net@684#14pmos@43_poly-right##45 net@684#14pmos@43_poly-right##46 9.871
R647 net@684#14pmos@43_poly-right##46 net@684#14pmos@43_poly-right##47 9.871
R648 net@684#14pmos@43_poly-right##47 net@684#14pmos@43_poly-right##48 9.871
R649 net@684#14pmos@43_poly-right##48 net@684#14pmos@43_poly-right##49 9.871
R650 net@684#14pmos@43_poly-right##49 net@684#14pmos@43_poly-right##50 9.871
R651 net@684#14pmos@43_poly-right##50 net@684#14pmos@43_poly-right##51 9.871
R652 net@684#14pmos@43_poly-right##51 net@684#14pmos@43_poly-right##52 9.871
R653 net@684#14pmos@43_poly-right##52 net@684#14pmos@43_poly-right##53 9.871
R654 net@684#14pmos@43_poly-right##53 net@684#14pmos@43_poly-right##54 9.871
R655 net@684#14pmos@43_poly-right##54 net@684#14pmos@43_poly-right##55 9.871
R656 net@684#14pmos@43_poly-right##55 net@684#9nmos@43_poly-left 9.871
R657 net@676#2contact@256_metal-1-polysilicon-1 net@676 4.706
R658 net@676#12pmos@46_poly-right net@676#12pmos@46_poly-right##0 9.864
R659 net@676#12pmos@46_poly-right##0 net@676#12pmos@46_poly-right##1 9.864
R660 net@676#12pmos@46_poly-right##1 net@676#12pmos@46_poly-right##2 9.864
R661 net@676#12pmos@46_poly-right##2 net@676#12pmos@46_poly-right##3 9.864
R662 net@676#12pmos@46_poly-right##3 net@676#12pmos@46_poly-right##4 9.864
R663 net@676#12pmos@46_poly-right##4 net@676#12pmos@46_poly-right##5 9.864
R664 net@676#12pmos@46_poly-right##5 net@676#12pmos@46_poly-right##6 9.864
R665 net@676#12pmos@46_poly-right##6 net@676#12pmos@46_poly-right##7 9.864
R666 net@676#12pmos@46_poly-right##7 net@676#12pmos@46_poly-right##8 9.864
R667 net@676#12pmos@46_poly-right##8 net@676#12pmos@46_poly-right##9 9.864
R668 net@676#12pmos@46_poly-right##9 net@676#12pmos@46_poly-right##10 9.864
R669 net@676#12pmos@46_poly-right##10 net@676#12pmos@46_poly-right##11 9.864
R670 net@676#12pmos@46_poly-right##11 net@676#12pmos@46_poly-right##12 9.864
R671 net@676#12pmos@46_poly-right##12 net@676#12pmos@46_poly-right##13 9.864
R672 net@676#12pmos@46_poly-right##13 net@676#12pmos@46_poly-right##14 9.864
R673 net@676#12pmos@46_poly-right##14 net@676#12pmos@46_poly-right##15 9.864
R674 net@676#12pmos@46_poly-right##15 net@676#12pmos@46_poly-right##16 9.864
R675 net@676#12pmos@46_poly-right##16 net@676#12pmos@46_poly-right##17 9.864
R676 net@676#12pmos@46_poly-right##17 net@676#12pmos@46_poly-right##18 9.864
R677 net@676#12pmos@46_poly-right##18 net@676#12pmos@46_poly-right##19 9.864
R678 net@676#12pmos@46_poly-right##19 net@676#12pmos@46_poly-right##20 9.864
R679 net@676#12pmos@46_poly-right##20 net@676#12pmos@46_poly-right##21 9.864
R680 net@676#12pmos@46_poly-right##21 net@676#12pmos@46_poly-right##22 9.864
R681 net@676#12pmos@46_poly-right##22 net@676#12pmos@46_poly-right##23 9.864
R682 net@676#12pmos@46_poly-right##23 net@676#12pmos@46_poly-right##24 9.864
R683 net@676#12pmos@46_poly-right##24 net@676#12pmos@46_poly-right##25 9.864
R684 net@676#12pmos@46_poly-right##25 net@676#12pmos@46_poly-right##26 9.864
R685 net@676#12pmos@46_poly-right##26 net@676#12pmos@46_poly-right##27 9.864
R686 net@676#12pmos@46_poly-right##27 net@676#12pmos@46_poly-right##28 9.864
R687 net@676#12pmos@46_poly-right##28 net@676#12pmos@46_poly-right##29 9.864
R688 net@676#12pmos@46_poly-right##29 net@676#12pmos@46_poly-right##30 9.864
R689 net@676#12pmos@46_poly-right##30 net@676#12pmos@46_poly-right##31 9.864
R690 net@676#12pmos@46_poly-right##31 net@676#12pmos@46_poly-right##32 9.864
R691 net@676#12pmos@46_poly-right##32 net@676#12pmos@46_poly-right##33 9.864
R692 net@676#12pmos@46_poly-right##33 net@676#12pmos@46_poly-right##34 9.864
R693 net@676#12pmos@46_poly-right##34 net@676#12pmos@46_poly-right##35 9.864
R694 net@676#12pmos@46_poly-right##35 net@676#12pmos@46_poly-right##36 9.864
R695 net@676#12pmos@46_poly-right##36 net@676#12pmos@46_poly-right##37 9.864
R696 net@676#12pmos@46_poly-right##37 net@676#12pmos@46_poly-right##38 9.864
R697 net@676#12pmos@46_poly-right##38 net@676#12pmos@46_poly-right##39 9.864
R698 net@676#12pmos@46_poly-right##39 net@676#12pmos@46_poly-right##40 9.864
R699 net@676#12pmos@46_poly-right##40 net@676#12pmos@46_poly-right##41 9.864
R700 net@676#12pmos@46_poly-right##41 net@676#12pmos@46_poly-right##42 9.864
R701 net@676#12pmos@46_poly-right##42 net@676#12pmos@46_poly-right##43 9.864
R702 net@676#12pmos@46_poly-right##43 net@676#12pmos@46_poly-right##44 9.864
R703 net@676#12pmos@46_poly-right##44 net@676#12pmos@46_poly-right##45 9.864
R704 net@676#12pmos@46_poly-right##45 net@676#12pmos@46_poly-right##46 9.864
R705 net@676#12pmos@46_poly-right##46 net@676#12pmos@46_poly-right##47 9.864
R706 net@676#12pmos@46_poly-right##47 net@676#12pmos@46_poly-right##48 9.864
R707 net@676#12pmos@46_poly-right##48 net@676#12pmos@46_poly-right##49 9.864
R708 net@676#12pmos@46_poly-right##49 net@676#12pmos@46_poly-right##50 9.864
R709 net@676#12pmos@46_poly-right##50 net@676#12pmos@46_poly-right##51 9.864
R710 net@676#12pmos@46_poly-right##51 net@676#12pmos@46_poly-right##52 9.864
R711 net@676#12pmos@46_poly-right##52 net@676#12pmos@46_poly-right##53 9.864
R712 net@676#12pmos@46_poly-right##53 net@676#5pin@169_polysilicon-1 9.864
R713 XOR1_to_NAND1#22pmos@46_diff-top XOR1_to_NAND1#1contact@309_metal-1-metal-2 4.862
R714 XOR1_to_NAND1#3pin@203_polysilicon-1 XOR1_to_NAND1#3pin@203_polysilicon-1##0 9.881
R715 XOR1_to_NAND1#3pin@203_polysilicon-1##0 XOR1_to_NAND1#3pin@203_polysilicon-1##1 9.881
R716 XOR1_to_NAND1#3pin@203_polysilicon-1##1 XOR1_to_NAND1#3pin@203_polysilicon-1##2 9.881
R717 XOR1_to_NAND1#3pin@203_polysilicon-1##2 XOR1_to_NAND1#3pin@203_polysilicon-1##3 9.881
R718 XOR1_to_NAND1#3pin@203_polysilicon-1##3 XOR1_to_NAND1#3pin@203_polysilicon-1##4 9.881
R719 XOR1_to_NAND1#3pin@203_polysilicon-1##4 XOR1_to_NAND1#3pin@203_polysilicon-1##5 9.881
R720 XOR1_to_NAND1#3pin@203_polysilicon-1##5 XOR1_to_NAND1#3pin@203_polysilicon-1##6 9.881
R721 XOR1_to_NAND1#3pin@203_polysilicon-1##6 XOR1_to_NAND1#3pin@203_polysilicon-1##7 9.881
R722 XOR1_to_NAND1#3pin@203_polysilicon-1##7 XOR1_to_NAND1#3pin@203_polysilicon-1##8 9.881
R723 XOR1_to_NAND1#3pin@203_polysilicon-1##8 XOR1_to_NAND1#3pin@203_polysilicon-1##9 9.881
R724 XOR1_to_NAND1#3pin@203_polysilicon-1##9 XOR1_to_NAND1#3pin@203_polysilicon-1##10 9.881
R725 XOR1_to_NAND1#3pin@203_polysilicon-1##10 XOR1_to_NAND1#3pin@203_polysilicon-1##11 9.881
R726 XOR1_to_NAND1#3pin@203_polysilicon-1##11 XOR1_to_NAND1#3pin@203_polysilicon-1##12 9.881
R727 XOR1_to_NAND1#3pin@203_polysilicon-1##12 XOR1_to_NAND1#3pin@203_polysilicon-1##13 9.881
R728 XOR1_to_NAND1#3pin@203_polysilicon-1##13 XOR1_to_NAND1#3pin@203_polysilicon-1##14 9.881
R729 XOR1_to_NAND1#3pin@203_polysilicon-1##14 XOR1_to_NAND1#3pin@203_polysilicon-1##15 9.881
R730 XOR1_to_NAND1#3pin@203_polysilicon-1##15 XOR1_to_NAND1#3pin@203_polysilicon-1##16 9.881
R731 XOR1_to_NAND1#3pin@203_polysilicon-1##16 XOR1_to_NAND1#3pin@203_polysilicon-1##17 9.881
R732 XOR1_to_NAND1#3pin@203_polysilicon-1##17 XOR1_to_NAND1#3pin@203_polysilicon-1##18 9.881
R733 XOR1_to_NAND1#3pin@203_polysilicon-1##18 XOR1_to_NAND1#3pin@203_polysilicon-1##19 9.881
R734 XOR1_to_NAND1#3pin@203_polysilicon-1##19 XOR1_to_NAND1#3pin@203_polysilicon-1##20 9.881
R735 XOR1_to_NAND1#3pin@203_polysilicon-1##20 XOR1_to_NAND1#3pin@203_polysilicon-1##21 9.881
R736 XOR1_to_NAND1#3pin@203_polysilicon-1##21 XOR1_to_NAND1#3pin@203_polysilicon-1##22 9.881
R737 XOR1_to_NAND1#3pin@203_polysilicon-1##22 XOR1_to_NAND1#3pin@203_polysilicon-1##23 9.881
R738 XOR1_to_NAND1#3pin@203_polysilicon-1##23 XOR1_to_NAND1#3pin@203_polysilicon-1##24 9.881
R739 XOR1_to_NAND1#3pin@203_polysilicon-1##24 XOR1_to_NAND1#3pin@203_polysilicon-1##25 9.881
R740 XOR1_to_NAND1#3pin@203_polysilicon-1##25 XOR1_to_NAND1#3pin@203_polysilicon-1##26 9.881
R741 XOR1_to_NAND1#3pin@203_polysilicon-1##26 XOR1_to_NAND1#3pin@203_polysilicon-1##27 9.881
R742 XOR1_to_NAND1#3pin@203_polysilicon-1##27 XOR1_to_NAND1#3pin@203_polysilicon-1##28 9.881
R743 XOR1_to_NAND1#3pin@203_polysilicon-1##28 XOR1_to_NAND1#3pin@203_polysilicon-1##29 9.881
R744 XOR1_to_NAND1#3pin@203_polysilicon-1##29 XOR1_to_NAND1#3pin@203_polysilicon-1##30 9.881
R745 XOR1_to_NAND1#3pin@203_polysilicon-1##30 XOR1_to_NAND1#3pin@203_polysilicon-1##31 9.881
R746 XOR1_to_NAND1#3pin@203_polysilicon-1##31 XOR1_to_NAND1#3pin@203_polysilicon-1##32 9.881
R747 XOR1_to_NAND1#3pin@203_polysilicon-1##32 XOR1_to_NAND1#3pin@203_polysilicon-1##33 9.881
R748 XOR1_to_NAND1#3pin@203_polysilicon-1##33 XOR1_to_NAND1#3pin@203_polysilicon-1##34 9.881
R749 XOR1_to_NAND1#3pin@203_polysilicon-1##34 XOR1_to_NAND1#3pin@203_polysilicon-1##35 9.881
R750 XOR1_to_NAND1#3pin@203_polysilicon-1##35 XOR1_to_NAND1#3pin@203_polysilicon-1##36 9.881
R751 XOR1_to_NAND1#3pin@203_polysilicon-1##36 XOR1_to_NAND1#3pin@203_polysilicon-1##37 9.881
R752 XOR1_to_NAND1#3pin@203_polysilicon-1##37 XOR1_to_NAND1#3pin@203_polysilicon-1##38 9.881
R753 XOR1_to_NAND1#3pin@203_polysilicon-1##38 XOR1_to_NAND1#3pin@203_polysilicon-1##39 9.881
R754 XOR1_to_NAND1#3pin@203_polysilicon-1##39 XOR1_to_NAND1#3pin@203_polysilicon-1##40 9.881
R755 XOR1_to_NAND1#3pin@203_polysilicon-1##40 XOR1_to_NAND1#3pin@203_polysilicon-1##41 9.881
R756 XOR1_to_NAND1#3pin@203_polysilicon-1##41 XOR1_to_NAND1#3pin@203_polysilicon-1##42 9.881
R757 XOR1_to_NAND1#3pin@203_polysilicon-1##42 XOR1_to_NAND1#3pin@203_polysilicon-1##43 9.881
R758 XOR1_to_NAND1#3pin@203_polysilicon-1##43 XOR1_to_NAND1#3pin@203_polysilicon-1##44 9.881
R759 XOR1_to_NAND1#3pin@203_polysilicon-1##44 XOR1_to_NAND1#3pin@203_polysilicon-1##45 9.881
R760 XOR1_to_NAND1#3pin@203_polysilicon-1##45 XOR1_to_NAND1#3pin@203_polysilicon-1##46 9.881
R761 XOR1_to_NAND1#3pin@203_polysilicon-1##46 XOR1_to_NAND1#3pin@203_polysilicon-1##47 9.881
R762 XOR1_to_NAND1#3pin@203_polysilicon-1##47 XOR1_to_NAND1#3pin@203_polysilicon-1##48 9.881
R763 XOR1_to_NAND1#3pin@203_polysilicon-1##48 XOR1_to_NAND1#3pin@203_polysilicon-1##49 9.881
R764 XOR1_to_NAND1#3pin@203_polysilicon-1##49 XOR1_to_NAND1#3pin@203_polysilicon-1##50 9.881
R765 XOR1_to_NAND1#3pin@203_polysilicon-1##50 XOR1_to_NAND1#3pin@203_polysilicon-1##51 9.881
R766 XOR1_to_NAND1#3pin@203_polysilicon-1##51 XOR1_to_NAND1#3pin@203_polysilicon-1##52 9.881
R767 XOR1_to_NAND1#3pin@203_polysilicon-1##52 XOR1_to_NAND1#3pin@203_polysilicon-1##53 9.881
R768 XOR1_to_NAND1#3pin@203_polysilicon-1##53 XOR1_to_NAND1#3pin@203_polysilicon-1##54 9.881
R769 XOR1_to_NAND1#3pin@203_polysilicon-1##54 XOR1_to_NAND1#24nmos@52_poly-right 9.881
R770 net@564#5pmos@52_diff-top net@564#2pin@192_metal-1 4.81
R771 net@564#1pin@202_polysilicon-1 net@564#1pin@202_polysilicon-1##0 9.85
R772 net@564#1pin@202_polysilicon-1##0 net@564#1pin@202_polysilicon-1##1 9.85
R773 net@564#1pin@202_polysilicon-1##1 net@564#1pin@202_polysilicon-1##2 9.85
R774 net@564#1pin@202_polysilicon-1##2 net@564#1pin@202_polysilicon-1##3 9.85
R775 net@564#1pin@202_polysilicon-1##3 net@564#1pin@202_polysilicon-1##4 9.85
R776 net@564#1pin@202_polysilicon-1##4 net@564#1pin@202_polysilicon-1##5 9.85
R777 net@564#1pin@202_polysilicon-1##5 net@564#1pin@202_polysilicon-1##6 9.85
R778 net@564#1pin@202_polysilicon-1##6 net@564#1pin@202_polysilicon-1##7 9.85
R779 net@564#1pin@202_polysilicon-1##7 net@564#1pin@202_polysilicon-1##8 9.85
R780 net@564#1pin@202_polysilicon-1##8 net@564#1pin@202_polysilicon-1##9 9.85
R781 net@564#1pin@202_polysilicon-1##9 net@564#1pin@202_polysilicon-1##10 9.85
R782 net@564#1pin@202_polysilicon-1##10 net@564#1pin@202_polysilicon-1##11 9.85
R783 net@564#1pin@202_polysilicon-1##11 net@564#1pin@202_polysilicon-1##12 9.85
R784 net@564#1pin@202_polysilicon-1##12 net@564#1pin@202_polysilicon-1##13 9.85
R785 net@564#1pin@202_polysilicon-1##13 net@564#1pin@202_polysilicon-1##14 9.85
R786 net@564#1pin@202_polysilicon-1##14 net@564#1pin@202_polysilicon-1##15 9.85
R787 net@564#1pin@202_polysilicon-1##15 net@564#1pin@202_polysilicon-1##16 9.85
R788 net@564#1pin@202_polysilicon-1##16 net@564#1pin@202_polysilicon-1##17 9.85
R789 net@564#1pin@202_polysilicon-1##17 net@564#1pin@202_polysilicon-1##18 9.85
R790 net@564#1pin@202_polysilicon-1##18 net@564#1pin@202_polysilicon-1##19 9.85
R791 net@564#1pin@202_polysilicon-1##19 net@564#1pin@202_polysilicon-1##20 9.85
R792 net@564#1pin@202_polysilicon-1##20 net@564#1pin@202_polysilicon-1##21 9.85
R793 net@564#1pin@202_polysilicon-1##21 net@564#1pin@202_polysilicon-1##22 9.85
R794 net@564#1pin@202_polysilicon-1##22 net@564#1pin@202_polysilicon-1##23 9.85
R795 net@564#1pin@202_polysilicon-1##23 net@564#1pin@202_polysilicon-1##24 9.85
R796 net@564#1pin@202_polysilicon-1##24 net@564#1pin@202_polysilicon-1##25 9.85
R797 net@564#1pin@202_polysilicon-1##25 net@564#1pin@202_polysilicon-1##26 9.85
R798 net@564#1pin@202_polysilicon-1##26 net@564#1pin@202_polysilicon-1##27 9.85
R799 net@564#1pin@202_polysilicon-1##27 net@564#1pin@202_polysilicon-1##28 9.85
R800 net@564#1pin@202_polysilicon-1##28 net@564#1pin@202_polysilicon-1##29 9.85
R801 net@564#1pin@202_polysilicon-1##29 net@564#1pin@202_polysilicon-1##30 9.85
R802 net@564#1pin@202_polysilicon-1##30 net@564#1pin@202_polysilicon-1##31 9.85
R803 net@564#1pin@202_polysilicon-1##31 net@564#1pin@202_polysilicon-1##32 9.85
R804 net@564#1pin@202_polysilicon-1##32 net@564#1pin@202_polysilicon-1##33 9.85
R805 net@564#1pin@202_polysilicon-1##33 net@564#1pin@202_polysilicon-1##34 9.85
R806 net@564#1pin@202_polysilicon-1##34 net@564#1pin@202_polysilicon-1##35 9.85
R807 net@564#1pin@202_polysilicon-1##35 net@564#1pin@202_polysilicon-1##36 9.85
R808 net@564#1pin@202_polysilicon-1##36 net@564#1pin@202_polysilicon-1##37 9.85
R809 net@564#1pin@202_polysilicon-1##37 net@564#1pin@202_polysilicon-1##38 9.85
R810 net@564#1pin@202_polysilicon-1##38 net@564#1pin@202_polysilicon-1##39 9.85
R811 net@564#1pin@202_polysilicon-1##39 net@564#1pin@202_polysilicon-1##40 9.85
R812 net@564#1pin@202_polysilicon-1##40 net@564#1pin@202_polysilicon-1##41 9.85
R813 net@564#1pin@202_polysilicon-1##41 net@564#1pin@202_polysilicon-1##42 9.85
R814 net@564#1pin@202_polysilicon-1##42 net@564#1pin@202_polysilicon-1##43 9.85
R815 net@564#1pin@202_polysilicon-1##43 net@564#1pin@202_polysilicon-1##44 9.85
R816 net@564#1pin@202_polysilicon-1##44 net@564#1pin@202_polysilicon-1##45 9.85
R817 net@564#1pin@202_polysilicon-1##45 net@564#1pin@202_polysilicon-1##46 9.85
R818 net@564#1pin@202_polysilicon-1##46 net@564#1pin@202_polysilicon-1##47 9.85
R819 net@564#1pin@202_polysilicon-1##47 net@564#1pin@202_polysilicon-1##48 9.85
R820 net@564#1pin@202_polysilicon-1##48 net@564#1pin@202_polysilicon-1##49 9.85
R821 net@564#1pin@202_polysilicon-1##49 net@564#1pin@202_polysilicon-1##50 9.85
R822 net@564#1pin@202_polysilicon-1##50 net@564#1pin@202_polysilicon-1##51 9.85
R823 net@564#1pin@202_polysilicon-1##51 net@564#1pin@202_polysilicon-1##52 9.85
R824 net@564#1pin@202_polysilicon-1##52 net@564#1pin@202_polysilicon-1##53 9.85
R825 net@564#1pin@202_polysilicon-1##53 net@564#1pin@202_polysilicon-1##54 9.85
R826 net@564#1pin@202_polysilicon-1##54 net@564#1pin@202_polysilicon-1##55 9.85
R827 net@564#1pin@202_polysilicon-1##55 net@564#1pin@202_polysilicon-1##56 9.85
R828 net@564#1pin@202_polysilicon-1##56 net@564#1pin@202_polysilicon-1##57 9.85
R829 net@564#1pin@202_polysilicon-1##57 net@564#1pin@202_polysilicon-1##58 9.85
R830 net@564#1pin@202_polysilicon-1##58 net@564#1pin@202_polysilicon-1##59 9.85
R831 net@564#1pin@202_polysilicon-1##59 net@564#1pin@202_polysilicon-1##60 9.85
R832 net@564#1pin@202_polysilicon-1##60 net@564#2pin@192_metal-1 9.85
R833 Cin#17pmos@51_poly-right Cin#17pmos@51_poly-right##0 9.854
R834 Cin#17pmos@51_poly-right##0 Cin#17pmos@51_poly-right##1 9.854
R835 Cin#17pmos@51_poly-right##1 Cin#17pmos@51_poly-right##2 9.854
R836 Cin#17pmos@51_poly-right##2 Cin#17pmos@51_poly-right##3 9.854
R837 Cin#17pmos@51_poly-right##3 Cin#17pmos@51_poly-right##4 9.854
R838 Cin#17pmos@51_poly-right##4 Cin#17pmos@51_poly-right##5 9.854
R839 Cin#17pmos@51_poly-right##5 Cin#17pmos@51_poly-right##6 9.854
R840 Cin#17pmos@51_poly-right##6 Cin#17pmos@51_poly-right##7 9.854
R841 Cin#17pmos@51_poly-right##7 Cin#17pmos@51_poly-right##8 9.854
R842 Cin#17pmos@51_poly-right##8 Cin#17pmos@51_poly-right##9 9.854
R843 Cin#17pmos@51_poly-right##9 Cin#17pmos@51_poly-right##10 9.854
R844 Cin#17pmos@51_poly-right##10 Cin#17pmos@51_poly-right##11 9.854
R845 Cin#17pmos@51_poly-right##11 Cin#17pmos@51_poly-right##12 9.854
R846 Cin#17pmos@51_poly-right##12 Cin#17pmos@51_poly-right##13 9.854
R847 Cin#17pmos@51_poly-right##13 Cin#17pmos@51_poly-right##14 9.854
R848 Cin#17pmos@51_poly-right##14 Cin#17pmos@51_poly-right##15 9.854
R849 Cin#17pmos@51_poly-right##15 Cin#17pmos@51_poly-right##16 9.854
R850 Cin#17pmos@51_poly-right##16 Cin#17pmos@51_poly-right##17 9.854
R851 Cin#17pmos@51_poly-right##17 Cin#17pmos@51_poly-right##18 9.854
R852 Cin#17pmos@51_poly-right##18 Cin#17pmos@51_poly-right##19 9.854
R853 Cin#17pmos@51_poly-right##19 Cin#17pmos@51_poly-right##20 9.854
R854 Cin#17pmos@51_poly-right##20 Cin#17pmos@51_poly-right##21 9.854
R855 Cin#17pmos@51_poly-right##21 Cin#17pmos@51_poly-right##22 9.854
R856 Cin#17pmos@51_poly-right##22 Cin#17pmos@51_poly-right##23 9.854
R857 Cin#17pmos@51_poly-right##23 Cin#17pmos@51_poly-right##24 9.854
R858 Cin#17pmos@51_poly-right##24 Cin#17pmos@51_poly-right##25 9.854
R859 Cin#17pmos@51_poly-right##25 Cin#17pmos@51_poly-right##26 9.854
R860 Cin#17pmos@51_poly-right##26 Cin#17pmos@51_poly-right##27 9.854
R861 Cin#17pmos@51_poly-right##27 Cin#17pmos@51_poly-right##28 9.854
R862 Cin#17pmos@51_poly-right##28 Cin#17pmos@51_poly-right##29 9.854
R863 Cin#17pmos@51_poly-right##29 Cin#17pmos@51_poly-right##30 9.854
R864 Cin#17pmos@51_poly-right##30 Cin#17pmos@51_poly-right##31 9.854
R865 Cin#17pmos@51_poly-right##31 Cin#17pmos@51_poly-right##32 9.854
R866 Cin#17pmos@51_poly-right##32 Cin#17pmos@51_poly-right##33 9.854
R867 Cin#17pmos@51_poly-right##33 Cin#17pmos@51_poly-right##34 9.854
R868 Cin#17pmos@51_poly-right##34 Cin#17pmos@51_poly-right##35 9.854
R869 Cin#17pmos@51_poly-right##35 Cin#17pmos@51_poly-right##36 9.854
R870 Cin#17pmos@51_poly-right##36 Cin#17pmos@51_poly-right##37 9.854
R871 Cin#17pmos@51_poly-right##37 Cin#17pmos@51_poly-right##38 9.854
R872 Cin#17pmos@51_poly-right##38 Cin#17pmos@51_poly-right##39 9.854
R873 Cin#17pmos@51_poly-right##39 Cin#17pmos@51_poly-right##40 9.854
R874 Cin#17pmos@51_poly-right##40 Cin#17pmos@51_poly-right##41 9.854
R875 Cin#17pmos@51_poly-right##41 Cin#17pmos@51_poly-right##42 9.854
R876 Cin#17pmos@51_poly-right##42 Cin#17pmos@51_poly-right##43 9.854
R877 Cin#17pmos@51_poly-right##43 Cin#17pmos@51_poly-right##44 9.854
R878 Cin#17pmos@51_poly-right##44 Cin#17pmos@51_poly-right##45 9.854
R879 Cin#17pmos@51_poly-right##45 Cin#17pmos@51_poly-right##46 9.854
R880 Cin#17pmos@51_poly-right##46 Cin#17pmos@51_poly-right##47 9.854
R881 Cin#17pmos@51_poly-right##47 Cin#17pmos@51_poly-right##48 9.854
R882 Cin#17pmos@51_poly-right##48 Cin#17pmos@51_poly-right##49 9.854
R883 Cin#17pmos@51_poly-right##49 Cin#17pmos@51_poly-right##50 9.854
R884 Cin#17pmos@51_poly-right##50 Cin#17pmos@51_poly-right##51 9.854
R885 Cin#17pmos@51_poly-right##51 Cin#17pmos@51_poly-right##52 9.854
R886 Cin#17pmos@51_poly-right##52 Cin#17pmos@51_poly-right##53 9.854
R887 Cin#17pmos@51_poly-right##53 Cin#17pmos@51_poly-right##54 9.854
R888 Cin#17pmos@51_poly-right##54 Cin#6pin@193_polysilicon-1 9.854
R889 net@577 net@577#2contact@270_metal-1-metal-2 4.797
R890 XOR1_to_NAND1#9pmos@47_poly-left XOR1_to_NAND1#9pmos@47_poly-left##0 9.871
R891 XOR1_to_NAND1#9pmos@47_poly-left##0 XOR1_to_NAND1#9pmos@47_poly-left##1 9.871
R892 XOR1_to_NAND1#9pmos@47_poly-left##1 XOR1_to_NAND1#9pmos@47_poly-left##2 9.871
R893 XOR1_to_NAND1#9pmos@47_poly-left##2 XOR1_to_NAND1#9pmos@47_poly-left##3 9.871
R894 XOR1_to_NAND1#9pmos@47_poly-left##3 XOR1_to_NAND1#9pmos@47_poly-left##4 9.871
R895 XOR1_to_NAND1#9pmos@47_poly-left##4 XOR1_to_NAND1#9pmos@47_poly-left##5 9.871
R896 XOR1_to_NAND1#9pmos@47_poly-left##5 XOR1_to_NAND1#9pmos@47_poly-left##6 9.871
R897 XOR1_to_NAND1#9pmos@47_poly-left##6 XOR1_to_NAND1#9pmos@47_poly-left##7 9.871
R898 XOR1_to_NAND1#9pmos@47_poly-left##7 XOR1_to_NAND1#9pmos@47_poly-left##8 9.871
R899 XOR1_to_NAND1#9pmos@47_poly-left##8 XOR1_to_NAND1#9pmos@47_poly-left##9 9.871
R900 XOR1_to_NAND1#9pmos@47_poly-left##9 XOR1_to_NAND1#9pmos@47_poly-left##10 9.871
R901 XOR1_to_NAND1#9pmos@47_poly-left##10 XOR1_to_NAND1#9pmos@47_poly-left##11 9.871
R902 XOR1_to_NAND1#9pmos@47_poly-left##11 XOR1_to_NAND1#9pmos@47_poly-left##12 9.871
R903 XOR1_to_NAND1#9pmos@47_poly-left##12 XOR1_to_NAND1#9pmos@47_poly-left##13 9.871
R904 XOR1_to_NAND1#9pmos@47_poly-left##13 XOR1_to_NAND1#9pmos@47_poly-left##14 9.871
R905 XOR1_to_NAND1#9pmos@47_poly-left##14 XOR1_to_NAND1#9pmos@47_poly-left##15 9.871
R906 XOR1_to_NAND1#9pmos@47_poly-left##15 XOR1_to_NAND1#9pmos@47_poly-left##16 9.871
R907 XOR1_to_NAND1#9pmos@47_poly-left##16 XOR1_to_NAND1#9pmos@47_poly-left##17 9.871
R908 XOR1_to_NAND1#9pmos@47_poly-left##17 XOR1_to_NAND1#9pmos@47_poly-left##18 9.871
R909 XOR1_to_NAND1#9pmos@47_poly-left##18 XOR1_to_NAND1#9pmos@47_poly-left##19 9.871
R910 XOR1_to_NAND1#9pmos@47_poly-left##19 XOR1_to_NAND1#9pmos@47_poly-left##20 9.871
R911 XOR1_to_NAND1#9pmos@47_poly-left##20 XOR1_to_NAND1#9pmos@47_poly-left##21 9.871
R912 XOR1_to_NAND1#9pmos@47_poly-left##21 XOR1_to_NAND1#9pmos@47_poly-left##22 9.871
R913 XOR1_to_NAND1#9pmos@47_poly-left##22 XOR1_to_NAND1#9pmos@47_poly-left##23 9.871
R914 XOR1_to_NAND1#9pmos@47_poly-left##23 XOR1_to_NAND1#9pmos@47_poly-left##24 9.871
R915 XOR1_to_NAND1#9pmos@47_poly-left##24 XOR1_to_NAND1#9pmos@47_poly-left##25 9.871
R916 XOR1_to_NAND1#9pmos@47_poly-left##25 XOR1_to_NAND1#9pmos@47_poly-left##26 9.871
R917 XOR1_to_NAND1#9pmos@47_poly-left##26 XOR1_to_NAND1#9pmos@47_poly-left##27 9.871
R918 XOR1_to_NAND1#9pmos@47_poly-left##27 XOR1_to_NAND1#9pmos@47_poly-left##28 9.871
R919 XOR1_to_NAND1#9pmos@47_poly-left##28 XOR1_to_NAND1#9pmos@47_poly-left##29 9.871
R920 XOR1_to_NAND1#9pmos@47_poly-left##29 XOR1_to_NAND1#9pmos@47_poly-left##30 9.871
R921 XOR1_to_NAND1#9pmos@47_poly-left##30 XOR1_to_NAND1#9pmos@47_poly-left##31 9.871
R922 XOR1_to_NAND1#9pmos@47_poly-left##31 XOR1_to_NAND1#9pmos@47_poly-left##32 9.871
R923 XOR1_to_NAND1#9pmos@47_poly-left##32 XOR1_to_NAND1#9pmos@47_poly-left##33 9.871
R924 XOR1_to_NAND1#9pmos@47_poly-left##33 XOR1_to_NAND1#9pmos@47_poly-left##34 9.871
R925 XOR1_to_NAND1#9pmos@47_poly-left##34 XOR1_to_NAND1#9pmos@47_poly-left##35 9.871
R926 XOR1_to_NAND1#9pmos@47_poly-left##35 XOR1_to_NAND1#9pmos@47_poly-left##36 9.871
R927 XOR1_to_NAND1#9pmos@47_poly-left##36 XOR1_to_NAND1#9pmos@47_poly-left##37 9.871
R928 XOR1_to_NAND1#9pmos@47_poly-left##37 XOR1_to_NAND1#9pmos@47_poly-left##38 9.871
R929 XOR1_to_NAND1#9pmos@47_poly-left##38 XOR1_to_NAND1#9pmos@47_poly-left##39 9.871
R930 XOR1_to_NAND1#9pmos@47_poly-left##39 XOR1_to_NAND1#9pmos@47_poly-left##40 9.871
R931 XOR1_to_NAND1#9pmos@47_poly-left##40 XOR1_to_NAND1#9pmos@47_poly-left##41 9.871
R932 XOR1_to_NAND1#9pmos@47_poly-left##41 XOR1_to_NAND1#9pmos@47_poly-left##42 9.871
R933 XOR1_to_NAND1#9pmos@47_poly-left##42 XOR1_to_NAND1#9pmos@47_poly-left##43 9.871
R934 XOR1_to_NAND1#9pmos@47_poly-left##43 XOR1_to_NAND1#9pmos@47_poly-left##44 9.871
R935 XOR1_to_NAND1#9pmos@47_poly-left##44 XOR1_to_NAND1#9pmos@47_poly-left##45 9.871
R936 XOR1_to_NAND1#9pmos@47_poly-left##45 XOR1_to_NAND1#9pmos@47_poly-left##46 9.871
R937 XOR1_to_NAND1#9pmos@47_poly-left##46 XOR1_to_NAND1#9pmos@47_poly-left##47 9.871
R938 XOR1_to_NAND1#9pmos@47_poly-left##47 XOR1_to_NAND1#9pmos@47_poly-left##48 9.871
R939 XOR1_to_NAND1#9pmos@47_poly-left##48 XOR1_to_NAND1#9pmos@47_poly-left##49 9.871
R940 XOR1_to_NAND1#9pmos@47_poly-left##49 XOR1_to_NAND1#9pmos@47_poly-left##50 9.871
R941 XOR1_to_NAND1#9pmos@47_poly-left##50 XOR1_to_NAND1#9pmos@47_poly-left##51 9.871
R942 XOR1_to_NAND1#9pmos@47_poly-left##51 XOR1_to_NAND1#9pmos@47_poly-left##52 9.871
R943 XOR1_to_NAND1#9pmos@47_poly-left##52 XOR1_to_NAND1#9pmos@47_poly-left##53 9.871
R944 XOR1_to_NAND1#9pmos@47_poly-left##53 XOR1_to_NAND1#9pmos@47_poly-left##54 9.871
R945 XOR1_to_NAND1#9pmos@47_poly-left##54 XOR1_to_NAND1#9pmos@47_poly-left##55 9.871
R946 XOR1_to_NAND1#9pmos@47_poly-left##55 XOR1_to_NAND1#26nmos@47_poly-right 9.871
R947 net@564#7pmos@48_poly-left net@564#7pmos@48_poly-left##0 9.871
R948 net@564#7pmos@48_poly-left##0 net@564#7pmos@48_poly-left##1 9.871
R949 net@564#7pmos@48_poly-left##1 net@564#7pmos@48_poly-left##2 9.871
R950 net@564#7pmos@48_poly-left##2 net@564#7pmos@48_poly-left##3 9.871
R951 net@564#7pmos@48_poly-left##3 net@564#7pmos@48_poly-left##4 9.871
R952 net@564#7pmos@48_poly-left##4 net@564#7pmos@48_poly-left##5 9.871
R953 net@564#7pmos@48_poly-left##5 net@564#7pmos@48_poly-left##6 9.871
R954 net@564#7pmos@48_poly-left##6 net@564#7pmos@48_poly-left##7 9.871
R955 net@564#7pmos@48_poly-left##7 net@564#7pmos@48_poly-left##8 9.871
R956 net@564#7pmos@48_poly-left##8 net@564#7pmos@48_poly-left##9 9.871
R957 net@564#7pmos@48_poly-left##9 net@564#7pmos@48_poly-left##10 9.871
R958 net@564#7pmos@48_poly-left##10 net@564#7pmos@48_poly-left##11 9.871
R959 net@564#7pmos@48_poly-left##11 net@564#7pmos@48_poly-left##12 9.871
R960 net@564#7pmos@48_poly-left##12 net@564#7pmos@48_poly-left##13 9.871
R961 net@564#7pmos@48_poly-left##13 net@564#7pmos@48_poly-left##14 9.871
R962 net@564#7pmos@48_poly-left##14 net@564#7pmos@48_poly-left##15 9.871
R963 net@564#7pmos@48_poly-left##15 net@564#7pmos@48_poly-left##16 9.871
R964 net@564#7pmos@48_poly-left##16 net@564#7pmos@48_poly-left##17 9.871
R965 net@564#7pmos@48_poly-left##17 net@564#7pmos@48_poly-left##18 9.871
R966 net@564#7pmos@48_poly-left##18 net@564#7pmos@48_poly-left##19 9.871
R967 net@564#7pmos@48_poly-left##19 net@564#7pmos@48_poly-left##20 9.871
R968 net@564#7pmos@48_poly-left##20 net@564#7pmos@48_poly-left##21 9.871
R969 net@564#7pmos@48_poly-left##21 net@564#7pmos@48_poly-left##22 9.871
R970 net@564#7pmos@48_poly-left##22 net@564#7pmos@48_poly-left##23 9.871
R971 net@564#7pmos@48_poly-left##23 net@564#7pmos@48_poly-left##24 9.871
R972 net@564#7pmos@48_poly-left##24 net@564#7pmos@48_poly-left##25 9.871
R973 net@564#7pmos@48_poly-left##25 net@564#7pmos@48_poly-left##26 9.871
R974 net@564#7pmos@48_poly-left##26 net@564#7pmos@48_poly-left##27 9.871
R975 net@564#7pmos@48_poly-left##27 net@564#7pmos@48_poly-left##28 9.871
R976 net@564#7pmos@48_poly-left##28 net@564#7pmos@48_poly-left##29 9.871
R977 net@564#7pmos@48_poly-left##29 net@564#7pmos@48_poly-left##30 9.871
R978 net@564#7pmos@48_poly-left##30 net@564#7pmos@48_poly-left##31 9.871
R979 net@564#7pmos@48_poly-left##31 net@564#7pmos@48_poly-left##32 9.871
R980 net@564#7pmos@48_poly-left##32 net@564#7pmos@48_poly-left##33 9.871
R981 net@564#7pmos@48_poly-left##33 net@564#7pmos@48_poly-left##34 9.871
R982 net@564#7pmos@48_poly-left##34 net@564#7pmos@48_poly-left##35 9.871
R983 net@564#7pmos@48_poly-left##35 net@564#7pmos@48_poly-left##36 9.871
R984 net@564#7pmos@48_poly-left##36 net@564#7pmos@48_poly-left##37 9.871
R985 net@564#7pmos@48_poly-left##37 net@564#7pmos@48_poly-left##38 9.871
R986 net@564#7pmos@48_poly-left##38 net@564#7pmos@48_poly-left##39 9.871
R987 net@564#7pmos@48_poly-left##39 net@564#7pmos@48_poly-left##40 9.871
R988 net@564#7pmos@48_poly-left##40 net@564#7pmos@48_poly-left##41 9.871
R989 net@564#7pmos@48_poly-left##41 net@564#7pmos@48_poly-left##42 9.871
R990 net@564#7pmos@48_poly-left##42 net@564#7pmos@48_poly-left##43 9.871
R991 net@564#7pmos@48_poly-left##43 net@564#7pmos@48_poly-left##44 9.871
R992 net@564#7pmos@48_poly-left##44 net@564#7pmos@48_poly-left##45 9.871
R993 net@564#7pmos@48_poly-left##45 net@564#7pmos@48_poly-left##46 9.871
R994 net@564#7pmos@48_poly-left##46 net@564#7pmos@48_poly-left##47 9.871
R995 net@564#7pmos@48_poly-left##47 net@564#7pmos@48_poly-left##48 9.871
R996 net@564#7pmos@48_poly-left##48 net@564#7pmos@48_poly-left##49 9.871
R997 net@564#7pmos@48_poly-left##49 net@564#7pmos@48_poly-left##50 9.871
R998 net@564#7pmos@48_poly-left##50 net@564#7pmos@48_poly-left##51 9.871
R999 net@564#7pmos@48_poly-left##51 net@564#7pmos@48_poly-left##52 9.871
R1000 net@564#7pmos@48_poly-left##52 net@564#7pmos@48_poly-left##53 9.871
R1001 net@564#7pmos@48_poly-left##53 net@564#7pmos@48_poly-left##54 9.871
R1002 net@564#7pmos@48_poly-left##54 net@564#7pmos@48_poly-left##55 9.871
R1003 net@564#7pmos@48_poly-left##55 net@564#11nmos@48_poly-right 9.871
R1004 Cin#18pmos@49_poly-right Cin#18pmos@49_poly-right##0 9.871
R1005 Cin#18pmos@49_poly-right##0 Cin#18pmos@49_poly-right##1 9.871
R1006 Cin#18pmos@49_poly-right##1 Cin#18pmos@49_poly-right##2 9.871
R1007 Cin#18pmos@49_poly-right##2 Cin#18pmos@49_poly-right##3 9.871
R1008 Cin#18pmos@49_poly-right##3 Cin#18pmos@49_poly-right##4 9.871
R1009 Cin#18pmos@49_poly-right##4 Cin#18pmos@49_poly-right##5 9.871
R1010 Cin#18pmos@49_poly-right##5 Cin#18pmos@49_poly-right##6 9.871
R1011 Cin#18pmos@49_poly-right##6 Cin#18pmos@49_poly-right##7 9.871
R1012 Cin#18pmos@49_poly-right##7 Cin#18pmos@49_poly-right##8 9.871
R1013 Cin#18pmos@49_poly-right##8 Cin#18pmos@49_poly-right##9 9.871
R1014 Cin#18pmos@49_poly-right##9 Cin#18pmos@49_poly-right##10 9.871
R1015 Cin#18pmos@49_poly-right##10 Cin#18pmos@49_poly-right##11 9.871
R1016 Cin#18pmos@49_poly-right##11 Cin#18pmos@49_poly-right##12 9.871
R1017 Cin#18pmos@49_poly-right##12 Cin#18pmos@49_poly-right##13 9.871
R1018 Cin#18pmos@49_poly-right##13 Cin#18pmos@49_poly-right##14 9.871
R1019 Cin#18pmos@49_poly-right##14 Cin#18pmos@49_poly-right##15 9.871
R1020 Cin#18pmos@49_poly-right##15 Cin#18pmos@49_poly-right##16 9.871
R1021 Cin#18pmos@49_poly-right##16 Cin#18pmos@49_poly-right##17 9.871
R1022 Cin#18pmos@49_poly-right##17 Cin#18pmos@49_poly-right##18 9.871
R1023 Cin#18pmos@49_poly-right##18 Cin#18pmos@49_poly-right##19 9.871
R1024 Cin#18pmos@49_poly-right##19 Cin#18pmos@49_poly-right##20 9.871
R1025 Cin#18pmos@49_poly-right##20 Cin#18pmos@49_poly-right##21 9.871
R1026 Cin#18pmos@49_poly-right##21 Cin#18pmos@49_poly-right##22 9.871
R1027 Cin#18pmos@49_poly-right##22 Cin#18pmos@49_poly-right##23 9.871
R1028 Cin#18pmos@49_poly-right##23 Cin#18pmos@49_poly-right##24 9.871
R1029 Cin#18pmos@49_poly-right##24 Cin#18pmos@49_poly-right##25 9.871
R1030 Cin#18pmos@49_poly-right##25 Cin#18pmos@49_poly-right##26 9.871
R1031 Cin#18pmos@49_poly-right##26 Cin#18pmos@49_poly-right##27 9.871
R1032 Cin#18pmos@49_poly-right##27 Cin#18pmos@49_poly-right##28 9.871
R1033 Cin#18pmos@49_poly-right##28 Cin#18pmos@49_poly-right##29 9.871
R1034 Cin#18pmos@49_poly-right##29 Cin#18pmos@49_poly-right##30 9.871
R1035 Cin#18pmos@49_poly-right##30 Cin#18pmos@49_poly-right##31 9.871
R1036 Cin#18pmos@49_poly-right##31 Cin#18pmos@49_poly-right##32 9.871
R1037 Cin#18pmos@49_poly-right##32 Cin#18pmos@49_poly-right##33 9.871
R1038 Cin#18pmos@49_poly-right##33 Cin#18pmos@49_poly-right##34 9.871
R1039 Cin#18pmos@49_poly-right##34 Cin#18pmos@49_poly-right##35 9.871
R1040 Cin#18pmos@49_poly-right##35 Cin#18pmos@49_poly-right##36 9.871
R1041 Cin#18pmos@49_poly-right##36 Cin#18pmos@49_poly-right##37 9.871
R1042 Cin#18pmos@49_poly-right##37 Cin#18pmos@49_poly-right##38 9.871
R1043 Cin#18pmos@49_poly-right##38 Cin#18pmos@49_poly-right##39 9.871
R1044 Cin#18pmos@49_poly-right##39 Cin#18pmos@49_poly-right##40 9.871
R1045 Cin#18pmos@49_poly-right##40 Cin#18pmos@49_poly-right##41 9.871
R1046 Cin#18pmos@49_poly-right##41 Cin#18pmos@49_poly-right##42 9.871
R1047 Cin#18pmos@49_poly-right##42 Cin#18pmos@49_poly-right##43 9.871
R1048 Cin#18pmos@49_poly-right##43 Cin#18pmos@49_poly-right##44 9.871
R1049 Cin#18pmos@49_poly-right##44 Cin#18pmos@49_poly-right##45 9.871
R1050 Cin#18pmos@49_poly-right##45 Cin#18pmos@49_poly-right##46 9.871
R1051 Cin#18pmos@49_poly-right##46 Cin#18pmos@49_poly-right##47 9.871
R1052 Cin#18pmos@49_poly-right##47 Cin#18pmos@49_poly-right##48 9.871
R1053 Cin#18pmos@49_poly-right##48 Cin#18pmos@49_poly-right##49 9.871
R1054 Cin#18pmos@49_poly-right##49 Cin#18pmos@49_poly-right##50 9.871
R1055 Cin#18pmos@49_poly-right##50 Cin#18pmos@49_poly-right##51 9.871
R1056 Cin#18pmos@49_poly-right##51 Cin#18pmos@49_poly-right##52 9.871
R1057 Cin#18pmos@49_poly-right##52 Cin#18pmos@49_poly-right##53 9.871
R1058 Cin#18pmos@49_poly-right##53 Cin#18pmos@49_poly-right##54 9.871
R1059 Cin#18pmos@49_poly-right##54 Cin#18pmos@49_poly-right##55 9.871
R1060 Cin#18pmos@49_poly-right##55 Cin#9nmos@49_poly-left 9.871
R1061 net@577#14pmos@50_poly-right net@577#14pmos@50_poly-right##0 9.871
R1062 net@577#14pmos@50_poly-right##0 net@577#14pmos@50_poly-right##1 9.871
R1063 net@577#14pmos@50_poly-right##1 net@577#14pmos@50_poly-right##2 9.871
R1064 net@577#14pmos@50_poly-right##2 net@577#14pmos@50_poly-right##3 9.871
R1065 net@577#14pmos@50_poly-right##3 net@577#14pmos@50_poly-right##4 9.871
R1066 net@577#14pmos@50_poly-right##4 net@577#14pmos@50_poly-right##5 9.871
R1067 net@577#14pmos@50_poly-right##5 net@577#14pmos@50_poly-right##6 9.871
R1068 net@577#14pmos@50_poly-right##6 net@577#14pmos@50_poly-right##7 9.871
R1069 net@577#14pmos@50_poly-right##7 net@577#14pmos@50_poly-right##8 9.871
R1070 net@577#14pmos@50_poly-right##8 net@577#14pmos@50_poly-right##9 9.871
R1071 net@577#14pmos@50_poly-right##9 net@577#14pmos@50_poly-right##10 9.871
R1072 net@577#14pmos@50_poly-right##10 net@577#14pmos@50_poly-right##11 9.871
R1073 net@577#14pmos@50_poly-right##11 net@577#14pmos@50_poly-right##12 9.871
R1074 net@577#14pmos@50_poly-right##12 net@577#14pmos@50_poly-right##13 9.871
R1075 net@577#14pmos@50_poly-right##13 net@577#14pmos@50_poly-right##14 9.871
R1076 net@577#14pmos@50_poly-right##14 net@577#14pmos@50_poly-right##15 9.871
R1077 net@577#14pmos@50_poly-right##15 net@577#14pmos@50_poly-right##16 9.871
R1078 net@577#14pmos@50_poly-right##16 net@577#14pmos@50_poly-right##17 9.871
R1079 net@577#14pmos@50_poly-right##17 net@577#14pmos@50_poly-right##18 9.871
R1080 net@577#14pmos@50_poly-right##18 net@577#14pmos@50_poly-right##19 9.871
R1081 net@577#14pmos@50_poly-right##19 net@577#14pmos@50_poly-right##20 9.871
R1082 net@577#14pmos@50_poly-right##20 net@577#14pmos@50_poly-right##21 9.871
R1083 net@577#14pmos@50_poly-right##21 net@577#14pmos@50_poly-right##22 9.871
R1084 net@577#14pmos@50_poly-right##22 net@577#14pmos@50_poly-right##23 9.871
R1085 net@577#14pmos@50_poly-right##23 net@577#14pmos@50_poly-right##24 9.871
R1086 net@577#14pmos@50_poly-right##24 net@577#14pmos@50_poly-right##25 9.871
R1087 net@577#14pmos@50_poly-right##25 net@577#14pmos@50_poly-right##26 9.871
R1088 net@577#14pmos@50_poly-right##26 net@577#14pmos@50_poly-right##27 9.871
R1089 net@577#14pmos@50_poly-right##27 net@577#14pmos@50_poly-right##28 9.871
R1090 net@577#14pmos@50_poly-right##28 net@577#14pmos@50_poly-right##29 9.871
R1091 net@577#14pmos@50_poly-right##29 net@577#14pmos@50_poly-right##30 9.871
R1092 net@577#14pmos@50_poly-right##30 net@577#14pmos@50_poly-right##31 9.871
R1093 net@577#14pmos@50_poly-right##31 net@577#14pmos@50_poly-right##32 9.871
R1094 net@577#14pmos@50_poly-right##32 net@577#14pmos@50_poly-right##33 9.871
R1095 net@577#14pmos@50_poly-right##33 net@577#14pmos@50_poly-right##34 9.871
R1096 net@577#14pmos@50_poly-right##34 net@577#14pmos@50_poly-right##35 9.871
R1097 net@577#14pmos@50_poly-right##35 net@577#14pmos@50_poly-right##36 9.871
R1098 net@577#14pmos@50_poly-right##36 net@577#14pmos@50_poly-right##37 9.871
R1099 net@577#14pmos@50_poly-right##37 net@577#14pmos@50_poly-right##38 9.871
R1100 net@577#14pmos@50_poly-right##38 net@577#14pmos@50_poly-right##39 9.871
R1101 net@577#14pmos@50_poly-right##39 net@577#14pmos@50_poly-right##40 9.871
R1102 net@577#14pmos@50_poly-right##40 net@577#14pmos@50_poly-right##41 9.871
R1103 net@577#14pmos@50_poly-right##41 net@577#14pmos@50_poly-right##42 9.871
R1104 net@577#14pmos@50_poly-right##42 net@577#14pmos@50_poly-right##43 9.871
R1105 net@577#14pmos@50_poly-right##43 net@577#14pmos@50_poly-right##44 9.871
R1106 net@577#14pmos@50_poly-right##44 net@577#14pmos@50_poly-right##45 9.871
R1107 net@577#14pmos@50_poly-right##45 net@577#14pmos@50_poly-right##46 9.871
R1108 net@577#14pmos@50_poly-right##46 net@577#14pmos@50_poly-right##47 9.871
R1109 net@577#14pmos@50_poly-right##47 net@577#14pmos@50_poly-right##48 9.871
R1110 net@577#14pmos@50_poly-right##48 net@577#14pmos@50_poly-right##49 9.871
R1111 net@577#14pmos@50_poly-right##49 net@577#14pmos@50_poly-right##50 9.871
R1112 net@577#14pmos@50_poly-right##50 net@577#14pmos@50_poly-right##51 9.871
R1113 net@577#14pmos@50_poly-right##51 net@577#14pmos@50_poly-right##52 9.871
R1114 net@577#14pmos@50_poly-right##52 net@577#14pmos@50_poly-right##53 9.871
R1115 net@577#14pmos@50_poly-right##53 net@577#14pmos@50_poly-right##54 9.871
R1116 net@577#14pmos@50_poly-right##54 net@577#14pmos@50_poly-right##55 9.871
R1117 net@577#14pmos@50_poly-right##55 net@577#9nmos@50_poly-left 9.871
R1118 net@576#2contact@295_metal-1-polysilicon-1 net@576 4.654
R1119 net@576#12pmos@53_poly-right net@576#12pmos@53_poly-right##0 9.931
R1120 net@576#12pmos@53_poly-right##0 net@576#12pmos@53_poly-right##1 9.931
R1121 net@576#12pmos@53_poly-right##1 net@576#12pmos@53_poly-right##2 9.931
R1122 net@576#12pmos@53_poly-right##2 net@576#12pmos@53_poly-right##3 9.931
R1123 net@576#12pmos@53_poly-right##3 net@576#12pmos@53_poly-right##4 9.931
R1124 net@576#12pmos@53_poly-right##4 net@576#12pmos@53_poly-right##5 9.931
R1125 net@576#12pmos@53_poly-right##5 net@576#12pmos@53_poly-right##6 9.931
R1126 net@576#12pmos@53_poly-right##6 net@576#12pmos@53_poly-right##7 9.931
R1127 net@576#12pmos@53_poly-right##7 net@576#12pmos@53_poly-right##8 9.931
R1128 net@576#12pmos@53_poly-right##8 net@576#12pmos@53_poly-right##9 9.931
R1129 net@576#12pmos@53_poly-right##9 net@576#12pmos@53_poly-right##10 9.931
R1130 net@576#12pmos@53_poly-right##10 net@576#12pmos@53_poly-right##11 9.931
R1131 net@576#12pmos@53_poly-right##11 net@576#12pmos@53_poly-right##12 9.931
R1132 net@576#12pmos@53_poly-right##12 net@576#12pmos@53_poly-right##13 9.931
R1133 net@576#12pmos@53_poly-right##13 net@576#12pmos@53_poly-right##14 9.931
R1134 net@576#12pmos@53_poly-right##14 net@576#12pmos@53_poly-right##15 9.931
R1135 net@576#12pmos@53_poly-right##15 net@576#12pmos@53_poly-right##16 9.931
R1136 net@576#12pmos@53_poly-right##16 net@576#12pmos@53_poly-right##17 9.931
R1137 net@576#12pmos@53_poly-right##17 net@576#12pmos@53_poly-right##18 9.931
R1138 net@576#12pmos@53_poly-right##18 net@576#12pmos@53_poly-right##19 9.931
R1139 net@576#12pmos@53_poly-right##19 net@576#12pmos@53_poly-right##20 9.931
R1140 net@576#12pmos@53_poly-right##20 net@576#12pmos@53_poly-right##21 9.931
R1141 net@576#12pmos@53_poly-right##21 net@576#12pmos@53_poly-right##22 9.931
R1142 net@576#12pmos@53_poly-right##22 net@576#12pmos@53_poly-right##23 9.931
R1143 net@576#12pmos@53_poly-right##23 net@576#12pmos@53_poly-right##24 9.931
R1144 net@576#12pmos@53_poly-right##24 net@576#12pmos@53_poly-right##25 9.931
R1145 net@576#12pmos@53_poly-right##25 net@576#12pmos@53_poly-right##26 9.931
R1146 net@576#12pmos@53_poly-right##26 net@576#12pmos@53_poly-right##27 9.931
R1147 net@576#12pmos@53_poly-right##27 net@576#12pmos@53_poly-right##28 9.931
R1148 net@576#12pmos@53_poly-right##28 net@576#12pmos@53_poly-right##29 9.931
R1149 net@576#12pmos@53_poly-right##29 net@576#12pmos@53_poly-right##30 9.931
R1150 net@576#12pmos@53_poly-right##30 net@576#12pmos@53_poly-right##31 9.931
R1151 net@576#12pmos@53_poly-right##31 net@576#12pmos@53_poly-right##32 9.931
R1152 net@576#12pmos@53_poly-right##32 net@576#12pmos@53_poly-right##33 9.931
R1153 net@576#12pmos@53_poly-right##33 net@576#12pmos@53_poly-right##34 9.931
R1154 net@576#12pmos@53_poly-right##34 net@576#12pmos@53_poly-right##35 9.931
R1155 net@576#12pmos@53_poly-right##35 net@576#12pmos@53_poly-right##36 9.931
R1156 net@576#12pmos@53_poly-right##36 net@576#12pmos@53_poly-right##37 9.931
R1157 net@576#12pmos@53_poly-right##37 net@576#12pmos@53_poly-right##38 9.931
R1158 net@576#12pmos@53_poly-right##38 net@576#12pmos@53_poly-right##39 9.931
R1159 net@576#12pmos@53_poly-right##39 net@576#12pmos@53_poly-right##40 9.931
R1160 net@576#12pmos@53_poly-right##40 net@576#12pmos@53_poly-right##41 9.931
R1161 net@576#12pmos@53_poly-right##41 net@576#12pmos@53_poly-right##42 9.931
R1162 net@576#12pmos@53_poly-right##42 net@576#12pmos@53_poly-right##43 9.931
R1163 net@576#12pmos@53_poly-right##43 net@576#12pmos@53_poly-right##44 9.931
R1164 net@576#12pmos@53_poly-right##44 net@576#12pmos@53_poly-right##45 9.931
R1165 net@576#12pmos@53_poly-right##45 net@576#12pmos@53_poly-right##46 9.931
R1166 net@576#12pmos@53_poly-right##46 net@576#12pmos@53_poly-right##47 9.931
R1167 net@576#12pmos@53_poly-right##47 net@576#12pmos@53_poly-right##48 9.931
R1168 net@576#12pmos@53_poly-right##48 net@576#12pmos@53_poly-right##49 9.931
R1169 net@576#12pmos@53_poly-right##49 net@576#12pmos@53_poly-right##50 9.931
R1170 net@576#12pmos@53_poly-right##50 net@576#12pmos@53_poly-right##51 9.931
R1171 net@576#12pmos@53_poly-right##51 net@576#12pmos@53_poly-right##52 9.931
R1172 net@576#12pmos@53_poly-right##52 net@576#5pin@195_polysilicon-1 9.931
R1173 Sum0#4pmos@53_diff-top Sum0 4.823
R1174 XOR1_to_NAND1#14pin@207_polysilicon-1 XOR1_to_NAND1#14pin@207_polysilicon-1##0 9.854
R1175 XOR1_to_NAND1#14pin@207_polysilicon-1##0 XOR1_to_NAND1#14pin@207_polysilicon-1##1 9.854
R1176 XOR1_to_NAND1#14pin@207_polysilicon-1##1 XOR1_to_NAND1#14pin@207_polysilicon-1##2 9.854
R1177 XOR1_to_NAND1#14pin@207_polysilicon-1##2 XOR1_to_NAND1#14pin@207_polysilicon-1##3 9.854
R1178 XOR1_to_NAND1#14pin@207_polysilicon-1##3 XOR1_to_NAND1#14pin@207_polysilicon-1##4 9.854
R1179 XOR1_to_NAND1#14pin@207_polysilicon-1##4 XOR1_to_NAND1#14pin@207_polysilicon-1##5 9.854
R1180 XOR1_to_NAND1#14pin@207_polysilicon-1##5 XOR1_to_NAND1#14pin@207_polysilicon-1##6 9.854
R1181 XOR1_to_NAND1#14pin@207_polysilicon-1##6 XOR1_to_NAND1#14pin@207_polysilicon-1##7 9.854
R1182 XOR1_to_NAND1#14pin@207_polysilicon-1##7 XOR1_to_NAND1#14pin@207_polysilicon-1##8 9.854
R1183 XOR1_to_NAND1#14pin@207_polysilicon-1##8 XOR1_to_NAND1#14pin@207_polysilicon-1##9 9.854
R1184 XOR1_to_NAND1#14pin@207_polysilicon-1##9 XOR1_to_NAND1#14pin@207_polysilicon-1##10 9.854
R1185 XOR1_to_NAND1#14pin@207_polysilicon-1##10 XOR1_to_NAND1#14pin@207_polysilicon-1##11 9.854
R1186 XOR1_to_NAND1#14pin@207_polysilicon-1##11 XOR1_to_NAND1#14pin@207_polysilicon-1##12 9.854
R1187 XOR1_to_NAND1#14pin@207_polysilicon-1##12 XOR1_to_NAND1#14pin@207_polysilicon-1##13 9.854
R1188 XOR1_to_NAND1#14pin@207_polysilicon-1##13 XOR1_to_NAND1#14pin@207_polysilicon-1##14 9.854
R1189 XOR1_to_NAND1#14pin@207_polysilicon-1##14 XOR1_to_NAND1#14pin@207_polysilicon-1##15 9.854
R1190 XOR1_to_NAND1#14pin@207_polysilicon-1##15 XOR1_to_NAND1#14pin@207_polysilicon-1##16 9.854
R1191 XOR1_to_NAND1#14pin@207_polysilicon-1##16 XOR1_to_NAND1#14pin@207_polysilicon-1##17 9.854
R1192 XOR1_to_NAND1#14pin@207_polysilicon-1##17 XOR1_to_NAND1#14pin@207_polysilicon-1##18 9.854
R1193 XOR1_to_NAND1#14pin@207_polysilicon-1##18 XOR1_to_NAND1#14pin@207_polysilicon-1##19 9.854
R1194 XOR1_to_NAND1#14pin@207_polysilicon-1##19 XOR1_to_NAND1#14pin@207_polysilicon-1##20 9.854
R1195 XOR1_to_NAND1#14pin@207_polysilicon-1##20 XOR1_to_NAND1#14pin@207_polysilicon-1##21 9.854
R1196 XOR1_to_NAND1#14pin@207_polysilicon-1##21 XOR1_to_NAND1#14pin@207_polysilicon-1##22 9.854
R1197 XOR1_to_NAND1#14pin@207_polysilicon-1##22 XOR1_to_NAND1#14pin@207_polysilicon-1##23 9.854
R1198 XOR1_to_NAND1#14pin@207_polysilicon-1##23 XOR1_to_NAND1#14pin@207_polysilicon-1##24 9.854
R1199 XOR1_to_NAND1#14pin@207_polysilicon-1##24 XOR1_to_NAND1#14pin@207_polysilicon-1##25 9.854
R1200 XOR1_to_NAND1#14pin@207_polysilicon-1##25 XOR1_to_NAND1#14pin@207_polysilicon-1##26 9.854
R1201 XOR1_to_NAND1#14pin@207_polysilicon-1##26 XOR1_to_NAND1#14pin@207_polysilicon-1##27 9.854
R1202 XOR1_to_NAND1#14pin@207_polysilicon-1##27 XOR1_to_NAND1#14pin@207_polysilicon-1##28 9.854
R1203 XOR1_to_NAND1#14pin@207_polysilicon-1##28 XOR1_to_NAND1#14pin@207_polysilicon-1##29 9.854
R1204 XOR1_to_NAND1#14pin@207_polysilicon-1##29 XOR1_to_NAND1#14pin@207_polysilicon-1##30 9.854
R1205 XOR1_to_NAND1#14pin@207_polysilicon-1##30 XOR1_to_NAND1#14pin@207_polysilicon-1##31 9.854
R1206 XOR1_to_NAND1#14pin@207_polysilicon-1##31 XOR1_to_NAND1#14pin@207_polysilicon-1##32 9.854
R1207 XOR1_to_NAND1#14pin@207_polysilicon-1##32 XOR1_to_NAND1#14pin@207_polysilicon-1##33 9.854
R1208 XOR1_to_NAND1#14pin@207_polysilicon-1##33 XOR1_to_NAND1#14pin@207_polysilicon-1##34 9.854
R1209 XOR1_to_NAND1#14pin@207_polysilicon-1##34 XOR1_to_NAND1#14pin@207_polysilicon-1##35 9.854
R1210 XOR1_to_NAND1#14pin@207_polysilicon-1##35 XOR1_to_NAND1#14pin@207_polysilicon-1##36 9.854
R1211 XOR1_to_NAND1#14pin@207_polysilicon-1##36 XOR1_to_NAND1#14pin@207_polysilicon-1##37 9.854
R1212 XOR1_to_NAND1#14pin@207_polysilicon-1##37 XOR1_to_NAND1#14pin@207_polysilicon-1##38 9.854
R1213 XOR1_to_NAND1#14pin@207_polysilicon-1##38 XOR1_to_NAND1#14pin@207_polysilicon-1##39 9.854
R1214 XOR1_to_NAND1#14pin@207_polysilicon-1##39 XOR1_to_NAND1#14pin@207_polysilicon-1##40 9.854
R1215 XOR1_to_NAND1#14pin@207_polysilicon-1##40 XOR1_to_NAND1#14pin@207_polysilicon-1##41 9.854
R1216 XOR1_to_NAND1#14pin@207_polysilicon-1##41 XOR1_to_NAND1#14pin@207_polysilicon-1##42 9.854
R1217 XOR1_to_NAND1#14pin@207_polysilicon-1##42 XOR1_to_NAND1#14pin@207_polysilicon-1##43 9.854
R1218 XOR1_to_NAND1#14pin@207_polysilicon-1##43 XOR1_to_NAND1#14pin@207_polysilicon-1##44 9.854
R1219 XOR1_to_NAND1#14pin@207_polysilicon-1##44 XOR1_to_NAND1#14pin@207_polysilicon-1##45 9.854
R1220 XOR1_to_NAND1#14pin@207_polysilicon-1##45 XOR1_to_NAND1#14pin@207_polysilicon-1##46 9.854
R1221 XOR1_to_NAND1#14pin@207_polysilicon-1##46 XOR1_to_NAND1#14pin@207_polysilicon-1##47 9.854
R1222 XOR1_to_NAND1#14pin@207_polysilicon-1##47 XOR1_to_NAND1#14pin@207_polysilicon-1##48 9.854
R1223 XOR1_to_NAND1#14pin@207_polysilicon-1##48 XOR1_to_NAND1#14pin@207_polysilicon-1##49 9.854
R1224 XOR1_to_NAND1#14pin@207_polysilicon-1##49 XOR1_to_NAND1#14pin@207_polysilicon-1##50 9.854
R1225 XOR1_to_NAND1#14pin@207_polysilicon-1##50 XOR1_to_NAND1#14pin@207_polysilicon-1##51 9.854
R1226 XOR1_to_NAND1#14pin@207_polysilicon-1##51 XOR1_to_NAND1#14pin@207_polysilicon-1##52 9.854
R1227 XOR1_to_NAND1#14pin@207_polysilicon-1##52 XOR1_to_NAND1#14pin@207_polysilicon-1##53 9.854
R1228 XOR1_to_NAND1#14pin@207_polysilicon-1##53 XOR1_to_NAND1#14pin@207_polysilicon-1##54 9.854
R1229 XOR1_to_NAND1#14pin@207_polysilicon-1##54 XOR1_to_NAND1#27nmos@54_poly-right 9.854
R1230 Cin#20pmos@55_poly-right Cin#20pmos@55_poly-right##0 9.877
R1231 Cin#20pmos@55_poly-right##0 Cin#20pmos@55_poly-right##1 9.877
R1232 Cin#20pmos@55_poly-right##1 Cin#20pmos@55_poly-right##2 9.877
R1233 Cin#20pmos@55_poly-right##2 Cin#20pmos@55_poly-right##3 9.877
R1234 Cin#20pmos@55_poly-right##3 Cin#20pmos@55_poly-right##4 9.877
R1235 Cin#20pmos@55_poly-right##4 Cin#20pmos@55_poly-right##5 9.877
R1236 Cin#20pmos@55_poly-right##5 Cin#20pmos@55_poly-right##6 9.877
R1237 Cin#20pmos@55_poly-right##6 Cin#20pmos@55_poly-right##7 9.877
R1238 Cin#20pmos@55_poly-right##7 Cin#20pmos@55_poly-right##8 9.877
R1239 Cin#20pmos@55_poly-right##8 Cin#20pmos@55_poly-right##9 9.877
R1240 Cin#20pmos@55_poly-right##9 Cin#20pmos@55_poly-right##10 9.877
R1241 Cin#20pmos@55_poly-right##10 Cin#20pmos@55_poly-right##11 9.877
R1242 Cin#20pmos@55_poly-right##11 Cin#20pmos@55_poly-right##12 9.877
R1243 Cin#20pmos@55_poly-right##12 Cin#20pmos@55_poly-right##13 9.877
R1244 Cin#20pmos@55_poly-right##13 Cin#20pmos@55_poly-right##14 9.877
R1245 Cin#20pmos@55_poly-right##14 Cin#20pmos@55_poly-right##15 9.877
R1246 Cin#20pmos@55_poly-right##15 Cin#20pmos@55_poly-right##16 9.877
R1247 Cin#20pmos@55_poly-right##16 Cin#20pmos@55_poly-right##17 9.877
R1248 Cin#20pmos@55_poly-right##17 Cin#20pmos@55_poly-right##18 9.877
R1249 Cin#20pmos@55_poly-right##18 Cin#20pmos@55_poly-right##19 9.877
R1250 Cin#20pmos@55_poly-right##19 Cin#20pmos@55_poly-right##20 9.877
R1251 Cin#20pmos@55_poly-right##20 Cin#20pmos@55_poly-right##21 9.877
R1252 Cin#20pmos@55_poly-right##21 Cin#20pmos@55_poly-right##22 9.877
R1253 Cin#20pmos@55_poly-right##22 Cin#20pmos@55_poly-right##23 9.877
R1254 Cin#20pmos@55_poly-right##23 Cin#20pmos@55_poly-right##24 9.877
R1255 Cin#20pmos@55_poly-right##24 Cin#20pmos@55_poly-right##25 9.877
R1256 Cin#20pmos@55_poly-right##25 Cin#20pmos@55_poly-right##26 9.877
R1257 Cin#20pmos@55_poly-right##26 Cin#20pmos@55_poly-right##27 9.877
R1258 Cin#20pmos@55_poly-right##27 Cin#20pmos@55_poly-right##28 9.877
R1259 Cin#20pmos@55_poly-right##28 Cin#20pmos@55_poly-right##29 9.877
R1260 Cin#20pmos@55_poly-right##29 Cin#20pmos@55_poly-right##30 9.877
R1261 Cin#20pmos@55_poly-right##30 Cin#20pmos@55_poly-right##31 9.877
R1262 Cin#20pmos@55_poly-right##31 Cin#20pmos@55_poly-right##32 9.877
R1263 Cin#20pmos@55_poly-right##32 Cin#20pmos@55_poly-right##33 9.877
R1264 Cin#20pmos@55_poly-right##33 Cin#20pmos@55_poly-right##34 9.877
R1265 Cin#20pmos@55_poly-right##34 Cin#20pmos@55_poly-right##35 9.877
R1266 Cin#20pmos@55_poly-right##35 Cin#20pmos@55_poly-right##36 9.877
R1267 Cin#20pmos@55_poly-right##36 Cin#20pmos@55_poly-right##37 9.877
R1268 Cin#20pmos@55_poly-right##37 Cin#20pmos@55_poly-right##38 9.877
R1269 Cin#20pmos@55_poly-right##38 Cin#20pmos@55_poly-right##39 9.877
R1270 Cin#20pmos@55_poly-right##39 Cin#20pmos@55_poly-right##40 9.877
R1271 Cin#20pmos@55_poly-right##40 Cin#20pmos@55_poly-right##41 9.877
R1272 Cin#20pmos@55_poly-right##41 Cin#20pmos@55_poly-right##42 9.877
R1273 Cin#20pmos@55_poly-right##42 Cin#20pmos@55_poly-right##43 9.877
R1274 Cin#20pmos@55_poly-right##43 Cin#20pmos@55_poly-right##44 9.877
R1275 Cin#20pmos@55_poly-right##44 Cin#20pmos@55_poly-right##45 9.877
R1276 Cin#20pmos@55_poly-right##45 Cin#20pmos@55_poly-right##46 9.877
R1277 Cin#20pmos@55_poly-right##46 Cin#20pmos@55_poly-right##47 9.877
R1278 Cin#20pmos@55_poly-right##47 Cin#20pmos@55_poly-right##48 9.877
R1279 Cin#20pmos@55_poly-right##48 Cin#20pmos@55_poly-right##49 9.877
R1280 Cin#20pmos@55_poly-right##49 Cin#14pin@212_polysilicon-1 9.877
R1281 NAND1_to_NAND3 NAND1_to_NAND3#4nmos@55_diff-bottom 4.823
R1282 A0#8pin@215_polysilicon-1 A0#8pin@215_polysilicon-1##0 9.938
R1283 A0#8pin@215_polysilicon-1##0 A0#8pin@215_polysilicon-1##1 9.938
R1284 A0#8pin@215_polysilicon-1##1 A0#8pin@215_polysilicon-1##2 9.938
R1285 A0#8pin@215_polysilicon-1##2 A0#8pin@215_polysilicon-1##3 9.938
R1286 A0#8pin@215_polysilicon-1##3 A0#8pin@215_polysilicon-1##4 9.938
R1287 A0#8pin@215_polysilicon-1##4 A0#8pin@215_polysilicon-1##5 9.938
R1288 A0#8pin@215_polysilicon-1##5 A0#8pin@215_polysilicon-1##6 9.938
R1289 A0#8pin@215_polysilicon-1##6 A0#8pin@215_polysilicon-1##7 9.938
R1290 A0#8pin@215_polysilicon-1##7 A0#8pin@215_polysilicon-1##8 9.938
R1291 A0#8pin@215_polysilicon-1##8 A0#8pin@215_polysilicon-1##9 9.938
R1292 A0#8pin@215_polysilicon-1##9 A0#8pin@215_polysilicon-1##10 9.938
R1293 A0#8pin@215_polysilicon-1##10 A0#8pin@215_polysilicon-1##11 9.938
R1294 A0#8pin@215_polysilicon-1##11 A0#8pin@215_polysilicon-1##12 9.938
R1295 A0#8pin@215_polysilicon-1##12 A0#8pin@215_polysilicon-1##13 9.938
R1296 A0#8pin@215_polysilicon-1##13 A0#8pin@215_polysilicon-1##14 9.938
R1297 A0#8pin@215_polysilicon-1##14 A0#8pin@215_polysilicon-1##15 9.938
R1298 A0#8pin@215_polysilicon-1##15 A0#8pin@215_polysilicon-1##16 9.938
R1299 A0#8pin@215_polysilicon-1##16 A0#8pin@215_polysilicon-1##17 9.938
R1300 A0#8pin@215_polysilicon-1##17 A0#8pin@215_polysilicon-1##18 9.938
R1301 A0#8pin@215_polysilicon-1##18 A0#8pin@215_polysilicon-1##19 9.938
R1302 A0#8pin@215_polysilicon-1##19 A0#8pin@215_polysilicon-1##20 9.938
R1303 A0#8pin@215_polysilicon-1##20 A0#8pin@215_polysilicon-1##21 9.938
R1304 A0#8pin@215_polysilicon-1##21 A0#8pin@215_polysilicon-1##22 9.938
R1305 A0#8pin@215_polysilicon-1##22 A0#8pin@215_polysilicon-1##23 9.938
R1306 A0#8pin@215_polysilicon-1##23 A0#8pin@215_polysilicon-1##24 9.938
R1307 A0#8pin@215_polysilicon-1##24 A0#8pin@215_polysilicon-1##25 9.938
R1308 A0#8pin@215_polysilicon-1##25 A0#8pin@215_polysilicon-1##26 9.938
R1309 A0#8pin@215_polysilicon-1##26 A0#8pin@215_polysilicon-1##27 9.938
R1310 A0#8pin@215_polysilicon-1##27 A0#8pin@215_polysilicon-1##28 9.938
R1311 A0#8pin@215_polysilicon-1##28 A0#8pin@215_polysilicon-1##29 9.938
R1312 A0#8pin@215_polysilicon-1##29 A0#8pin@215_polysilicon-1##30 9.938
R1313 A0#8pin@215_polysilicon-1##30 A0#8pin@215_polysilicon-1##31 9.938
R1314 A0#8pin@215_polysilicon-1##31 A0#8pin@215_polysilicon-1##32 9.938
R1315 A0#8pin@215_polysilicon-1##32 A0#8pin@215_polysilicon-1##33 9.938
R1316 A0#8pin@215_polysilicon-1##33 A0#8pin@215_polysilicon-1##34 9.938
R1317 A0#8pin@215_polysilicon-1##34 A0#8pin@215_polysilicon-1##35 9.938
R1318 A0#8pin@215_polysilicon-1##35 A0#8pin@215_polysilicon-1##36 9.938
R1319 A0#8pin@215_polysilicon-1##36 A0#8pin@215_polysilicon-1##37 9.938
R1320 A0#8pin@215_polysilicon-1##37 A0#8pin@215_polysilicon-1##38 9.938
R1321 A0#8pin@215_polysilicon-1##38 A0#8pin@215_polysilicon-1##39 9.938
R1322 A0#8pin@215_polysilicon-1##39 A0#8pin@215_polysilicon-1##40 9.938
R1323 A0#8pin@215_polysilicon-1##40 A0#8pin@215_polysilicon-1##41 9.938
R1324 A0#8pin@215_polysilicon-1##41 A0#8pin@215_polysilicon-1##42 9.938
R1325 A0#8pin@215_polysilicon-1##42 A0#8pin@215_polysilicon-1##43 9.938
R1326 A0#8pin@215_polysilicon-1##43 A0#8pin@215_polysilicon-1##44 9.938
R1327 A0#8pin@215_polysilicon-1##44 A0#8pin@215_polysilicon-1##45 9.938
R1328 A0#8pin@215_polysilicon-1##45 A0#8pin@215_polysilicon-1##46 9.938
R1329 A0#8pin@215_polysilicon-1##46 A0#8pin@215_polysilicon-1##47 9.938
R1330 A0#8pin@215_polysilicon-1##47 A0#8pin@215_polysilicon-1##48 9.938
R1331 A0#8pin@215_polysilicon-1##48 A0#8pin@215_polysilicon-1##49 9.938
R1332 A0#8pin@215_polysilicon-1##49 A0#17nmos@56_poly-right 9.938
R1333 B0#18pmos@57_poly-right B0#18pmos@57_poly-right##0 9.869
R1334 B0#18pmos@57_poly-right##0 B0#18pmos@57_poly-right##1 9.869
R1335 B0#18pmos@57_poly-right##1 B0#18pmos@57_poly-right##2 9.869
R1336 B0#18pmos@57_poly-right##2 B0#18pmos@57_poly-right##3 9.869
R1337 B0#18pmos@57_poly-right##3 B0#18pmos@57_poly-right##4 9.869
R1338 B0#18pmos@57_poly-right##4 B0#18pmos@57_poly-right##5 9.869
R1339 B0#18pmos@57_poly-right##5 B0#18pmos@57_poly-right##6 9.869
R1340 B0#18pmos@57_poly-right##6 B0#18pmos@57_poly-right##7 9.869
R1341 B0#18pmos@57_poly-right##7 B0#18pmos@57_poly-right##8 9.869
R1342 B0#18pmos@57_poly-right##8 B0#18pmos@57_poly-right##9 9.869
R1343 B0#18pmos@57_poly-right##9 B0#18pmos@57_poly-right##10 9.869
R1344 B0#18pmos@57_poly-right##10 B0#18pmos@57_poly-right##11 9.869
R1345 B0#18pmos@57_poly-right##11 B0#18pmos@57_poly-right##12 9.869
R1346 B0#18pmos@57_poly-right##12 B0#18pmos@57_poly-right##13 9.869
R1347 B0#18pmos@57_poly-right##13 B0#18pmos@57_poly-right##14 9.869
R1348 B0#18pmos@57_poly-right##14 B0#18pmos@57_poly-right##15 9.869
R1349 B0#18pmos@57_poly-right##15 B0#18pmos@57_poly-right##16 9.869
R1350 B0#18pmos@57_poly-right##16 B0#18pmos@57_poly-right##17 9.869
R1351 B0#18pmos@57_poly-right##17 B0#18pmos@57_poly-right##18 9.869
R1352 B0#18pmos@57_poly-right##18 B0#18pmos@57_poly-right##19 9.869
R1353 B0#18pmos@57_poly-right##19 B0#18pmos@57_poly-right##20 9.869
R1354 B0#18pmos@57_poly-right##20 B0#18pmos@57_poly-right##21 9.869
R1355 B0#18pmos@57_poly-right##21 B0#18pmos@57_poly-right##22 9.869
R1356 B0#18pmos@57_poly-right##22 B0#18pmos@57_poly-right##23 9.869
R1357 B0#18pmos@57_poly-right##23 B0#18pmos@57_poly-right##24 9.869
R1358 B0#18pmos@57_poly-right##24 B0#18pmos@57_poly-right##25 9.869
R1359 B0#18pmos@57_poly-right##25 B0#18pmos@57_poly-right##26 9.869
R1360 B0#18pmos@57_poly-right##26 B0#18pmos@57_poly-right##27 9.869
R1361 B0#18pmos@57_poly-right##27 B0#18pmos@57_poly-right##28 9.869
R1362 B0#18pmos@57_poly-right##28 B0#18pmos@57_poly-right##29 9.869
R1363 B0#18pmos@57_poly-right##29 B0#18pmos@57_poly-right##30 9.869
R1364 B0#18pmos@57_poly-right##30 B0#18pmos@57_poly-right##31 9.869
R1365 B0#18pmos@57_poly-right##31 B0#18pmos@57_poly-right##32 9.869
R1366 B0#18pmos@57_poly-right##32 B0#18pmos@57_poly-right##33 9.869
R1367 B0#18pmos@57_poly-right##33 B0#18pmos@57_poly-right##34 9.869
R1368 B0#18pmos@57_poly-right##34 B0#18pmos@57_poly-right##35 9.869
R1369 B0#18pmos@57_poly-right##35 B0#18pmos@57_poly-right##36 9.869
R1370 B0#18pmos@57_poly-right##36 B0#18pmos@57_poly-right##37 9.869
R1371 B0#18pmos@57_poly-right##37 B0#18pmos@57_poly-right##38 9.869
R1372 B0#18pmos@57_poly-right##38 B0#18pmos@57_poly-right##39 9.869
R1373 B0#18pmos@57_poly-right##39 B0#18pmos@57_poly-right##40 9.869
R1374 B0#18pmos@57_poly-right##40 B0#18pmos@57_poly-right##41 9.869
R1375 B0#18pmos@57_poly-right##41 B0#18pmos@57_poly-right##42 9.869
R1376 B0#18pmos@57_poly-right##42 B0#18pmos@57_poly-right##43 9.869
R1377 B0#18pmos@57_poly-right##43 B0#18pmos@57_poly-right##44 9.869
R1378 B0#18pmos@57_poly-right##44 B0#18pmos@57_poly-right##45 9.869
R1379 B0#18pmos@57_poly-right##45 B0#18pmos@57_poly-right##46 9.869
R1380 B0#18pmos@57_poly-right##46 B0#18pmos@57_poly-right##47 9.869
R1381 B0#18pmos@57_poly-right##47 B0#8pin@220_polysilicon-1 9.869
R1382 NAND2_to_Nand3#9pin@224_polysilicon-1 NAND2_to_Nand3#9pin@224_polysilicon-1##0 9.938
R1383 NAND2_to_Nand3#9pin@224_polysilicon-1##0 NAND2_to_Nand3#9pin@224_polysilicon-1##1 9.938
R1384 NAND2_to_Nand3#9pin@224_polysilicon-1##1 NAND2_to_Nand3#9pin@224_polysilicon-1##2 9.938
R1385 NAND2_to_Nand3#9pin@224_polysilicon-1##2 NAND2_to_Nand3#9pin@224_polysilicon-1##3 9.938
R1386 NAND2_to_Nand3#9pin@224_polysilicon-1##3 NAND2_to_Nand3#9pin@224_polysilicon-1##4 9.938
R1387 NAND2_to_Nand3#9pin@224_polysilicon-1##4 NAND2_to_Nand3#9pin@224_polysilicon-1##5 9.938
R1388 NAND2_to_Nand3#9pin@224_polysilicon-1##5 NAND2_to_Nand3#9pin@224_polysilicon-1##6 9.938
R1389 NAND2_to_Nand3#9pin@224_polysilicon-1##6 NAND2_to_Nand3#9pin@224_polysilicon-1##7 9.938
R1390 NAND2_to_Nand3#9pin@224_polysilicon-1##7 NAND2_to_Nand3#9pin@224_polysilicon-1##8 9.938
R1391 NAND2_to_Nand3#9pin@224_polysilicon-1##8 NAND2_to_Nand3#9pin@224_polysilicon-1##9 9.938
R1392 NAND2_to_Nand3#9pin@224_polysilicon-1##9 NAND2_to_Nand3#9pin@224_polysilicon-1##10 9.938
R1393 NAND2_to_Nand3#9pin@224_polysilicon-1##10 NAND2_to_Nand3#9pin@224_polysilicon-1##11 9.938
R1394 NAND2_to_Nand3#9pin@224_polysilicon-1##11 NAND2_to_Nand3#9pin@224_polysilicon-1##12 9.938
R1395 NAND2_to_Nand3#9pin@224_polysilicon-1##12 NAND2_to_Nand3#9pin@224_polysilicon-1##13 9.938
R1396 NAND2_to_Nand3#9pin@224_polysilicon-1##13 NAND2_to_Nand3#9pin@224_polysilicon-1##14 9.938
R1397 NAND2_to_Nand3#9pin@224_polysilicon-1##14 NAND2_to_Nand3#9pin@224_polysilicon-1##15 9.938
R1398 NAND2_to_Nand3#9pin@224_polysilicon-1##15 NAND2_to_Nand3#9pin@224_polysilicon-1##16 9.938
R1399 NAND2_to_Nand3#9pin@224_polysilicon-1##16 NAND2_to_Nand3#9pin@224_polysilicon-1##17 9.938
R1400 NAND2_to_Nand3#9pin@224_polysilicon-1##17 NAND2_to_Nand3#9pin@224_polysilicon-1##18 9.938
R1401 NAND2_to_Nand3#9pin@224_polysilicon-1##18 NAND2_to_Nand3#9pin@224_polysilicon-1##19 9.938
R1402 NAND2_to_Nand3#9pin@224_polysilicon-1##19 NAND2_to_Nand3#9pin@224_polysilicon-1##20 9.938
R1403 NAND2_to_Nand3#9pin@224_polysilicon-1##20 NAND2_to_Nand3#9pin@224_polysilicon-1##21 9.938
R1404 NAND2_to_Nand3#9pin@224_polysilicon-1##21 NAND2_to_Nand3#9pin@224_polysilicon-1##22 9.938
R1405 NAND2_to_Nand3#9pin@224_polysilicon-1##22 NAND2_to_Nand3#9pin@224_polysilicon-1##23 9.938
R1406 NAND2_to_Nand3#9pin@224_polysilicon-1##23 NAND2_to_Nand3#9pin@224_polysilicon-1##24 9.938
R1407 NAND2_to_Nand3#9pin@224_polysilicon-1##24 NAND2_to_Nand3#9pin@224_polysilicon-1##25 9.938
R1408 NAND2_to_Nand3#9pin@224_polysilicon-1##25 NAND2_to_Nand3#9pin@224_polysilicon-1##26 9.938
R1409 NAND2_to_Nand3#9pin@224_polysilicon-1##26 NAND2_to_Nand3#9pin@224_polysilicon-1##27 9.938
R1410 NAND2_to_Nand3#9pin@224_polysilicon-1##27 NAND2_to_Nand3#9pin@224_polysilicon-1##28 9.938
R1411 NAND2_to_Nand3#9pin@224_polysilicon-1##28 NAND2_to_Nand3#9pin@224_polysilicon-1##29 9.938
R1412 NAND2_to_Nand3#9pin@224_polysilicon-1##29 NAND2_to_Nand3#9pin@224_polysilicon-1##30 9.938
R1413 NAND2_to_Nand3#9pin@224_polysilicon-1##30 NAND2_to_Nand3#9pin@224_polysilicon-1##31 9.938
R1414 NAND2_to_Nand3#9pin@224_polysilicon-1##31 NAND2_to_Nand3#9pin@224_polysilicon-1##32 9.938
R1415 NAND2_to_Nand3#9pin@224_polysilicon-1##32 NAND2_to_Nand3#9pin@224_polysilicon-1##33 9.938
R1416 NAND2_to_Nand3#9pin@224_polysilicon-1##33 NAND2_to_Nand3#9pin@224_polysilicon-1##34 9.938
R1417 NAND2_to_Nand3#9pin@224_polysilicon-1##34 NAND2_to_Nand3#9pin@224_polysilicon-1##35 9.938
R1418 NAND2_to_Nand3#9pin@224_polysilicon-1##35 NAND2_to_Nand3#9pin@224_polysilicon-1##36 9.938
R1419 NAND2_to_Nand3#9pin@224_polysilicon-1##36 NAND2_to_Nand3#9pin@224_polysilicon-1##37 9.938
R1420 NAND2_to_Nand3#9pin@224_polysilicon-1##37 NAND2_to_Nand3#9pin@224_polysilicon-1##38 9.938
R1421 NAND2_to_Nand3#9pin@224_polysilicon-1##38 NAND2_to_Nand3#9pin@224_polysilicon-1##39 9.938
R1422 NAND2_to_Nand3#9pin@224_polysilicon-1##39 NAND2_to_Nand3#9pin@224_polysilicon-1##40 9.938
R1423 NAND2_to_Nand3#9pin@224_polysilicon-1##40 NAND2_to_Nand3#9pin@224_polysilicon-1##41 9.938
R1424 NAND2_to_Nand3#9pin@224_polysilicon-1##41 NAND2_to_Nand3#9pin@224_polysilicon-1##42 9.938
R1425 NAND2_to_Nand3#9pin@224_polysilicon-1##42 NAND2_to_Nand3#9pin@224_polysilicon-1##43 9.938
R1426 NAND2_to_Nand3#9pin@224_polysilicon-1##43 NAND2_to_Nand3#9pin@224_polysilicon-1##44 9.938
R1427 NAND2_to_Nand3#9pin@224_polysilicon-1##44 NAND2_to_Nand3#9pin@224_polysilicon-1##45 9.938
R1428 NAND2_to_Nand3#9pin@224_polysilicon-1##45 NAND2_to_Nand3#9pin@224_polysilicon-1##46 9.938
R1429 NAND2_to_Nand3#9pin@224_polysilicon-1##46 NAND2_to_Nand3#9pin@224_polysilicon-1##47 9.938
R1430 NAND2_to_Nand3#9pin@224_polysilicon-1##47 NAND2_to_Nand3#9pin@224_polysilicon-1##48 9.938
R1431 NAND2_to_Nand3#9pin@224_polysilicon-1##48 NAND2_to_Nand3#9pin@224_polysilicon-1##49 9.938
R1432 NAND2_to_Nand3#9pin@224_polysilicon-1##49 NAND2_to_Nand3#11nmos@58_poly-right 9.938
R1433 NAND1_to_NAND3#14nmos@59_poly-right NAND1_to_NAND3#14nmos@59_poly-right##0 9.898
R1434 NAND1_to_NAND3#14nmos@59_poly-right##0 NAND1_to_NAND3#14nmos@59_poly-right##1 9.898
R1435 NAND1_to_NAND3#14nmos@59_poly-right##1 NAND1_to_NAND3#14nmos@59_poly-right##2 9.898
R1436 NAND1_to_NAND3#14nmos@59_poly-right##2 NAND1_to_NAND3#14nmos@59_poly-right##3 9.898
R1437 NAND1_to_NAND3#14nmos@59_poly-right##3 NAND1_to_NAND3#14nmos@59_poly-right##4 9.898
R1438 NAND1_to_NAND3#14nmos@59_poly-right##4 NAND1_to_NAND3#14nmos@59_poly-right##5 9.898
R1439 NAND1_to_NAND3#14nmos@59_poly-right##5 NAND1_to_NAND3#14nmos@59_poly-right##6 9.898
R1440 NAND1_to_NAND3#14nmos@59_poly-right##6 NAND1_to_NAND3#14nmos@59_poly-right##7 9.898
R1441 NAND1_to_NAND3#14nmos@59_poly-right##7 NAND1_to_NAND3#14nmos@59_poly-right##8 9.898
R1442 NAND1_to_NAND3#14nmos@59_poly-right##8 NAND1_to_NAND3#14nmos@59_poly-right##9 9.898
R1443 NAND1_to_NAND3#14nmos@59_poly-right##9 NAND1_to_NAND3#14nmos@59_poly-right##10 9.898
R1444 NAND1_to_NAND3#14nmos@59_poly-right##10 NAND1_to_NAND3#14nmos@59_poly-right##11 9.898
R1445 NAND1_to_NAND3#14nmos@59_poly-right##11 NAND1_to_NAND3#14nmos@59_poly-right##12 9.898
R1446 NAND1_to_NAND3#14nmos@59_poly-right##12 NAND1_to_NAND3#14nmos@59_poly-right##13 9.898
R1447 NAND1_to_NAND3#14nmos@59_poly-right##13 NAND1_to_NAND3#14nmos@59_poly-right##14 9.898
R1448 NAND1_to_NAND3#14nmos@59_poly-right##14 NAND1_to_NAND3#14nmos@59_poly-right##15 9.898
R1449 NAND1_to_NAND3#14nmos@59_poly-right##15 NAND1_to_NAND3#14nmos@59_poly-right##16 9.898
R1450 NAND1_to_NAND3#14nmos@59_poly-right##16 NAND1_to_NAND3#14nmos@59_poly-right##17 9.898
R1451 NAND1_to_NAND3#14nmos@59_poly-right##17 NAND1_to_NAND3#14nmos@59_poly-right##18 9.898
R1452 NAND1_to_NAND3#14nmos@59_poly-right##18 NAND1_to_NAND3#14nmos@59_poly-right##19 9.898
R1453 NAND1_to_NAND3#14nmos@59_poly-right##19 NAND1_to_NAND3#14nmos@59_poly-right##20 9.898
R1454 NAND1_to_NAND3#14nmos@59_poly-right##20 NAND1_to_NAND3#14nmos@59_poly-right##21 9.898
R1455 NAND1_to_NAND3#14nmos@59_poly-right##21 NAND1_to_NAND3#14nmos@59_poly-right##22 9.898
R1456 NAND1_to_NAND3#14nmos@59_poly-right##22 NAND1_to_NAND3#14nmos@59_poly-right##23 9.898
R1457 NAND1_to_NAND3#14nmos@59_poly-right##23 NAND1_to_NAND3#14nmos@59_poly-right##24 9.898
R1458 NAND1_to_NAND3#14nmos@59_poly-right##24 NAND1_to_NAND3#14nmos@59_poly-right##25 9.898
R1459 NAND1_to_NAND3#14nmos@59_poly-right##25 NAND1_to_NAND3#14nmos@59_poly-right##26 9.898
R1460 NAND1_to_NAND3#14nmos@59_poly-right##26 NAND1_to_NAND3#14nmos@59_poly-right##27 9.898
R1461 NAND1_to_NAND3#14nmos@59_poly-right##27 NAND1_to_NAND3#14nmos@59_poly-right##28 9.898
R1462 NAND1_to_NAND3#14nmos@59_poly-right##28 NAND1_to_NAND3#14nmos@59_poly-right##29 9.898
R1463 NAND1_to_NAND3#14nmos@59_poly-right##29 NAND1_to_NAND3#14nmos@59_poly-right##30 9.898
R1464 NAND1_to_NAND3#14nmos@59_poly-right##30 NAND1_to_NAND3#14nmos@59_poly-right##31 9.898
R1465 NAND1_to_NAND3#14nmos@59_poly-right##31 NAND1_to_NAND3#14nmos@59_poly-right##32 9.898
R1466 NAND1_to_NAND3#14nmos@59_poly-right##32 NAND1_to_NAND3#14nmos@59_poly-right##33 9.898
R1467 NAND1_to_NAND3#14nmos@59_poly-right##33 NAND1_to_NAND3#14nmos@59_poly-right##34 9.898
R1468 NAND1_to_NAND3#14nmos@59_poly-right##34 NAND1_to_NAND3#14nmos@59_poly-right##35 9.898
R1469 NAND1_to_NAND3#14nmos@59_poly-right##35 NAND1_to_NAND3#14nmos@59_poly-right##36 9.898
R1470 NAND1_to_NAND3#14nmos@59_poly-right##36 NAND1_to_NAND3#14nmos@59_poly-right##37 9.898
R1471 NAND1_to_NAND3#14nmos@59_poly-right##37 NAND1_to_NAND3#14nmos@59_poly-right##38 9.898
R1472 NAND1_to_NAND3#14nmos@59_poly-right##38 NAND1_to_NAND3#14nmos@59_poly-right##39 9.898
R1473 NAND1_to_NAND3#14nmos@59_poly-right##39 NAND1_to_NAND3#14nmos@59_poly-right##40 9.898
R1474 NAND1_to_NAND3#14nmos@59_poly-right##40 NAND1_to_NAND3#14nmos@59_poly-right##41 9.898
R1475 NAND1_to_NAND3#14nmos@59_poly-right##41 NAND1_to_NAND3#14nmos@59_poly-right##42 9.898
R1476 NAND1_to_NAND3#14nmos@59_poly-right##42 NAND1_to_NAND3#14nmos@59_poly-right##43 9.898
R1477 NAND1_to_NAND3#14nmos@59_poly-right##43 NAND1_to_NAND3#14nmos@59_poly-right##44 9.898
R1478 NAND1_to_NAND3#14nmos@59_poly-right##44 NAND1_to_NAND3#14nmos@59_poly-right##45 9.898
R1479 NAND1_to_NAND3#14nmos@59_poly-right##45 NAND1_to_NAND3#14nmos@59_poly-right##46 9.898
R1480 NAND1_to_NAND3#14nmos@59_poly-right##46 NAND1_to_NAND3#14nmos@59_poly-right##47 9.898
R1481 NAND1_to_NAND3#14nmos@59_poly-right##47 NAND1_to_NAND3#14nmos@59_poly-right##48 9.898
R1482 NAND1_to_NAND3#14nmos@59_poly-right##48 NAND1_to_NAND3#14nmos@59_poly-right##49 9.898
R1483 NAND1_to_NAND3#14nmos@59_poly-right##49 NAND1_to_NAND3#14nmos@59_poly-right##50 9.898
R1484 NAND1_to_NAND3#14nmos@59_poly-right##50 NAND1_to_NAND3#14nmos@59_poly-right##51 9.898
R1485 NAND1_to_NAND3#14nmos@59_poly-right##51 NAND1_to_NAND3#14nmos@59_poly-right##52 9.898
R1486 NAND1_to_NAND3#14nmos@59_poly-right##52 NAND1_to_NAND3#14nmos@59_poly-right##53 9.898
R1487 NAND1_to_NAND3#14nmos@59_poly-right##53 NAND1_to_NAND3#14nmos@59_poly-right##54 9.898
R1488 NAND1_to_NAND3#14nmos@59_poly-right##54 NAND1_to_NAND3#14nmos@59_poly-right##55 9.898
R1489 NAND1_to_NAND3#14nmos@59_poly-right##55 NAND1_to_NAND3#11pmos@59_poly-right 9.898
R1490 NAND2_to_Nand3 NAND2_to_Nand3#4nmos@57_diff-bottom 4.42
R1491 net@1209 net@1209##0 9.92
R1492 net@1209##0 net@1209##1 9.92
R1493 net@1209##1 net@1209##2 9.92
R1494 net@1209##2 net@1209##3 9.92
R1495 net@1209##3 net@1209##4 9.92
R1496 net@1209##4 net@1209##5 9.92
R1497 net@1209##5 net@1209##6 9.92
R1498 net@1209##6 net@1209##7 9.92
R1499 net@1209##7 net@1209##8 9.92
R1500 net@1209##8 net@1209##9 9.92
R1501 net@1209##9 net@1209##10 9.92
R1502 net@1209##10 net@1209##11 9.92
R1503 net@1209##11 net@1209##12 9.92
R1504 net@1209##12 net@1209##13 9.92
R1505 net@1209##13 net@1209##14 9.92
R1506 net@1209##14 net@1209##15 9.92
R1507 net@1209##15 net@1209##16 9.92
R1508 net@1209##16 net@1209##17 9.92
R1509 net@1209##17 net@1209##18 9.92
R1510 net@1209##18 net@1209#1pin@352_polysilicon-1 9.92
R1511 net@1211 net@1211##0 9.92
R1512 net@1211##0 net@1211##1 9.92
R1513 net@1211##1 net@1211##2 9.92
R1514 net@1211##2 net@1211##3 9.92
R1515 net@1211##3 net@1211##4 9.92
R1516 net@1211##4 net@1211##5 9.92
R1517 net@1211##5 net@1211##6 9.92
R1518 net@1211##6 net@1211##7 9.92
R1519 net@1211##7 net@1211##8 9.92
R1520 net@1211##8 net@1211##9 9.92
R1521 net@1211##9 net@1211##10 9.92
R1522 net@1211##10 net@1211##11 9.92
R1523 net@1211##11 net@1211##12 9.92
R1524 net@1211##12 net@1211##13 9.92
R1525 net@1211##13 net@1211##14 9.92
R1526 net@1211##14 net@1211##15 9.92
R1527 net@1211##15 net@1211##16 9.92
R1528 net@1211##16 net@1211##17 9.92
R1529 net@1211##17 net@1211##18 9.92
R1530 net@1211##18 net@1211#1pin@377_polysilicon-1 9.92
R1531 XOR1_to_NAND2#3pin@378_polysilicon-1 XOR1_to_NAND2#3pin@378_polysilicon-1##0 6.2
R1532 XOR1_to_NAND2#3pin@378_polysilicon-1##0 XOR1_to_NAND2#4pmos@72_poly-right 6.2
R1533 XOR1_to_NAND2#3pin@378_polysilicon-1 XOR1_to_NAND2#3pin@378_polysilicon-1##0 8.138
R1534 XOR1_to_NAND2#3pin@378_polysilicon-1##0 XOR1_to_NAND2#3pin@378_polysilicon-1##1 8.138
R1535 XOR1_to_NAND2#3pin@378_polysilicon-1##1 XOR1_to_NAND2#3pin@378_polysilicon-1##2 8.138
R1536 XOR1_to_NAND2#3pin@378_polysilicon-1##2 XOR1_to_NAND2#1contact@544_metal-1-metal-2 8.138
R1537 Cin_to_XOR2___NAND2#14nmos@71_poly-right Cin_to_XOR2___NAND2#14nmos@71_poly-right##0 5.425
R1538 Cin_to_XOR2___NAND2#14nmos@71_poly-right##0 Cin_to_XOR2___NAND2#15pin@368_polysilicon-1 5.425
R1539 Cin_to_XOR2___NAND2 Cin_to_XOR2___NAND2##0 8.99
R1540 Cin_to_XOR2___NAND2##0 Cin_to_XOR2___NAND2##1 8.99
R1541 Cin_to_XOR2___NAND2##1 Cin_to_XOR2___NAND2##2 8.99
R1542 Cin_to_XOR2___NAND2##2 Cin_to_XOR2___NAND2##3 8.99
R1543 Cin_to_XOR2___NAND2##3 Cin_to_XOR2___NAND2#15pin@368_polysilicon-1 8.99
R1544 A1#4pin@353_polysilicon-1 A1#4pin@353_polysilicon-1##0 6.2
R1545 A1#4pin@353_polysilicon-1##0 A1#5pmos@65_poly-right 6.2
R1546 XOR1_to_NAND2#9pmos@67_poly-left XOR1_to_NAND2#9pmos@67_poly-left##0 8.138
R1547 XOR1_to_NAND2#9pmos@67_poly-left##0 XOR1_to_NAND2#9pmos@67_poly-left##1 8.138
R1548 XOR1_to_NAND2#9pmos@67_poly-left##1 XOR1_to_NAND2#9pmos@67_poly-left##2 8.138
R1549 XOR1_to_NAND2#9pmos@67_poly-left##2 XOR1_to_NAND2#10pin@365_polysilicon-1 8.138
R1550 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##0 9.843
R1551 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##0 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##1 9.843
R1552 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##1 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##2 9.843
R1553 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##2 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##3 9.843
R1554 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##3 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##4 9.843
R1555 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##4 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##5 9.843
R1556 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##5 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##6 9.843
R1557 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##6 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##7 9.843
R1558 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##7 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##8 9.843
R1559 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##8 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##9 9.843
R1560 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##9 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##10 9.843
R1561 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##10 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##11 9.843
R1562 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##11 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##12 9.843
R1563 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##12 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##13 9.843
R1564 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##13 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##14 9.843
R1565 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##14 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##15 9.843
R1566 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##15 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##16 9.843
R1567 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##16 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##17 9.843
R1568 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##17 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##18 9.843
R1569 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##18 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1 9.843
R1570 net@1220#4nmos@73_poly-right net@1220#4nmos@73_poly-right##0 9.3
R1571 net@1220#4nmos@73_poly-right##0 net@1220#4nmos@73_poly-right##1 9.3
R1572 net@1220#4nmos@73_poly-right##1 net@1220#5pin@370_polysilicon-1 9.3
R1573 net@1220#2contact@530_metal-1-polysilicon-1 net@1220#2contact@530_metal-1-polysilicon-1##0 8.99
R1574 net@1220#2contact@530_metal-1-polysilicon-1##0 net@1220#2contact@530_metal-1-polysilicon-1##1 8.99
R1575 net@1220#2contact@530_metal-1-polysilicon-1##1 net@1220#2contact@530_metal-1-polysilicon-1##2 8.99
R1576 net@1220#2contact@530_metal-1-polysilicon-1##2 net@1220#2contact@530_metal-1-polysilicon-1##3 8.99
R1577 net@1220#2contact@530_metal-1-polysilicon-1##3 net@1220#5pin@370_polysilicon-1 8.99
R1578 A1#4pin@353_polysilicon-1 A1#4pin@353_polysilicon-1##0 8.138
R1579 A1#4pin@353_polysilicon-1##0 A1#4pin@353_polysilicon-1##1 8.138
R1580 A1#4pin@353_polysilicon-1##1 A1#4pin@353_polysilicon-1##2 8.138
R1581 A1#4pin@353_polysilicon-1##2 A1#1pin@517_metal-2 8.138
R1582 XOR1_to_NAND2#1contact@544_metal-1-metal-2 XOR1_to_NAND2#1contact@544_metal-1-metal-2##0 6.717
R1583 XOR1_to_NAND2#1contact@544_metal-1-metal-2##0 XOR1_to_NAND2#1contact@544_metal-1-metal-2##1 6.717
R1584 XOR1_to_NAND2#1contact@544_metal-1-metal-2##1 XOR1_to_NAND2#12pin@366_polysilicon-1 6.717
R1585 XOR1_to_NAND2#10pin@365_polysilicon-1 XOR1_to_NAND2#10pin@365_polysilicon-1##0 7.75
R1586 XOR1_to_NAND2#10pin@365_polysilicon-1##0 XOR1_to_NAND2#10pin@365_polysilicon-1##1 7.75
R1587 XOR1_to_NAND2#10pin@365_polysilicon-1##1 XOR1_to_NAND2#12pin@366_polysilicon-1 7.75
R1588 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1##0 9.743
R1589 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1##0 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1##1 9.743
R1590 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1##1 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1##2 9.743
R1591 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1##2 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1##3 9.743
R1592 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1##3 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1##4 9.743
R1593 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1##4 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1##5 9.743
R1594 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1##5 Cin_to_XOR2___NAND2 9.743
R1595 net@1211#7pmos@68_poly-left net@1211#7pmos@68_poly-left##0 7.75
R1596 net@1211#7pmos@68_poly-left##0 net@1211 7.75
R1597 Cin_to_XOR2___NAND2#18nmos@69_poly-left Cin_to_XOR2___NAND2#18nmos@69_poly-left##0 6.2
R1598 Cin_to_XOR2___NAND2#18nmos@69_poly-left##0 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1 6.2
R1599 net@1221#9nmos@70_poly-left net@1221#9nmos@70_poly-left##0 8.37
R1600 net@1221#9nmos@70_poly-left##0 net@1221#9nmos@70_poly-left##1 8.37
R1601 net@1221#9nmos@70_poly-left##1 net@1221#9nmos@70_poly-left##2 8.37
R1602 net@1221#9nmos@70_poly-left##2 net@1221#9nmos@70_poly-left##3 8.37
R1603 net@1221#9nmos@70_poly-left##3 net@1221#2contact@505_metal-1-metal-2 8.37
R1604 XOR1_to_NAND2 XOR1_to_NAND2##0 6.717
R1605 XOR1_to_NAND2##0 XOR1_to_NAND2##1 6.717
R1606 XOR1_to_NAND2##1 XOR1_to_NAND2#14pin@382_polysilicon-1 6.717
R1607 XOR1_to_NAND2#16pmos@74_poly-right XOR1_to_NAND2#16pmos@74_poly-right##0 6.2
R1608 XOR1_to_NAND2#16pmos@74_poly-right##0 XOR1_to_NAND2#14pin@382_polysilicon-1 6.2
R1609 Cin_to_XOR2___NAND2#23pin@386_polysilicon-1 Cin_to_XOR2___NAND2#23pin@386_polysilicon-1##0 9.688
R1610 Cin_to_XOR2___NAND2#23pin@386_polysilicon-1##0 Cin_to_XOR2___NAND2#23pin@386_polysilicon-1##1 9.688
R1611 Cin_to_XOR2___NAND2#23pin@386_polysilicon-1##1 Cin_to_XOR2___NAND2#23pin@386_polysilicon-1##2 9.688
R1612 Cin_to_XOR2___NAND2#23pin@386_polysilicon-1##2 Cin_to_XOR2___NAND2#20contact@543_metal-1-metal-2 9.688
R1613 Cin_to_XOR2___NAND2#20contact@543_metal-1-metal-2 Cin_to_XOR2___NAND2 4.953
R1614 A1#2contact@552_metal-1-metal-2 A1#2contact@552_metal-1-metal-2##0 6.717
R1615 A1#2contact@552_metal-1-metal-2##0 A1#2contact@552_metal-1-metal-2##1 6.717
R1616 A1#2contact@552_metal-1-metal-2##1 A1#11pin@389_polysilicon-1 6.717
R1617 A1#12pmos@76_poly-right A1#12pmos@76_poly-right##0 9.558
R1618 A1#12pmos@76_poly-right##0 A1#12pmos@76_poly-right##1 9.558
R1619 A1#12pmos@76_poly-right##1 A1#12pmos@76_poly-right##2 9.558
R1620 A1#12pmos@76_poly-right##2 A1#12pmos@76_poly-right##3 9.558
R1621 A1#12pmos@76_poly-right##3 A1#12pmos@76_poly-right##4 9.558
R1622 A1#12pmos@76_poly-right##4 A1#11pin@389_polysilicon-1 9.558
R1623 B1#11pin@393_polysilicon-1 B1#11pin@393_polysilicon-1##0 8.138
R1624 B1#11pin@393_polysilicon-1##0 B1#11pin@393_polysilicon-1##1 8.138
R1625 B1#11pin@393_polysilicon-1##1 B1#11pin@393_polysilicon-1##2 8.138
R1626 B1#11pin@393_polysilicon-1##2 B1#2contact@553_metal-1-metal-2 8.138
R1627 B1#12nmos@64_poly-right B1#12nmos@64_poly-right##0 5.425
R1628 B1#12nmos@64_poly-right##0 B1#13pin@343_polysilicon-1 5.425
R1629 NAND2_to_Nand4 NAND2_to_Nand4##0 6.717
R1630 NAND2_to_Nand4##0 NAND2_to_Nand4##1 6.717
R1631 NAND2_to_Nand4##1 NAND2_to_Nand4#9pin@395_polysilicon-1 6.717
R1632 NAND2_to_Nand4#10pmos@78_poly-right NAND2_to_Nand4#10pmos@78_poly-right##0 9.558
R1633 NAND2_to_Nand4#10pmos@78_poly-right##0 NAND2_to_Nand4#10pmos@78_poly-right##1 9.558
R1634 NAND2_to_Nand4#10pmos@78_poly-right##1 NAND2_to_Nand4#10pmos@78_poly-right##2 9.558
R1635 NAND2_to_Nand4#10pmos@78_poly-right##2 NAND2_to_Nand4#10pmos@78_poly-right##3 9.558
R1636 NAND2_to_Nand4#10pmos@78_poly-right##3 NAND2_to_Nand4#10pmos@78_poly-right##4 9.558
R1637 NAND2_to_Nand4#10pmos@78_poly-right##4 NAND2_to_Nand4#9pin@395_polysilicon-1 9.558
R1638 B1#0pin@508_metal-2 B1#0pin@508_metal-2##0 8.99
R1639 B1#0pin@508_metal-2##0 B1#0pin@508_metal-2##1 8.99
R1640 B1#0pin@508_metal-2##1 B1#0pin@508_metal-2##2 8.99
R1641 B1#0pin@508_metal-2##2 B1#0pin@508_metal-2##3 8.99
R1642 B1#0pin@508_metal-2##3 B1#13pin@343_polysilicon-1 8.99
R1643 NAND1_to_NAND4#11pmos@79_poly-right NAND1_to_NAND4#11pmos@79_poly-right##0 5.425
R1644 NAND1_to_NAND4#11pmos@79_poly-right##0 NAND1_to_NAND4#12pin@399_polysilicon-1 5.425
R1645 NAND1_to_NAND4#12pin@399_polysilicon-1 NAND1_to_NAND4#12pin@399_polysilicon-1##0 9.3
R1646 NAND1_to_NAND4#12pin@399_polysilicon-1##0 NAND1_to_NAND4#12pin@399_polysilicon-1##1 9.3
R1647 NAND1_to_NAND4#12pin@399_polysilicon-1##1 NAND1_to_NAND4 9.3
R1648 Cin_to_XOR2___NAND2#25nmos@75_poly-right Cin_to_XOR2___NAND2#25nmos@75_poly-right##0 8.636
R1649 Cin_to_XOR2___NAND2#25nmos@75_poly-right##0 Cin_to_XOR2___NAND2#25nmos@75_poly-right##1 8.636
R1650 Cin_to_XOR2___NAND2#25nmos@75_poly-right##1 Cin_to_XOR2___NAND2#25nmos@75_poly-right##2 8.636
R1651 Cin_to_XOR2___NAND2#25nmos@75_poly-right##2 Cin_to_XOR2___NAND2#25nmos@75_poly-right##3 8.636
R1652 Cin_to_XOR2___NAND2#25nmos@75_poly-right##3 Cin_to_XOR2___NAND2#25nmos@75_poly-right##4 8.636
R1653 Cin_to_XOR2___NAND2#25nmos@75_poly-right##4 Cin_to_XOR2___NAND2#25nmos@75_poly-right##5 8.636
R1654 Cin_to_XOR2___NAND2#25nmos@75_poly-right##5 Cin_to_XOR2___NAND2#23pin@386_polysilicon-1 8.636
R1655 B1#14nmos@77_poly-right B1#14nmos@77_poly-right##0 8.956
R1656 B1#14nmos@77_poly-right##0 B1#14nmos@77_poly-right##1 8.956
R1657 B1#14nmos@77_poly-right##1 B1#14nmos@77_poly-right##2 8.956
R1658 B1#14nmos@77_poly-right##2 B1#14nmos@77_poly-right##3 8.956
R1659 B1#14nmos@77_poly-right##3 B1#14nmos@77_poly-right##4 8.956
R1660 B1#14nmos@77_poly-right##4 B1#14nmos@77_poly-right##5 8.956
R1661 B1#14nmos@77_poly-right##5 B1#14nmos@77_poly-right##6 8.956
R1662 B1#14nmos@77_poly-right##6 B1#14nmos@77_poly-right##7 8.956
R1663 B1#14nmos@77_poly-right##7 B1#11pin@393_polysilicon-1 8.956
R1664 A1#13pmos@60_poly-left A1#13pmos@60_poly-left##0 8.138
R1665 A1#13pmos@60_poly-left##0 A1#13pmos@60_poly-left##1 8.138
R1666 A1#13pmos@60_poly-left##1 A1#13pmos@60_poly-left##2 8.138
R1667 A1#13pmos@60_poly-left##2 A1#14pin@340_polysilicon-1 8.138
R1668 B1#15pin@333_polysilicon-1 B1#15pin@333_polysilicon-1##0 9.843
R1669 B1#15pin@333_polysilicon-1##0 B1#15pin@333_polysilicon-1##1 9.843
R1670 B1#15pin@333_polysilicon-1##1 B1#15pin@333_polysilicon-1##2 9.843
R1671 B1#15pin@333_polysilicon-1##2 B1#15pin@333_polysilicon-1##3 9.843
R1672 B1#15pin@333_polysilicon-1##3 B1#15pin@333_polysilicon-1##4 9.843
R1673 B1#15pin@333_polysilicon-1##4 B1#15pin@333_polysilicon-1##5 9.843
R1674 B1#15pin@333_polysilicon-1##5 B1#15pin@333_polysilicon-1##6 9.843
R1675 B1#15pin@333_polysilicon-1##6 B1#15pin@333_polysilicon-1##7 9.843
R1676 B1#15pin@333_polysilicon-1##7 B1#15pin@333_polysilicon-1##8 9.843
R1677 B1#15pin@333_polysilicon-1##8 B1#15pin@333_polysilicon-1##9 9.843
R1678 B1#15pin@333_polysilicon-1##9 B1#15pin@333_polysilicon-1##10 9.843
R1679 B1#15pin@333_polysilicon-1##10 B1#15pin@333_polysilicon-1##11 9.843
R1680 B1#15pin@333_polysilicon-1##11 B1#15pin@333_polysilicon-1##12 9.843
R1681 B1#15pin@333_polysilicon-1##12 B1#15pin@333_polysilicon-1##13 9.843
R1682 B1#15pin@333_polysilicon-1##13 B1#15pin@333_polysilicon-1##14 9.843
R1683 B1#15pin@333_polysilicon-1##14 B1#15pin@333_polysilicon-1##15 9.843
R1684 B1#15pin@333_polysilicon-1##15 B1#15pin@333_polysilicon-1##16 9.843
R1685 B1#15pin@333_polysilicon-1##16 B1#15pin@333_polysilicon-1##17 9.843
R1686 B1#15pin@333_polysilicon-1##17 B1#15pin@333_polysilicon-1##18 9.843
R1687 B1#15pin@333_polysilicon-1##18 B1#16pin@350_polysilicon-1 9.843
R1688 net@1307#4nmos@66_poly-right net@1307#4nmos@66_poly-right##0 7.233
R1689 net@1307#4nmos@66_poly-right##0 net@1307#4nmos@66_poly-right##1 7.233
R1690 net@1307#4nmos@66_poly-right##1 net@1307#5pin@345_polysilicon-1 7.233
R1691 net@1307#2contact@491_metal-1-polysilicon-1 net@1307#2contact@491_metal-1-polysilicon-1##0 8.99
R1692 net@1307#2contact@491_metal-1-polysilicon-1##0 net@1307#2contact@491_metal-1-polysilicon-1##1 8.99
R1693 net@1307#2contact@491_metal-1-polysilicon-1##1 net@1307#2contact@491_metal-1-polysilicon-1##2 8.99
R1694 net@1307#2contact@491_metal-1-polysilicon-1##2 net@1307#2contact@491_metal-1-polysilicon-1##3 8.99
R1695 net@1307#2contact@491_metal-1-polysilicon-1##3 net@1307#5pin@345_polysilicon-1 8.99
R1696 A1#1pin@517_metal-2 A1#1pin@517_metal-2##0 6.717
R1697 A1#1pin@517_metal-2##0 A1#1pin@517_metal-2##1 6.717
R1698 A1#1pin@517_metal-2##1 A1#16pin@341_polysilicon-1 6.717
R1699 A1#14pin@340_polysilicon-1 A1#14pin@340_polysilicon-1##0 7.75
R1700 A1#14pin@340_polysilicon-1##0 A1#14pin@340_polysilicon-1##1 7.75
R1701 A1#14pin@340_polysilicon-1##1 A1#16pin@341_polysilicon-1 7.75
R1702 B1#16pin@350_polysilicon-1 B1#16pin@350_polysilicon-1##0 9.743
R1703 B1#16pin@350_polysilicon-1##0 B1#16pin@350_polysilicon-1##1 9.743
R1704 B1#16pin@350_polysilicon-1##1 B1#16pin@350_polysilicon-1##2 9.743
R1705 B1#16pin@350_polysilicon-1##2 B1#16pin@350_polysilicon-1##3 9.743
R1706 B1#16pin@350_polysilicon-1##3 B1#16pin@350_polysilicon-1##4 9.743
R1707 B1#16pin@350_polysilicon-1##4 B1#16pin@350_polysilicon-1##5 9.743
R1708 B1#16pin@350_polysilicon-1##5 B1#0pin@508_metal-2 9.743
R1709 net@1209#7pmos@61_poly-left net@1209#7pmos@61_poly-left##0 7.75
R1710 net@1209#7pmos@61_poly-left##0 net@1209 7.75
R1711 B1#17nmos@62_poly-left B1#17nmos@62_poly-left##0 6.2
R1712 B1#17nmos@62_poly-left##0 B1#15pin@333_polysilicon-1 6.2
R1713 net@1314#9nmos@63_poly-left net@1314#9nmos@63_poly-left##0 8.37
R1714 net@1314#9nmos@63_poly-left##0 net@1314#9nmos@63_poly-left##1 8.37
R1715 net@1314#9nmos@63_poly-left##1 net@1314#9nmos@63_poly-left##2 8.37
R1716 net@1314#9nmos@63_poly-left##2 net@1314#9nmos@63_poly-left##3 8.37
R1717 net@1314#9nmos@63_poly-left##3 net@1314#2contact@466_metal-1-metal-2 8.37
R1718 A1#4pin@353_polysilicon-1 A1#4pin@353_polysilicon-1##0 9.881
R1719 A1#4pin@353_polysilicon-1##0 A1#4pin@353_polysilicon-1##1 9.881
R1720 A1#4pin@353_polysilicon-1##1 A1#4pin@353_polysilicon-1##2 9.881
R1721 A1#4pin@353_polysilicon-1##2 A1#4pin@353_polysilicon-1##3 9.881
R1722 A1#4pin@353_polysilicon-1##3 A1#4pin@353_polysilicon-1##4 9.881
R1723 A1#4pin@353_polysilicon-1##4 A1#4pin@353_polysilicon-1##5 9.881
R1724 A1#4pin@353_polysilicon-1##5 A1#4pin@353_polysilicon-1##6 9.881
R1725 A1#4pin@353_polysilicon-1##6 A1#4pin@353_polysilicon-1##7 9.881
R1726 A1#4pin@353_polysilicon-1##7 A1#4pin@353_polysilicon-1##8 9.881
R1727 A1#4pin@353_polysilicon-1##8 A1#4pin@353_polysilicon-1##9 9.881
R1728 A1#4pin@353_polysilicon-1##9 A1#4pin@353_polysilicon-1##10 9.881
R1729 A1#4pin@353_polysilicon-1##10 A1#4pin@353_polysilicon-1##11 9.881
R1730 A1#4pin@353_polysilicon-1##11 A1#4pin@353_polysilicon-1##12 9.881
R1731 A1#4pin@353_polysilicon-1##12 A1#4pin@353_polysilicon-1##13 9.881
R1732 A1#4pin@353_polysilicon-1##13 A1#4pin@353_polysilicon-1##14 9.881
R1733 A1#4pin@353_polysilicon-1##14 A1#4pin@353_polysilicon-1##15 9.881
R1734 A1#4pin@353_polysilicon-1##15 A1#4pin@353_polysilicon-1##16 9.881
R1735 A1#4pin@353_polysilicon-1##16 A1#4pin@353_polysilicon-1##17 9.881
R1736 A1#4pin@353_polysilicon-1##17 A1#4pin@353_polysilicon-1##18 9.881
R1737 A1#4pin@353_polysilicon-1##18 A1#4pin@353_polysilicon-1##19 9.881
R1738 A1#4pin@353_polysilicon-1##19 A1#4pin@353_polysilicon-1##20 9.881
R1739 A1#4pin@353_polysilicon-1##20 A1#4pin@353_polysilicon-1##21 9.881
R1740 A1#4pin@353_polysilicon-1##21 A1#4pin@353_polysilicon-1##22 9.881
R1741 A1#4pin@353_polysilicon-1##22 A1#4pin@353_polysilicon-1##23 9.881
R1742 A1#4pin@353_polysilicon-1##23 A1#4pin@353_polysilicon-1##24 9.881
R1743 A1#4pin@353_polysilicon-1##24 A1#4pin@353_polysilicon-1##25 9.881
R1744 A1#4pin@353_polysilicon-1##25 A1#4pin@353_polysilicon-1##26 9.881
R1745 A1#4pin@353_polysilicon-1##26 A1#4pin@353_polysilicon-1##27 9.881
R1746 A1#4pin@353_polysilicon-1##27 A1#4pin@353_polysilicon-1##28 9.881
R1747 A1#4pin@353_polysilicon-1##28 A1#4pin@353_polysilicon-1##29 9.881
R1748 A1#4pin@353_polysilicon-1##29 A1#4pin@353_polysilicon-1##30 9.881
R1749 A1#4pin@353_polysilicon-1##30 A1#4pin@353_polysilicon-1##31 9.881
R1750 A1#4pin@353_polysilicon-1##31 A1#4pin@353_polysilicon-1##32 9.881
R1751 A1#4pin@353_polysilicon-1##32 A1#4pin@353_polysilicon-1##33 9.881
R1752 A1#4pin@353_polysilicon-1##33 A1#4pin@353_polysilicon-1##34 9.881
R1753 A1#4pin@353_polysilicon-1##34 A1#4pin@353_polysilicon-1##35 9.881
R1754 A1#4pin@353_polysilicon-1##35 A1#4pin@353_polysilicon-1##36 9.881
R1755 A1#4pin@353_polysilicon-1##36 A1#4pin@353_polysilicon-1##37 9.881
R1756 A1#4pin@353_polysilicon-1##37 A1#4pin@353_polysilicon-1##38 9.881
R1757 A1#4pin@353_polysilicon-1##38 A1#4pin@353_polysilicon-1##39 9.881
R1758 A1#4pin@353_polysilicon-1##39 A1#4pin@353_polysilicon-1##40 9.881
R1759 A1#4pin@353_polysilicon-1##40 A1#4pin@353_polysilicon-1##41 9.881
R1760 A1#4pin@353_polysilicon-1##41 A1#4pin@353_polysilicon-1##42 9.881
R1761 A1#4pin@353_polysilicon-1##42 A1#4pin@353_polysilicon-1##43 9.881
R1762 A1#4pin@353_polysilicon-1##43 A1#4pin@353_polysilicon-1##44 9.881
R1763 A1#4pin@353_polysilicon-1##44 A1#4pin@353_polysilicon-1##45 9.881
R1764 A1#4pin@353_polysilicon-1##45 A1#4pin@353_polysilicon-1##46 9.881
R1765 A1#4pin@353_polysilicon-1##46 A1#4pin@353_polysilicon-1##47 9.881
R1766 A1#4pin@353_polysilicon-1##47 A1#4pin@353_polysilicon-1##48 9.881
R1767 A1#4pin@353_polysilicon-1##48 A1#4pin@353_polysilicon-1##49 9.881
R1768 A1#4pin@353_polysilicon-1##49 A1#4pin@353_polysilicon-1##50 9.881
R1769 A1#4pin@353_polysilicon-1##50 A1#4pin@353_polysilicon-1##51 9.881
R1770 A1#4pin@353_polysilicon-1##51 A1#4pin@353_polysilicon-1##52 9.881
R1771 A1#4pin@353_polysilicon-1##52 A1#4pin@353_polysilicon-1##53 9.881
R1772 A1#4pin@353_polysilicon-1##53 A1#4pin@353_polysilicon-1##54 9.881
R1773 A1#4pin@353_polysilicon-1##54 A1#17nmos@65_poly-right 9.881
R1774 net@1209#5pmos@65_diff-top net@1209#2pin@342_metal-1 4.81
R1775 net@1209#1pin@352_polysilicon-1 net@1209#1pin@352_polysilicon-1##0 9.85
R1776 net@1209#1pin@352_polysilicon-1##0 net@1209#1pin@352_polysilicon-1##1 9.85
R1777 net@1209#1pin@352_polysilicon-1##1 net@1209#1pin@352_polysilicon-1##2 9.85
R1778 net@1209#1pin@352_polysilicon-1##2 net@1209#1pin@352_polysilicon-1##3 9.85
R1779 net@1209#1pin@352_polysilicon-1##3 net@1209#1pin@352_polysilicon-1##4 9.85
R1780 net@1209#1pin@352_polysilicon-1##4 net@1209#1pin@352_polysilicon-1##5 9.85
R1781 net@1209#1pin@352_polysilicon-1##5 net@1209#1pin@352_polysilicon-1##6 9.85
R1782 net@1209#1pin@352_polysilicon-1##6 net@1209#1pin@352_polysilicon-1##7 9.85
R1783 net@1209#1pin@352_polysilicon-1##7 net@1209#1pin@352_polysilicon-1##8 9.85
R1784 net@1209#1pin@352_polysilicon-1##8 net@1209#1pin@352_polysilicon-1##9 9.85
R1785 net@1209#1pin@352_polysilicon-1##9 net@1209#1pin@352_polysilicon-1##10 9.85
R1786 net@1209#1pin@352_polysilicon-1##10 net@1209#1pin@352_polysilicon-1##11 9.85
R1787 net@1209#1pin@352_polysilicon-1##11 net@1209#1pin@352_polysilicon-1##12 9.85
R1788 net@1209#1pin@352_polysilicon-1##12 net@1209#1pin@352_polysilicon-1##13 9.85
R1789 net@1209#1pin@352_polysilicon-1##13 net@1209#1pin@352_polysilicon-1##14 9.85
R1790 net@1209#1pin@352_polysilicon-1##14 net@1209#1pin@352_polysilicon-1##15 9.85
R1791 net@1209#1pin@352_polysilicon-1##15 net@1209#1pin@352_polysilicon-1##16 9.85
R1792 net@1209#1pin@352_polysilicon-1##16 net@1209#1pin@352_polysilicon-1##17 9.85
R1793 net@1209#1pin@352_polysilicon-1##17 net@1209#1pin@352_polysilicon-1##18 9.85
R1794 net@1209#1pin@352_polysilicon-1##18 net@1209#1pin@352_polysilicon-1##19 9.85
R1795 net@1209#1pin@352_polysilicon-1##19 net@1209#1pin@352_polysilicon-1##20 9.85
R1796 net@1209#1pin@352_polysilicon-1##20 net@1209#1pin@352_polysilicon-1##21 9.85
R1797 net@1209#1pin@352_polysilicon-1##21 net@1209#1pin@352_polysilicon-1##22 9.85
R1798 net@1209#1pin@352_polysilicon-1##22 net@1209#1pin@352_polysilicon-1##23 9.85
R1799 net@1209#1pin@352_polysilicon-1##23 net@1209#1pin@352_polysilicon-1##24 9.85
R1800 net@1209#1pin@352_polysilicon-1##24 net@1209#1pin@352_polysilicon-1##25 9.85
R1801 net@1209#1pin@352_polysilicon-1##25 net@1209#1pin@352_polysilicon-1##26 9.85
R1802 net@1209#1pin@352_polysilicon-1##26 net@1209#1pin@352_polysilicon-1##27 9.85
R1803 net@1209#1pin@352_polysilicon-1##27 net@1209#1pin@352_polysilicon-1##28 9.85
R1804 net@1209#1pin@352_polysilicon-1##28 net@1209#1pin@352_polysilicon-1##29 9.85
R1805 net@1209#1pin@352_polysilicon-1##29 net@1209#1pin@352_polysilicon-1##30 9.85
R1806 net@1209#1pin@352_polysilicon-1##30 net@1209#1pin@352_polysilicon-1##31 9.85
R1807 net@1209#1pin@352_polysilicon-1##31 net@1209#1pin@352_polysilicon-1##32 9.85
R1808 net@1209#1pin@352_polysilicon-1##32 net@1209#1pin@352_polysilicon-1##33 9.85
R1809 net@1209#1pin@352_polysilicon-1##33 net@1209#1pin@352_polysilicon-1##34 9.85
R1810 net@1209#1pin@352_polysilicon-1##34 net@1209#1pin@352_polysilicon-1##35 9.85
R1811 net@1209#1pin@352_polysilicon-1##35 net@1209#1pin@352_polysilicon-1##36 9.85
R1812 net@1209#1pin@352_polysilicon-1##36 net@1209#1pin@352_polysilicon-1##37 9.85
R1813 net@1209#1pin@352_polysilicon-1##37 net@1209#1pin@352_polysilicon-1##38 9.85
R1814 net@1209#1pin@352_polysilicon-1##38 net@1209#1pin@352_polysilicon-1##39 9.85
R1815 net@1209#1pin@352_polysilicon-1##39 net@1209#1pin@352_polysilicon-1##40 9.85
R1816 net@1209#1pin@352_polysilicon-1##40 net@1209#1pin@352_polysilicon-1##41 9.85
R1817 net@1209#1pin@352_polysilicon-1##41 net@1209#1pin@352_polysilicon-1##42 9.85
R1818 net@1209#1pin@352_polysilicon-1##42 net@1209#1pin@352_polysilicon-1##43 9.85
R1819 net@1209#1pin@352_polysilicon-1##43 net@1209#1pin@352_polysilicon-1##44 9.85
R1820 net@1209#1pin@352_polysilicon-1##44 net@1209#1pin@352_polysilicon-1##45 9.85
R1821 net@1209#1pin@352_polysilicon-1##45 net@1209#1pin@352_polysilicon-1##46 9.85
R1822 net@1209#1pin@352_polysilicon-1##46 net@1209#1pin@352_polysilicon-1##47 9.85
R1823 net@1209#1pin@352_polysilicon-1##47 net@1209#1pin@352_polysilicon-1##48 9.85
R1824 net@1209#1pin@352_polysilicon-1##48 net@1209#1pin@352_polysilicon-1##49 9.85
R1825 net@1209#1pin@352_polysilicon-1##49 net@1209#1pin@352_polysilicon-1##50 9.85
R1826 net@1209#1pin@352_polysilicon-1##50 net@1209#1pin@352_polysilicon-1##51 9.85
R1827 net@1209#1pin@352_polysilicon-1##51 net@1209#1pin@352_polysilicon-1##52 9.85
R1828 net@1209#1pin@352_polysilicon-1##52 net@1209#1pin@352_polysilicon-1##53 9.85
R1829 net@1209#1pin@352_polysilicon-1##53 net@1209#1pin@352_polysilicon-1##54 9.85
R1830 net@1209#1pin@352_polysilicon-1##54 net@1209#1pin@352_polysilicon-1##55 9.85
R1831 net@1209#1pin@352_polysilicon-1##55 net@1209#1pin@352_polysilicon-1##56 9.85
R1832 net@1209#1pin@352_polysilicon-1##56 net@1209#1pin@352_polysilicon-1##57 9.85
R1833 net@1209#1pin@352_polysilicon-1##57 net@1209#1pin@352_polysilicon-1##58 9.85
R1834 net@1209#1pin@352_polysilicon-1##58 net@1209#1pin@352_polysilicon-1##59 9.85
R1835 net@1209#1pin@352_polysilicon-1##59 net@1209#1pin@352_polysilicon-1##60 9.85
R1836 net@1209#1pin@352_polysilicon-1##60 net@1209#2pin@342_metal-1 9.85
R1837 B1#18pmos@64_poly-right B1#18pmos@64_poly-right##0 9.854
R1838 B1#18pmos@64_poly-right##0 B1#18pmos@64_poly-right##1 9.854
R1839 B1#18pmos@64_poly-right##1 B1#18pmos@64_poly-right##2 9.854
R1840 B1#18pmos@64_poly-right##2 B1#18pmos@64_poly-right##3 9.854
R1841 B1#18pmos@64_poly-right##3 B1#18pmos@64_poly-right##4 9.854
R1842 B1#18pmos@64_poly-right##4 B1#18pmos@64_poly-right##5 9.854
R1843 B1#18pmos@64_poly-right##5 B1#18pmos@64_poly-right##6 9.854
R1844 B1#18pmos@64_poly-right##6 B1#18pmos@64_poly-right##7 9.854
R1845 B1#18pmos@64_poly-right##7 B1#18pmos@64_poly-right##8 9.854
R1846 B1#18pmos@64_poly-right##8 B1#18pmos@64_poly-right##9 9.854
R1847 B1#18pmos@64_poly-right##9 B1#18pmos@64_poly-right##10 9.854
R1848 B1#18pmos@64_poly-right##10 B1#18pmos@64_poly-right##11 9.854
R1849 B1#18pmos@64_poly-right##11 B1#18pmos@64_poly-right##12 9.854
R1850 B1#18pmos@64_poly-right##12 B1#18pmos@64_poly-right##13 9.854
R1851 B1#18pmos@64_poly-right##13 B1#18pmos@64_poly-right##14 9.854
R1852 B1#18pmos@64_poly-right##14 B1#18pmos@64_poly-right##15 9.854
R1853 B1#18pmos@64_poly-right##15 B1#18pmos@64_poly-right##16 9.854
R1854 B1#18pmos@64_poly-right##16 B1#18pmos@64_poly-right##17 9.854
R1855 B1#18pmos@64_poly-right##17 B1#18pmos@64_poly-right##18 9.854
R1856 B1#18pmos@64_poly-right##18 B1#18pmos@64_poly-right##19 9.854
R1857 B1#18pmos@64_poly-right##19 B1#18pmos@64_poly-right##20 9.854
R1858 B1#18pmos@64_poly-right##20 B1#18pmos@64_poly-right##21 9.854
R1859 B1#18pmos@64_poly-right##21 B1#18pmos@64_poly-right##22 9.854
R1860 B1#18pmos@64_poly-right##22 B1#18pmos@64_poly-right##23 9.854
R1861 B1#18pmos@64_poly-right##23 B1#18pmos@64_poly-right##24 9.854
R1862 B1#18pmos@64_poly-right##24 B1#18pmos@64_poly-right##25 9.854
R1863 B1#18pmos@64_poly-right##25 B1#18pmos@64_poly-right##26 9.854
R1864 B1#18pmos@64_poly-right##26 B1#18pmos@64_poly-right##27 9.854
R1865 B1#18pmos@64_poly-right##27 B1#18pmos@64_poly-right##28 9.854
R1866 B1#18pmos@64_poly-right##28 B1#18pmos@64_poly-right##29 9.854
R1867 B1#18pmos@64_poly-right##29 B1#18pmos@64_poly-right##30 9.854
R1868 B1#18pmos@64_poly-right##30 B1#18pmos@64_poly-right##31 9.854
R1869 B1#18pmos@64_poly-right##31 B1#18pmos@64_poly-right##32 9.854
R1870 B1#18pmos@64_poly-right##32 B1#18pmos@64_poly-right##33 9.854
R1871 B1#18pmos@64_poly-right##33 B1#18pmos@64_poly-right##34 9.854
R1872 B1#18pmos@64_poly-right##34 B1#18pmos@64_poly-right##35 9.854
R1873 B1#18pmos@64_poly-right##35 B1#18pmos@64_poly-right##36 9.854
R1874 B1#18pmos@64_poly-right##36 B1#18pmos@64_poly-right##37 9.854
R1875 B1#18pmos@64_poly-right##37 B1#18pmos@64_poly-right##38 9.854
R1876 B1#18pmos@64_poly-right##38 B1#18pmos@64_poly-right##39 9.854
R1877 B1#18pmos@64_poly-right##39 B1#18pmos@64_poly-right##40 9.854
R1878 B1#18pmos@64_poly-right##40 B1#18pmos@64_poly-right##41 9.854
R1879 B1#18pmos@64_poly-right##41 B1#18pmos@64_poly-right##42 9.854
R1880 B1#18pmos@64_poly-right##42 B1#18pmos@64_poly-right##43 9.854
R1881 B1#18pmos@64_poly-right##43 B1#18pmos@64_poly-right##44 9.854
R1882 B1#18pmos@64_poly-right##44 B1#18pmos@64_poly-right##45 9.854
R1883 B1#18pmos@64_poly-right##45 B1#18pmos@64_poly-right##46 9.854
R1884 B1#18pmos@64_poly-right##46 B1#18pmos@64_poly-right##47 9.854
R1885 B1#18pmos@64_poly-right##47 B1#18pmos@64_poly-right##48 9.854
R1886 B1#18pmos@64_poly-right##48 B1#18pmos@64_poly-right##49 9.854
R1887 B1#18pmos@64_poly-right##49 B1#18pmos@64_poly-right##50 9.854
R1888 B1#18pmos@64_poly-right##50 B1#18pmos@64_poly-right##51 9.854
R1889 B1#18pmos@64_poly-right##51 B1#18pmos@64_poly-right##52 9.854
R1890 B1#18pmos@64_poly-right##52 B1#18pmos@64_poly-right##53 9.854
R1891 B1#18pmos@64_poly-right##53 B1#18pmos@64_poly-right##54 9.854
R1892 B1#18pmos@64_poly-right##54 B1#13pin@343_polysilicon-1 9.854
R1893 net@1314 net@1314#2contact@466_metal-1-metal-2 4.797
R1894 A1#18nmos@60_poly-right A1#18nmos@60_poly-right##0 9.871
R1895 A1#18nmos@60_poly-right##0 A1#18nmos@60_poly-right##1 9.871
R1896 A1#18nmos@60_poly-right##1 A1#18nmos@60_poly-right##2 9.871
R1897 A1#18nmos@60_poly-right##2 A1#18nmos@60_poly-right##3 9.871
R1898 A1#18nmos@60_poly-right##3 A1#18nmos@60_poly-right##4 9.871
R1899 A1#18nmos@60_poly-right##4 A1#18nmos@60_poly-right##5 9.871
R1900 A1#18nmos@60_poly-right##5 A1#18nmos@60_poly-right##6 9.871
R1901 A1#18nmos@60_poly-right##6 A1#18nmos@60_poly-right##7 9.871
R1902 A1#18nmos@60_poly-right##7 A1#18nmos@60_poly-right##8 9.871
R1903 A1#18nmos@60_poly-right##8 A1#18nmos@60_poly-right##9 9.871
R1904 A1#18nmos@60_poly-right##9 A1#18nmos@60_poly-right##10 9.871
R1905 A1#18nmos@60_poly-right##10 A1#18nmos@60_poly-right##11 9.871
R1906 A1#18nmos@60_poly-right##11 A1#18nmos@60_poly-right##12 9.871
R1907 A1#18nmos@60_poly-right##12 A1#18nmos@60_poly-right##13 9.871
R1908 A1#18nmos@60_poly-right##13 A1#18nmos@60_poly-right##14 9.871
R1909 A1#18nmos@60_poly-right##14 A1#18nmos@60_poly-right##15 9.871
R1910 A1#18nmos@60_poly-right##15 A1#18nmos@60_poly-right##16 9.871
R1911 A1#18nmos@60_poly-right##16 A1#18nmos@60_poly-right##17 9.871
R1912 A1#18nmos@60_poly-right##17 A1#18nmos@60_poly-right##18 9.871
R1913 A1#18nmos@60_poly-right##18 A1#18nmos@60_poly-right##19 9.871
R1914 A1#18nmos@60_poly-right##19 A1#18nmos@60_poly-right##20 9.871
R1915 A1#18nmos@60_poly-right##20 A1#18nmos@60_poly-right##21 9.871
R1916 A1#18nmos@60_poly-right##21 A1#18nmos@60_poly-right##22 9.871
R1917 A1#18nmos@60_poly-right##22 A1#18nmos@60_poly-right##23 9.871
R1918 A1#18nmos@60_poly-right##23 A1#18nmos@60_poly-right##24 9.871
R1919 A1#18nmos@60_poly-right##24 A1#18nmos@60_poly-right##25 9.871
R1920 A1#18nmos@60_poly-right##25 A1#18nmos@60_poly-right##26 9.871
R1921 A1#18nmos@60_poly-right##26 A1#18nmos@60_poly-right##27 9.871
R1922 A1#18nmos@60_poly-right##27 A1#18nmos@60_poly-right##28 9.871
R1923 A1#18nmos@60_poly-right##28 A1#18nmos@60_poly-right##29 9.871
R1924 A1#18nmos@60_poly-right##29 A1#18nmos@60_poly-right##30 9.871
R1925 A1#18nmos@60_poly-right##30 A1#18nmos@60_poly-right##31 9.871
R1926 A1#18nmos@60_poly-right##31 A1#18nmos@60_poly-right##32 9.871
R1927 A1#18nmos@60_poly-right##32 A1#18nmos@60_poly-right##33 9.871
R1928 A1#18nmos@60_poly-right##33 A1#18nmos@60_poly-right##34 9.871
R1929 A1#18nmos@60_poly-right##34 A1#18nmos@60_poly-right##35 9.871
R1930 A1#18nmos@60_poly-right##35 A1#18nmos@60_poly-right##36 9.871
R1931 A1#18nmos@60_poly-right##36 A1#18nmos@60_poly-right##37 9.871
R1932 A1#18nmos@60_poly-right##37 A1#18nmos@60_poly-right##38 9.871
R1933 A1#18nmos@60_poly-right##38 A1#18nmos@60_poly-right##39 9.871
R1934 A1#18nmos@60_poly-right##39 A1#18nmos@60_poly-right##40 9.871
R1935 A1#18nmos@60_poly-right##40 A1#18nmos@60_poly-right##41 9.871
R1936 A1#18nmos@60_poly-right##41 A1#18nmos@60_poly-right##42 9.871
R1937 A1#18nmos@60_poly-right##42 A1#18nmos@60_poly-right##43 9.871
R1938 A1#18nmos@60_poly-right##43 A1#18nmos@60_poly-right##44 9.871
R1939 A1#18nmos@60_poly-right##44 A1#18nmos@60_poly-right##45 9.871
R1940 A1#18nmos@60_poly-right##45 A1#18nmos@60_poly-right##46 9.871
R1941 A1#18nmos@60_poly-right##46 A1#18nmos@60_poly-right##47 9.871
R1942 A1#18nmos@60_poly-right##47 A1#18nmos@60_poly-right##48 9.871
R1943 A1#18nmos@60_poly-right##48 A1#18nmos@60_poly-right##49 9.871
R1944 A1#18nmos@60_poly-right##49 A1#18nmos@60_poly-right##50 9.871
R1945 A1#18nmos@60_poly-right##50 A1#18nmos@60_poly-right##51 9.871
R1946 A1#18nmos@60_poly-right##51 A1#18nmos@60_poly-right##52 9.871
R1947 A1#18nmos@60_poly-right##52 A1#18nmos@60_poly-right##53 9.871
R1948 A1#18nmos@60_poly-right##53 A1#18nmos@60_poly-right##54 9.871
R1949 A1#18nmos@60_poly-right##54 A1#18nmos@60_poly-right##55 9.871
R1950 A1#18nmos@60_poly-right##55 A1#13pmos@60_poly-left 9.871
R1951 net@1209#7pmos@61_poly-left net@1209#7pmos@61_poly-left##0 9.871
R1952 net@1209#7pmos@61_poly-left##0 net@1209#7pmos@61_poly-left##1 9.871
R1953 net@1209#7pmos@61_poly-left##1 net@1209#7pmos@61_poly-left##2 9.871
R1954 net@1209#7pmos@61_poly-left##2 net@1209#7pmos@61_poly-left##3 9.871
R1955 net@1209#7pmos@61_poly-left##3 net@1209#7pmos@61_poly-left##4 9.871
R1956 net@1209#7pmos@61_poly-left##4 net@1209#7pmos@61_poly-left##5 9.871
R1957 net@1209#7pmos@61_poly-left##5 net@1209#7pmos@61_poly-left##6 9.871
R1958 net@1209#7pmos@61_poly-left##6 net@1209#7pmos@61_poly-left##7 9.871
R1959 net@1209#7pmos@61_poly-left##7 net@1209#7pmos@61_poly-left##8 9.871
R1960 net@1209#7pmos@61_poly-left##8 net@1209#7pmos@61_poly-left##9 9.871
R1961 net@1209#7pmos@61_poly-left##9 net@1209#7pmos@61_poly-left##10 9.871
R1962 net@1209#7pmos@61_poly-left##10 net@1209#7pmos@61_poly-left##11 9.871
R1963 net@1209#7pmos@61_poly-left##11 net@1209#7pmos@61_poly-left##12 9.871
R1964 net@1209#7pmos@61_poly-left##12 net@1209#7pmos@61_poly-left##13 9.871
R1965 net@1209#7pmos@61_poly-left##13 net@1209#7pmos@61_poly-left##14 9.871
R1966 net@1209#7pmos@61_poly-left##14 net@1209#7pmos@61_poly-left##15 9.871
R1967 net@1209#7pmos@61_poly-left##15 net@1209#7pmos@61_poly-left##16 9.871
R1968 net@1209#7pmos@61_poly-left##16 net@1209#7pmos@61_poly-left##17 9.871
R1969 net@1209#7pmos@61_poly-left##17 net@1209#7pmos@61_poly-left##18 9.871
R1970 net@1209#7pmos@61_poly-left##18 net@1209#7pmos@61_poly-left##19 9.871
R1971 net@1209#7pmos@61_poly-left##19 net@1209#7pmos@61_poly-left##20 9.871
R1972 net@1209#7pmos@61_poly-left##20 net@1209#7pmos@61_poly-left##21 9.871
R1973 net@1209#7pmos@61_poly-left##21 net@1209#7pmos@61_poly-left##22 9.871
R1974 net@1209#7pmos@61_poly-left##22 net@1209#7pmos@61_poly-left##23 9.871
R1975 net@1209#7pmos@61_poly-left##23 net@1209#7pmos@61_poly-left##24 9.871
R1976 net@1209#7pmos@61_poly-left##24 net@1209#7pmos@61_poly-left##25 9.871
R1977 net@1209#7pmos@61_poly-left##25 net@1209#7pmos@61_poly-left##26 9.871
R1978 net@1209#7pmos@61_poly-left##26 net@1209#7pmos@61_poly-left##27 9.871
R1979 net@1209#7pmos@61_poly-left##27 net@1209#7pmos@61_poly-left##28 9.871
R1980 net@1209#7pmos@61_poly-left##28 net@1209#7pmos@61_poly-left##29 9.871
R1981 net@1209#7pmos@61_poly-left##29 net@1209#7pmos@61_poly-left##30 9.871
R1982 net@1209#7pmos@61_poly-left##30 net@1209#7pmos@61_poly-left##31 9.871
R1983 net@1209#7pmos@61_poly-left##31 net@1209#7pmos@61_poly-left##32 9.871
R1984 net@1209#7pmos@61_poly-left##32 net@1209#7pmos@61_poly-left##33 9.871
R1985 net@1209#7pmos@61_poly-left##33 net@1209#7pmos@61_poly-left##34 9.871
R1986 net@1209#7pmos@61_poly-left##34 net@1209#7pmos@61_poly-left##35 9.871
R1987 net@1209#7pmos@61_poly-left##35 net@1209#7pmos@61_poly-left##36 9.871
R1988 net@1209#7pmos@61_poly-left##36 net@1209#7pmos@61_poly-left##37 9.871
R1989 net@1209#7pmos@61_poly-left##37 net@1209#7pmos@61_poly-left##38 9.871
R1990 net@1209#7pmos@61_poly-left##38 net@1209#7pmos@61_poly-left##39 9.871
R1991 net@1209#7pmos@61_poly-left##39 net@1209#7pmos@61_poly-left##40 9.871
R1992 net@1209#7pmos@61_poly-left##40 net@1209#7pmos@61_poly-left##41 9.871
R1993 net@1209#7pmos@61_poly-left##41 net@1209#7pmos@61_poly-left##42 9.871
R1994 net@1209#7pmos@61_poly-left##42 net@1209#7pmos@61_poly-left##43 9.871
R1995 net@1209#7pmos@61_poly-left##43 net@1209#7pmos@61_poly-left##44 9.871
R1996 net@1209#7pmos@61_poly-left##44 net@1209#7pmos@61_poly-left##45 9.871
R1997 net@1209#7pmos@61_poly-left##45 net@1209#7pmos@61_poly-left##46 9.871
R1998 net@1209#7pmos@61_poly-left##46 net@1209#7pmos@61_poly-left##47 9.871
R1999 net@1209#7pmos@61_poly-left##47 net@1209#7pmos@61_poly-left##48 9.871
R2000 net@1209#7pmos@61_poly-left##48 net@1209#7pmos@61_poly-left##49 9.871
R2001 net@1209#7pmos@61_poly-left##49 net@1209#7pmos@61_poly-left##50 9.871
R2002 net@1209#7pmos@61_poly-left##50 net@1209#7pmos@61_poly-left##51 9.871
R2003 net@1209#7pmos@61_poly-left##51 net@1209#7pmos@61_poly-left##52 9.871
R2004 net@1209#7pmos@61_poly-left##52 net@1209#7pmos@61_poly-left##53 9.871
R2005 net@1209#7pmos@61_poly-left##53 net@1209#7pmos@61_poly-left##54 9.871
R2006 net@1209#7pmos@61_poly-left##54 net@1209#7pmos@61_poly-left##55 9.871
R2007 net@1209#7pmos@61_poly-left##55 net@1209#11nmos@61_poly-right 9.871
R2008 B1#19pmos@62_poly-right B1#19pmos@62_poly-right##0 9.871
R2009 B1#19pmos@62_poly-right##0 B1#19pmos@62_poly-right##1 9.871
R2010 B1#19pmos@62_poly-right##1 B1#19pmos@62_poly-right##2 9.871
R2011 B1#19pmos@62_poly-right##2 B1#19pmos@62_poly-right##3 9.871
R2012 B1#19pmos@62_poly-right##3 B1#19pmos@62_poly-right##4 9.871
R2013 B1#19pmos@62_poly-right##4 B1#19pmos@62_poly-right##5 9.871
R2014 B1#19pmos@62_poly-right##5 B1#19pmos@62_poly-right##6 9.871
R2015 B1#19pmos@62_poly-right##6 B1#19pmos@62_poly-right##7 9.871
R2016 B1#19pmos@62_poly-right##7 B1#19pmos@62_poly-right##8 9.871
R2017 B1#19pmos@62_poly-right##8 B1#19pmos@62_poly-right##9 9.871
R2018 B1#19pmos@62_poly-right##9 B1#19pmos@62_poly-right##10 9.871
R2019 B1#19pmos@62_poly-right##10 B1#19pmos@62_poly-right##11 9.871
R2020 B1#19pmos@62_poly-right##11 B1#19pmos@62_poly-right##12 9.871
R2021 B1#19pmos@62_poly-right##12 B1#19pmos@62_poly-right##13 9.871
R2022 B1#19pmos@62_poly-right##13 B1#19pmos@62_poly-right##14 9.871
R2023 B1#19pmos@62_poly-right##14 B1#19pmos@62_poly-right##15 9.871
R2024 B1#19pmos@62_poly-right##15 B1#19pmos@62_poly-right##16 9.871
R2025 B1#19pmos@62_poly-right##16 B1#19pmos@62_poly-right##17 9.871
R2026 B1#19pmos@62_poly-right##17 B1#19pmos@62_poly-right##18 9.871
R2027 B1#19pmos@62_poly-right##18 B1#19pmos@62_poly-right##19 9.871
R2028 B1#19pmos@62_poly-right##19 B1#19pmos@62_poly-right##20 9.871
R2029 B1#19pmos@62_poly-right##20 B1#19pmos@62_poly-right##21 9.871
R2030 B1#19pmos@62_poly-right##21 B1#19pmos@62_poly-right##22 9.871
R2031 B1#19pmos@62_poly-right##22 B1#19pmos@62_poly-right##23 9.871
R2032 B1#19pmos@62_poly-right##23 B1#19pmos@62_poly-right##24 9.871
R2033 B1#19pmos@62_poly-right##24 B1#19pmos@62_poly-right##25 9.871
R2034 B1#19pmos@62_poly-right##25 B1#19pmos@62_poly-right##26 9.871
R2035 B1#19pmos@62_poly-right##26 B1#19pmos@62_poly-right##27 9.871
R2036 B1#19pmos@62_poly-right##27 B1#19pmos@62_poly-right##28 9.871
R2037 B1#19pmos@62_poly-right##28 B1#19pmos@62_poly-right##29 9.871
R2038 B1#19pmos@62_poly-right##29 B1#19pmos@62_poly-right##30 9.871
R2039 B1#19pmos@62_poly-right##30 B1#19pmos@62_poly-right##31 9.871
R2040 B1#19pmos@62_poly-right##31 B1#19pmos@62_poly-right##32 9.871
R2041 B1#19pmos@62_poly-right##32 B1#19pmos@62_poly-right##33 9.871
R2042 B1#19pmos@62_poly-right##33 B1#19pmos@62_poly-right##34 9.871
R2043 B1#19pmos@62_poly-right##34 B1#19pmos@62_poly-right##35 9.871
R2044 B1#19pmos@62_poly-right##35 B1#19pmos@62_poly-right##36 9.871
R2045 B1#19pmos@62_poly-right##36 B1#19pmos@62_poly-right##37 9.871
R2046 B1#19pmos@62_poly-right##37 B1#19pmos@62_poly-right##38 9.871
R2047 B1#19pmos@62_poly-right##38 B1#19pmos@62_poly-right##39 9.871
R2048 B1#19pmos@62_poly-right##39 B1#19pmos@62_poly-right##40 9.871
R2049 B1#19pmos@62_poly-right##40 B1#19pmos@62_poly-right##41 9.871
R2050 B1#19pmos@62_poly-right##41 B1#19pmos@62_poly-right##42 9.871
R2051 B1#19pmos@62_poly-right##42 B1#19pmos@62_poly-right##43 9.871
R2052 B1#19pmos@62_poly-right##43 B1#19pmos@62_poly-right##44 9.871
R2053 B1#19pmos@62_poly-right##44 B1#19pmos@62_poly-right##45 9.871
R2054 B1#19pmos@62_poly-right##45 B1#19pmos@62_poly-right##46 9.871
R2055 B1#19pmos@62_poly-right##46 B1#19pmos@62_poly-right##47 9.871
R2056 B1#19pmos@62_poly-right##47 B1#19pmos@62_poly-right##48 9.871
R2057 B1#19pmos@62_poly-right##48 B1#19pmos@62_poly-right##49 9.871
R2058 B1#19pmos@62_poly-right##49 B1#19pmos@62_poly-right##50 9.871
R2059 B1#19pmos@62_poly-right##50 B1#19pmos@62_poly-right##51 9.871
R2060 B1#19pmos@62_poly-right##51 B1#19pmos@62_poly-right##52 9.871
R2061 B1#19pmos@62_poly-right##52 B1#19pmos@62_poly-right##53 9.871
R2062 B1#19pmos@62_poly-right##53 B1#19pmos@62_poly-right##54 9.871
R2063 B1#19pmos@62_poly-right##54 B1#19pmos@62_poly-right##55 9.871
R2064 B1#19pmos@62_poly-right##55 B1#17nmos@62_poly-left 9.871
R2065 net@1314#14pmos@63_poly-right net@1314#14pmos@63_poly-right##0 9.871
R2066 net@1314#14pmos@63_poly-right##0 net@1314#14pmos@63_poly-right##1 9.871
R2067 net@1314#14pmos@63_poly-right##1 net@1314#14pmos@63_poly-right##2 9.871
R2068 net@1314#14pmos@63_poly-right##2 net@1314#14pmos@63_poly-right##3 9.871
R2069 net@1314#14pmos@63_poly-right##3 net@1314#14pmos@63_poly-right##4 9.871
R2070 net@1314#14pmos@63_poly-right##4 net@1314#14pmos@63_poly-right##5 9.871
R2071 net@1314#14pmos@63_poly-right##5 net@1314#14pmos@63_poly-right##6 9.871
R2072 net@1314#14pmos@63_poly-right##6 net@1314#14pmos@63_poly-right##7 9.871
R2073 net@1314#14pmos@63_poly-right##7 net@1314#14pmos@63_poly-right##8 9.871
R2074 net@1314#14pmos@63_poly-right##8 net@1314#14pmos@63_poly-right##9 9.871
R2075 net@1314#14pmos@63_poly-right##9 net@1314#14pmos@63_poly-right##10 9.871
R2076 net@1314#14pmos@63_poly-right##10 net@1314#14pmos@63_poly-right##11 9.871
R2077 net@1314#14pmos@63_poly-right##11 net@1314#14pmos@63_poly-right##12 9.871
R2078 net@1314#14pmos@63_poly-right##12 net@1314#14pmos@63_poly-right##13 9.871
R2079 net@1314#14pmos@63_poly-right##13 net@1314#14pmos@63_poly-right##14 9.871
R2080 net@1314#14pmos@63_poly-right##14 net@1314#14pmos@63_poly-right##15 9.871
R2081 net@1314#14pmos@63_poly-right##15 net@1314#14pmos@63_poly-right##16 9.871
R2082 net@1314#14pmos@63_poly-right##16 net@1314#14pmos@63_poly-right##17 9.871
R2083 net@1314#14pmos@63_poly-right##17 net@1314#14pmos@63_poly-right##18 9.871
R2084 net@1314#14pmos@63_poly-right##18 net@1314#14pmos@63_poly-right##19 9.871
R2085 net@1314#14pmos@63_poly-right##19 net@1314#14pmos@63_poly-right##20 9.871
R2086 net@1314#14pmos@63_poly-right##20 net@1314#14pmos@63_poly-right##21 9.871
R2087 net@1314#14pmos@63_poly-right##21 net@1314#14pmos@63_poly-right##22 9.871
R2088 net@1314#14pmos@63_poly-right##22 net@1314#14pmos@63_poly-right##23 9.871
R2089 net@1314#14pmos@63_poly-right##23 net@1314#14pmos@63_poly-right##24 9.871
R2090 net@1314#14pmos@63_poly-right##24 net@1314#14pmos@63_poly-right##25 9.871
R2091 net@1314#14pmos@63_poly-right##25 net@1314#14pmos@63_poly-right##26 9.871
R2092 net@1314#14pmos@63_poly-right##26 net@1314#14pmos@63_poly-right##27 9.871
R2093 net@1314#14pmos@63_poly-right##27 net@1314#14pmos@63_poly-right##28 9.871
R2094 net@1314#14pmos@63_poly-right##28 net@1314#14pmos@63_poly-right##29 9.871
R2095 net@1314#14pmos@63_poly-right##29 net@1314#14pmos@63_poly-right##30 9.871
R2096 net@1314#14pmos@63_poly-right##30 net@1314#14pmos@63_poly-right##31 9.871
R2097 net@1314#14pmos@63_poly-right##31 net@1314#14pmos@63_poly-right##32 9.871
R2098 net@1314#14pmos@63_poly-right##32 net@1314#14pmos@63_poly-right##33 9.871
R2099 net@1314#14pmos@63_poly-right##33 net@1314#14pmos@63_poly-right##34 9.871
R2100 net@1314#14pmos@63_poly-right##34 net@1314#14pmos@63_poly-right##35 9.871
R2101 net@1314#14pmos@63_poly-right##35 net@1314#14pmos@63_poly-right##36 9.871
R2102 net@1314#14pmos@63_poly-right##36 net@1314#14pmos@63_poly-right##37 9.871
R2103 net@1314#14pmos@63_poly-right##37 net@1314#14pmos@63_poly-right##38 9.871
R2104 net@1314#14pmos@63_poly-right##38 net@1314#14pmos@63_poly-right##39 9.871
R2105 net@1314#14pmos@63_poly-right##39 net@1314#14pmos@63_poly-right##40 9.871
R2106 net@1314#14pmos@63_poly-right##40 net@1314#14pmos@63_poly-right##41 9.871
R2107 net@1314#14pmos@63_poly-right##41 net@1314#14pmos@63_poly-right##42 9.871
R2108 net@1314#14pmos@63_poly-right##42 net@1314#14pmos@63_poly-right##43 9.871
R2109 net@1314#14pmos@63_poly-right##43 net@1314#14pmos@63_poly-right##44 9.871
R2110 net@1314#14pmos@63_poly-right##44 net@1314#14pmos@63_poly-right##45 9.871
R2111 net@1314#14pmos@63_poly-right##45 net@1314#14pmos@63_poly-right##46 9.871
R2112 net@1314#14pmos@63_poly-right##46 net@1314#14pmos@63_poly-right##47 9.871
R2113 net@1314#14pmos@63_poly-right##47 net@1314#14pmos@63_poly-right##48 9.871
R2114 net@1314#14pmos@63_poly-right##48 net@1314#14pmos@63_poly-right##49 9.871
R2115 net@1314#14pmos@63_poly-right##49 net@1314#14pmos@63_poly-right##50 9.871
R2116 net@1314#14pmos@63_poly-right##50 net@1314#14pmos@63_poly-right##51 9.871
R2117 net@1314#14pmos@63_poly-right##51 net@1314#14pmos@63_poly-right##52 9.871
R2118 net@1314#14pmos@63_poly-right##52 net@1314#14pmos@63_poly-right##53 9.871
R2119 net@1314#14pmos@63_poly-right##53 net@1314#14pmos@63_poly-right##54 9.871
R2120 net@1314#14pmos@63_poly-right##54 net@1314#14pmos@63_poly-right##55 9.871
R2121 net@1314#14pmos@63_poly-right##55 net@1314#9nmos@63_poly-left 9.871
R2122 net@1307#2contact@491_metal-1-polysilicon-1 net@1307 4.706
R2123 net@1307#12pmos@66_poly-right net@1307#12pmos@66_poly-right##0 9.864
R2124 net@1307#12pmos@66_poly-right##0 net@1307#12pmos@66_poly-right##1 9.864
R2125 net@1307#12pmos@66_poly-right##1 net@1307#12pmos@66_poly-right##2 9.864
R2126 net@1307#12pmos@66_poly-right##2 net@1307#12pmos@66_poly-right##3 9.864
R2127 net@1307#12pmos@66_poly-right##3 net@1307#12pmos@66_poly-right##4 9.864
R2128 net@1307#12pmos@66_poly-right##4 net@1307#12pmos@66_poly-right##5 9.864
R2129 net@1307#12pmos@66_poly-right##5 net@1307#12pmos@66_poly-right##6 9.864
R2130 net@1307#12pmos@66_poly-right##6 net@1307#12pmos@66_poly-right##7 9.864
R2131 net@1307#12pmos@66_poly-right##7 net@1307#12pmos@66_poly-right##8 9.864
R2132 net@1307#12pmos@66_poly-right##8 net@1307#12pmos@66_poly-right##9 9.864
R2133 net@1307#12pmos@66_poly-right##9 net@1307#12pmos@66_poly-right##10 9.864
R2134 net@1307#12pmos@66_poly-right##10 net@1307#12pmos@66_poly-right##11 9.864
R2135 net@1307#12pmos@66_poly-right##11 net@1307#12pmos@66_poly-right##12 9.864
R2136 net@1307#12pmos@66_poly-right##12 net@1307#12pmos@66_poly-right##13 9.864
R2137 net@1307#12pmos@66_poly-right##13 net@1307#12pmos@66_poly-right##14 9.864
R2138 net@1307#12pmos@66_poly-right##14 net@1307#12pmos@66_poly-right##15 9.864
R2139 net@1307#12pmos@66_poly-right##15 net@1307#12pmos@66_poly-right##16 9.864
R2140 net@1307#12pmos@66_poly-right##16 net@1307#12pmos@66_poly-right##17 9.864
R2141 net@1307#12pmos@66_poly-right##17 net@1307#12pmos@66_poly-right##18 9.864
R2142 net@1307#12pmos@66_poly-right##18 net@1307#12pmos@66_poly-right##19 9.864
R2143 net@1307#12pmos@66_poly-right##19 net@1307#12pmos@66_poly-right##20 9.864
R2144 net@1307#12pmos@66_poly-right##20 net@1307#12pmos@66_poly-right##21 9.864
R2145 net@1307#12pmos@66_poly-right##21 net@1307#12pmos@66_poly-right##22 9.864
R2146 net@1307#12pmos@66_poly-right##22 net@1307#12pmos@66_poly-right##23 9.864
R2147 net@1307#12pmos@66_poly-right##23 net@1307#12pmos@66_poly-right##24 9.864
R2148 net@1307#12pmos@66_poly-right##24 net@1307#12pmos@66_poly-right##25 9.864
R2149 net@1307#12pmos@66_poly-right##25 net@1307#12pmos@66_poly-right##26 9.864
R2150 net@1307#12pmos@66_poly-right##26 net@1307#12pmos@66_poly-right##27 9.864
R2151 net@1307#12pmos@66_poly-right##27 net@1307#12pmos@66_poly-right##28 9.864
R2152 net@1307#12pmos@66_poly-right##28 net@1307#12pmos@66_poly-right##29 9.864
R2153 net@1307#12pmos@66_poly-right##29 net@1307#12pmos@66_poly-right##30 9.864
R2154 net@1307#12pmos@66_poly-right##30 net@1307#12pmos@66_poly-right##31 9.864
R2155 net@1307#12pmos@66_poly-right##31 net@1307#12pmos@66_poly-right##32 9.864
R2156 net@1307#12pmos@66_poly-right##32 net@1307#12pmos@66_poly-right##33 9.864
R2157 net@1307#12pmos@66_poly-right##33 net@1307#12pmos@66_poly-right##34 9.864
R2158 net@1307#12pmos@66_poly-right##34 net@1307#12pmos@66_poly-right##35 9.864
R2159 net@1307#12pmos@66_poly-right##35 net@1307#12pmos@66_poly-right##36 9.864
R2160 net@1307#12pmos@66_poly-right##36 net@1307#12pmos@66_poly-right##37 9.864
R2161 net@1307#12pmos@66_poly-right##37 net@1307#12pmos@66_poly-right##38 9.864
R2162 net@1307#12pmos@66_poly-right##38 net@1307#12pmos@66_poly-right##39 9.864
R2163 net@1307#12pmos@66_poly-right##39 net@1307#12pmos@66_poly-right##40 9.864
R2164 net@1307#12pmos@66_poly-right##40 net@1307#12pmos@66_poly-right##41 9.864
R2165 net@1307#12pmos@66_poly-right##41 net@1307#12pmos@66_poly-right##42 9.864
R2166 net@1307#12pmos@66_poly-right##42 net@1307#12pmos@66_poly-right##43 9.864
R2167 net@1307#12pmos@66_poly-right##43 net@1307#12pmos@66_poly-right##44 9.864
R2168 net@1307#12pmos@66_poly-right##44 net@1307#12pmos@66_poly-right##45 9.864
R2169 net@1307#12pmos@66_poly-right##45 net@1307#12pmos@66_poly-right##46 9.864
R2170 net@1307#12pmos@66_poly-right##46 net@1307#12pmos@66_poly-right##47 9.864
R2171 net@1307#12pmos@66_poly-right##47 net@1307#12pmos@66_poly-right##48 9.864
R2172 net@1307#12pmos@66_poly-right##48 net@1307#12pmos@66_poly-right##49 9.864
R2173 net@1307#12pmos@66_poly-right##49 net@1307#12pmos@66_poly-right##50 9.864
R2174 net@1307#12pmos@66_poly-right##50 net@1307#12pmos@66_poly-right##51 9.864
R2175 net@1307#12pmos@66_poly-right##51 net@1307#12pmos@66_poly-right##52 9.864
R2176 net@1307#12pmos@66_poly-right##52 net@1307#12pmos@66_poly-right##53 9.864
R2177 net@1307#12pmos@66_poly-right##53 net@1307#5pin@345_polysilicon-1 9.864
R2178 XOR1_to_NAND2#22pmos@66_diff-top XOR1_to_NAND2#1contact@544_metal-1-metal-2 4.862
R2179 XOR1_to_NAND2#3pin@378_polysilicon-1 XOR1_to_NAND2#3pin@378_polysilicon-1##0 9.881
R2180 XOR1_to_NAND2#3pin@378_polysilicon-1##0 XOR1_to_NAND2#3pin@378_polysilicon-1##1 9.881
R2181 XOR1_to_NAND2#3pin@378_polysilicon-1##1 XOR1_to_NAND2#3pin@378_polysilicon-1##2 9.881
R2182 XOR1_to_NAND2#3pin@378_polysilicon-1##2 XOR1_to_NAND2#3pin@378_polysilicon-1##3 9.881
R2183 XOR1_to_NAND2#3pin@378_polysilicon-1##3 XOR1_to_NAND2#3pin@378_polysilicon-1##4 9.881
R2184 XOR1_to_NAND2#3pin@378_polysilicon-1##4 XOR1_to_NAND2#3pin@378_polysilicon-1##5 9.881
R2185 XOR1_to_NAND2#3pin@378_polysilicon-1##5 XOR1_to_NAND2#3pin@378_polysilicon-1##6 9.881
R2186 XOR1_to_NAND2#3pin@378_polysilicon-1##6 XOR1_to_NAND2#3pin@378_polysilicon-1##7 9.881
R2187 XOR1_to_NAND2#3pin@378_polysilicon-1##7 XOR1_to_NAND2#3pin@378_polysilicon-1##8 9.881
R2188 XOR1_to_NAND2#3pin@378_polysilicon-1##8 XOR1_to_NAND2#3pin@378_polysilicon-1##9 9.881
R2189 XOR1_to_NAND2#3pin@378_polysilicon-1##9 XOR1_to_NAND2#3pin@378_polysilicon-1##10 9.881
R2190 XOR1_to_NAND2#3pin@378_polysilicon-1##10 XOR1_to_NAND2#3pin@378_polysilicon-1##11 9.881
R2191 XOR1_to_NAND2#3pin@378_polysilicon-1##11 XOR1_to_NAND2#3pin@378_polysilicon-1##12 9.881
R2192 XOR1_to_NAND2#3pin@378_polysilicon-1##12 XOR1_to_NAND2#3pin@378_polysilicon-1##13 9.881
R2193 XOR1_to_NAND2#3pin@378_polysilicon-1##13 XOR1_to_NAND2#3pin@378_polysilicon-1##14 9.881
R2194 XOR1_to_NAND2#3pin@378_polysilicon-1##14 XOR1_to_NAND2#3pin@378_polysilicon-1##15 9.881
R2195 XOR1_to_NAND2#3pin@378_polysilicon-1##15 XOR1_to_NAND2#3pin@378_polysilicon-1##16 9.881
R2196 XOR1_to_NAND2#3pin@378_polysilicon-1##16 XOR1_to_NAND2#3pin@378_polysilicon-1##17 9.881
R2197 XOR1_to_NAND2#3pin@378_polysilicon-1##17 XOR1_to_NAND2#3pin@378_polysilicon-1##18 9.881
R2198 XOR1_to_NAND2#3pin@378_polysilicon-1##18 XOR1_to_NAND2#3pin@378_polysilicon-1##19 9.881
R2199 XOR1_to_NAND2#3pin@378_polysilicon-1##19 XOR1_to_NAND2#3pin@378_polysilicon-1##20 9.881
R2200 XOR1_to_NAND2#3pin@378_polysilicon-1##20 XOR1_to_NAND2#3pin@378_polysilicon-1##21 9.881
R2201 XOR1_to_NAND2#3pin@378_polysilicon-1##21 XOR1_to_NAND2#3pin@378_polysilicon-1##22 9.881
R2202 XOR1_to_NAND2#3pin@378_polysilicon-1##22 XOR1_to_NAND2#3pin@378_polysilicon-1##23 9.881
R2203 XOR1_to_NAND2#3pin@378_polysilicon-1##23 XOR1_to_NAND2#3pin@378_polysilicon-1##24 9.881
R2204 XOR1_to_NAND2#3pin@378_polysilicon-1##24 XOR1_to_NAND2#3pin@378_polysilicon-1##25 9.881
R2205 XOR1_to_NAND2#3pin@378_polysilicon-1##25 XOR1_to_NAND2#3pin@378_polysilicon-1##26 9.881
R2206 XOR1_to_NAND2#3pin@378_polysilicon-1##26 XOR1_to_NAND2#3pin@378_polysilicon-1##27 9.881
R2207 XOR1_to_NAND2#3pin@378_polysilicon-1##27 XOR1_to_NAND2#3pin@378_polysilicon-1##28 9.881
R2208 XOR1_to_NAND2#3pin@378_polysilicon-1##28 XOR1_to_NAND2#3pin@378_polysilicon-1##29 9.881
R2209 XOR1_to_NAND2#3pin@378_polysilicon-1##29 XOR1_to_NAND2#3pin@378_polysilicon-1##30 9.881
R2210 XOR1_to_NAND2#3pin@378_polysilicon-1##30 XOR1_to_NAND2#3pin@378_polysilicon-1##31 9.881
R2211 XOR1_to_NAND2#3pin@378_polysilicon-1##31 XOR1_to_NAND2#3pin@378_polysilicon-1##32 9.881
R2212 XOR1_to_NAND2#3pin@378_polysilicon-1##32 XOR1_to_NAND2#3pin@378_polysilicon-1##33 9.881
R2213 XOR1_to_NAND2#3pin@378_polysilicon-1##33 XOR1_to_NAND2#3pin@378_polysilicon-1##34 9.881
R2214 XOR1_to_NAND2#3pin@378_polysilicon-1##34 XOR1_to_NAND2#3pin@378_polysilicon-1##35 9.881
R2215 XOR1_to_NAND2#3pin@378_polysilicon-1##35 XOR1_to_NAND2#3pin@378_polysilicon-1##36 9.881
R2216 XOR1_to_NAND2#3pin@378_polysilicon-1##36 XOR1_to_NAND2#3pin@378_polysilicon-1##37 9.881
R2217 XOR1_to_NAND2#3pin@378_polysilicon-1##37 XOR1_to_NAND2#3pin@378_polysilicon-1##38 9.881
R2218 XOR1_to_NAND2#3pin@378_polysilicon-1##38 XOR1_to_NAND2#3pin@378_polysilicon-1##39 9.881
R2219 XOR1_to_NAND2#3pin@378_polysilicon-1##39 XOR1_to_NAND2#3pin@378_polysilicon-1##40 9.881
R2220 XOR1_to_NAND2#3pin@378_polysilicon-1##40 XOR1_to_NAND2#3pin@378_polysilicon-1##41 9.881
R2221 XOR1_to_NAND2#3pin@378_polysilicon-1##41 XOR1_to_NAND2#3pin@378_polysilicon-1##42 9.881
R2222 XOR1_to_NAND2#3pin@378_polysilicon-1##42 XOR1_to_NAND2#3pin@378_polysilicon-1##43 9.881
R2223 XOR1_to_NAND2#3pin@378_polysilicon-1##43 XOR1_to_NAND2#3pin@378_polysilicon-1##44 9.881
R2224 XOR1_to_NAND2#3pin@378_polysilicon-1##44 XOR1_to_NAND2#3pin@378_polysilicon-1##45 9.881
R2225 XOR1_to_NAND2#3pin@378_polysilicon-1##45 XOR1_to_NAND2#3pin@378_polysilicon-1##46 9.881
R2226 XOR1_to_NAND2#3pin@378_polysilicon-1##46 XOR1_to_NAND2#3pin@378_polysilicon-1##47 9.881
R2227 XOR1_to_NAND2#3pin@378_polysilicon-1##47 XOR1_to_NAND2#3pin@378_polysilicon-1##48 9.881
R2228 XOR1_to_NAND2#3pin@378_polysilicon-1##48 XOR1_to_NAND2#3pin@378_polysilicon-1##49 9.881
R2229 XOR1_to_NAND2#3pin@378_polysilicon-1##49 XOR1_to_NAND2#3pin@378_polysilicon-1##50 9.881
R2230 XOR1_to_NAND2#3pin@378_polysilicon-1##50 XOR1_to_NAND2#3pin@378_polysilicon-1##51 9.881
R2231 XOR1_to_NAND2#3pin@378_polysilicon-1##51 XOR1_to_NAND2#3pin@378_polysilicon-1##52 9.881
R2232 XOR1_to_NAND2#3pin@378_polysilicon-1##52 XOR1_to_NAND2#3pin@378_polysilicon-1##53 9.881
R2233 XOR1_to_NAND2#3pin@378_polysilicon-1##53 XOR1_to_NAND2#3pin@378_polysilicon-1##54 9.881
R2234 XOR1_to_NAND2#3pin@378_polysilicon-1##54 XOR1_to_NAND2#24nmos@72_poly-right 9.881
R2235 net@1211#5pmos@72_diff-top net@1211#2pin@367_metal-1 4.81
R2236 net@1211#1pin@377_polysilicon-1 net@1211#1pin@377_polysilicon-1##0 9.85
R2237 net@1211#1pin@377_polysilicon-1##0 net@1211#1pin@377_polysilicon-1##1 9.85
R2238 net@1211#1pin@377_polysilicon-1##1 net@1211#1pin@377_polysilicon-1##2 9.85
R2239 net@1211#1pin@377_polysilicon-1##2 net@1211#1pin@377_polysilicon-1##3 9.85
R2240 net@1211#1pin@377_polysilicon-1##3 net@1211#1pin@377_polysilicon-1##4 9.85
R2241 net@1211#1pin@377_polysilicon-1##4 net@1211#1pin@377_polysilicon-1##5 9.85
R2242 net@1211#1pin@377_polysilicon-1##5 net@1211#1pin@377_polysilicon-1##6 9.85
R2243 net@1211#1pin@377_polysilicon-1##6 net@1211#1pin@377_polysilicon-1##7 9.85
R2244 net@1211#1pin@377_polysilicon-1##7 net@1211#1pin@377_polysilicon-1##8 9.85
R2245 net@1211#1pin@377_polysilicon-1##8 net@1211#1pin@377_polysilicon-1##9 9.85
R2246 net@1211#1pin@377_polysilicon-1##9 net@1211#1pin@377_polysilicon-1##10 9.85
R2247 net@1211#1pin@377_polysilicon-1##10 net@1211#1pin@377_polysilicon-1##11 9.85
R2248 net@1211#1pin@377_polysilicon-1##11 net@1211#1pin@377_polysilicon-1##12 9.85
R2249 net@1211#1pin@377_polysilicon-1##12 net@1211#1pin@377_polysilicon-1##13 9.85
R2250 net@1211#1pin@377_polysilicon-1##13 net@1211#1pin@377_polysilicon-1##14 9.85
R2251 net@1211#1pin@377_polysilicon-1##14 net@1211#1pin@377_polysilicon-1##15 9.85
R2252 net@1211#1pin@377_polysilicon-1##15 net@1211#1pin@377_polysilicon-1##16 9.85
R2253 net@1211#1pin@377_polysilicon-1##16 net@1211#1pin@377_polysilicon-1##17 9.85
R2254 net@1211#1pin@377_polysilicon-1##17 net@1211#1pin@377_polysilicon-1##18 9.85
R2255 net@1211#1pin@377_polysilicon-1##18 net@1211#1pin@377_polysilicon-1##19 9.85
R2256 net@1211#1pin@377_polysilicon-1##19 net@1211#1pin@377_polysilicon-1##20 9.85
R2257 net@1211#1pin@377_polysilicon-1##20 net@1211#1pin@377_polysilicon-1##21 9.85
R2258 net@1211#1pin@377_polysilicon-1##21 net@1211#1pin@377_polysilicon-1##22 9.85
R2259 net@1211#1pin@377_polysilicon-1##22 net@1211#1pin@377_polysilicon-1##23 9.85
R2260 net@1211#1pin@377_polysilicon-1##23 net@1211#1pin@377_polysilicon-1##24 9.85
R2261 net@1211#1pin@377_polysilicon-1##24 net@1211#1pin@377_polysilicon-1##25 9.85
R2262 net@1211#1pin@377_polysilicon-1##25 net@1211#1pin@377_polysilicon-1##26 9.85
R2263 net@1211#1pin@377_polysilicon-1##26 net@1211#1pin@377_polysilicon-1##27 9.85
R2264 net@1211#1pin@377_polysilicon-1##27 net@1211#1pin@377_polysilicon-1##28 9.85
R2265 net@1211#1pin@377_polysilicon-1##28 net@1211#1pin@377_polysilicon-1##29 9.85
R2266 net@1211#1pin@377_polysilicon-1##29 net@1211#1pin@377_polysilicon-1##30 9.85
R2267 net@1211#1pin@377_polysilicon-1##30 net@1211#1pin@377_polysilicon-1##31 9.85
R2268 net@1211#1pin@377_polysilicon-1##31 net@1211#1pin@377_polysilicon-1##32 9.85
R2269 net@1211#1pin@377_polysilicon-1##32 net@1211#1pin@377_polysilicon-1##33 9.85
R2270 net@1211#1pin@377_polysilicon-1##33 net@1211#1pin@377_polysilicon-1##34 9.85
R2271 net@1211#1pin@377_polysilicon-1##34 net@1211#1pin@377_polysilicon-1##35 9.85
R2272 net@1211#1pin@377_polysilicon-1##35 net@1211#1pin@377_polysilicon-1##36 9.85
R2273 net@1211#1pin@377_polysilicon-1##36 net@1211#1pin@377_polysilicon-1##37 9.85
R2274 net@1211#1pin@377_polysilicon-1##37 net@1211#1pin@377_polysilicon-1##38 9.85
R2275 net@1211#1pin@377_polysilicon-1##38 net@1211#1pin@377_polysilicon-1##39 9.85
R2276 net@1211#1pin@377_polysilicon-1##39 net@1211#1pin@377_polysilicon-1##40 9.85
R2277 net@1211#1pin@377_polysilicon-1##40 net@1211#1pin@377_polysilicon-1##41 9.85
R2278 net@1211#1pin@377_polysilicon-1##41 net@1211#1pin@377_polysilicon-1##42 9.85
R2279 net@1211#1pin@377_polysilicon-1##42 net@1211#1pin@377_polysilicon-1##43 9.85
R2280 net@1211#1pin@377_polysilicon-1##43 net@1211#1pin@377_polysilicon-1##44 9.85
R2281 net@1211#1pin@377_polysilicon-1##44 net@1211#1pin@377_polysilicon-1##45 9.85
R2282 net@1211#1pin@377_polysilicon-1##45 net@1211#1pin@377_polysilicon-1##46 9.85
R2283 net@1211#1pin@377_polysilicon-1##46 net@1211#1pin@377_polysilicon-1##47 9.85
R2284 net@1211#1pin@377_polysilicon-1##47 net@1211#1pin@377_polysilicon-1##48 9.85
R2285 net@1211#1pin@377_polysilicon-1##48 net@1211#1pin@377_polysilicon-1##49 9.85
R2286 net@1211#1pin@377_polysilicon-1##49 net@1211#1pin@377_polysilicon-1##50 9.85
R2287 net@1211#1pin@377_polysilicon-1##50 net@1211#1pin@377_polysilicon-1##51 9.85
R2288 net@1211#1pin@377_polysilicon-1##51 net@1211#1pin@377_polysilicon-1##52 9.85
R2289 net@1211#1pin@377_polysilicon-1##52 net@1211#1pin@377_polysilicon-1##53 9.85
R2290 net@1211#1pin@377_polysilicon-1##53 net@1211#1pin@377_polysilicon-1##54 9.85
R2291 net@1211#1pin@377_polysilicon-1##54 net@1211#1pin@377_polysilicon-1##55 9.85
R2292 net@1211#1pin@377_polysilicon-1##55 net@1211#1pin@377_polysilicon-1##56 9.85
R2293 net@1211#1pin@377_polysilicon-1##56 net@1211#1pin@377_polysilicon-1##57 9.85
R2294 net@1211#1pin@377_polysilicon-1##57 net@1211#1pin@377_polysilicon-1##58 9.85
R2295 net@1211#1pin@377_polysilicon-1##58 net@1211#1pin@377_polysilicon-1##59 9.85
R2296 net@1211#1pin@377_polysilicon-1##59 net@1211#1pin@377_polysilicon-1##60 9.85
R2297 net@1211#1pin@377_polysilicon-1##60 net@1211#2pin@367_metal-1 9.85
R2298 Cin_to_XOR2___NAND2#26pmos@71_poly-right Cin_to_XOR2___NAND2#26pmos@71_poly-right##0 9.854
R2299 Cin_to_XOR2___NAND2#26pmos@71_poly-right##0 Cin_to_XOR2___NAND2#26pmos@71_poly-right##1 9.854
R2300 Cin_to_XOR2___NAND2#26pmos@71_poly-right##1 Cin_to_XOR2___NAND2#26pmos@71_poly-right##2 9.854
R2301 Cin_to_XOR2___NAND2#26pmos@71_poly-right##2 Cin_to_XOR2___NAND2#26pmos@71_poly-right##3 9.854
R2302 Cin_to_XOR2___NAND2#26pmos@71_poly-right##3 Cin_to_XOR2___NAND2#26pmos@71_poly-right##4 9.854
R2303 Cin_to_XOR2___NAND2#26pmos@71_poly-right##4 Cin_to_XOR2___NAND2#26pmos@71_poly-right##5 9.854
R2304 Cin_to_XOR2___NAND2#26pmos@71_poly-right##5 Cin_to_XOR2___NAND2#26pmos@71_poly-right##6 9.854
R2305 Cin_to_XOR2___NAND2#26pmos@71_poly-right##6 Cin_to_XOR2___NAND2#26pmos@71_poly-right##7 9.854
R2306 Cin_to_XOR2___NAND2#26pmos@71_poly-right##7 Cin_to_XOR2___NAND2#26pmos@71_poly-right##8 9.854
R2307 Cin_to_XOR2___NAND2#26pmos@71_poly-right##8 Cin_to_XOR2___NAND2#26pmos@71_poly-right##9 9.854
R2308 Cin_to_XOR2___NAND2#26pmos@71_poly-right##9 Cin_to_XOR2___NAND2#26pmos@71_poly-right##10 9.854
R2309 Cin_to_XOR2___NAND2#26pmos@71_poly-right##10 Cin_to_XOR2___NAND2#26pmos@71_poly-right##11 9.854
R2310 Cin_to_XOR2___NAND2#26pmos@71_poly-right##11 Cin_to_XOR2___NAND2#26pmos@71_poly-right##12 9.854
R2311 Cin_to_XOR2___NAND2#26pmos@71_poly-right##12 Cin_to_XOR2___NAND2#26pmos@71_poly-right##13 9.854
R2312 Cin_to_XOR2___NAND2#26pmos@71_poly-right##13 Cin_to_XOR2___NAND2#26pmos@71_poly-right##14 9.854
R2313 Cin_to_XOR2___NAND2#26pmos@71_poly-right##14 Cin_to_XOR2___NAND2#26pmos@71_poly-right##15 9.854
R2314 Cin_to_XOR2___NAND2#26pmos@71_poly-right##15 Cin_to_XOR2___NAND2#26pmos@71_poly-right##16 9.854
R2315 Cin_to_XOR2___NAND2#26pmos@71_poly-right##16 Cin_to_XOR2___NAND2#26pmos@71_poly-right##17 9.854
R2316 Cin_to_XOR2___NAND2#26pmos@71_poly-right##17 Cin_to_XOR2___NAND2#26pmos@71_poly-right##18 9.854
R2317 Cin_to_XOR2___NAND2#26pmos@71_poly-right##18 Cin_to_XOR2___NAND2#26pmos@71_poly-right##19 9.854
R2318 Cin_to_XOR2___NAND2#26pmos@71_poly-right##19 Cin_to_XOR2___NAND2#26pmos@71_poly-right##20 9.854
R2319 Cin_to_XOR2___NAND2#26pmos@71_poly-right##20 Cin_to_XOR2___NAND2#26pmos@71_poly-right##21 9.854
R2320 Cin_to_XOR2___NAND2#26pmos@71_poly-right##21 Cin_to_XOR2___NAND2#26pmos@71_poly-right##22 9.854
R2321 Cin_to_XOR2___NAND2#26pmos@71_poly-right##22 Cin_to_XOR2___NAND2#26pmos@71_poly-right##23 9.854
R2322 Cin_to_XOR2___NAND2#26pmos@71_poly-right##23 Cin_to_XOR2___NAND2#26pmos@71_poly-right##24 9.854
R2323 Cin_to_XOR2___NAND2#26pmos@71_poly-right##24 Cin_to_XOR2___NAND2#26pmos@71_poly-right##25 9.854
R2324 Cin_to_XOR2___NAND2#26pmos@71_poly-right##25 Cin_to_XOR2___NAND2#26pmos@71_poly-right##26 9.854
R2325 Cin_to_XOR2___NAND2#26pmos@71_poly-right##26 Cin_to_XOR2___NAND2#26pmos@71_poly-right##27 9.854
R2326 Cin_to_XOR2___NAND2#26pmos@71_poly-right##27 Cin_to_XOR2___NAND2#26pmos@71_poly-right##28 9.854
R2327 Cin_to_XOR2___NAND2#26pmos@71_poly-right##28 Cin_to_XOR2___NAND2#26pmos@71_poly-right##29 9.854
R2328 Cin_to_XOR2___NAND2#26pmos@71_poly-right##29 Cin_to_XOR2___NAND2#26pmos@71_poly-right##30 9.854
R2329 Cin_to_XOR2___NAND2#26pmos@71_poly-right##30 Cin_to_XOR2___NAND2#26pmos@71_poly-right##31 9.854
R2330 Cin_to_XOR2___NAND2#26pmos@71_poly-right##31 Cin_to_XOR2___NAND2#26pmos@71_poly-right##32 9.854
R2331 Cin_to_XOR2___NAND2#26pmos@71_poly-right##32 Cin_to_XOR2___NAND2#26pmos@71_poly-right##33 9.854
R2332 Cin_to_XOR2___NAND2#26pmos@71_poly-right##33 Cin_to_XOR2___NAND2#26pmos@71_poly-right##34 9.854
R2333 Cin_to_XOR2___NAND2#26pmos@71_poly-right##34 Cin_to_XOR2___NAND2#26pmos@71_poly-right##35 9.854
R2334 Cin_to_XOR2___NAND2#26pmos@71_poly-right##35 Cin_to_XOR2___NAND2#26pmos@71_poly-right##36 9.854
R2335 Cin_to_XOR2___NAND2#26pmos@71_poly-right##36 Cin_to_XOR2___NAND2#26pmos@71_poly-right##37 9.854
R2336 Cin_to_XOR2___NAND2#26pmos@71_poly-right##37 Cin_to_XOR2___NAND2#26pmos@71_poly-right##38 9.854
R2337 Cin_to_XOR2___NAND2#26pmos@71_poly-right##38 Cin_to_XOR2___NAND2#26pmos@71_poly-right##39 9.854
R2338 Cin_to_XOR2___NAND2#26pmos@71_poly-right##39 Cin_to_XOR2___NAND2#26pmos@71_poly-right##40 9.854
R2339 Cin_to_XOR2___NAND2#26pmos@71_poly-right##40 Cin_to_XOR2___NAND2#26pmos@71_poly-right##41 9.854
R2340 Cin_to_XOR2___NAND2#26pmos@71_poly-right##41 Cin_to_XOR2___NAND2#26pmos@71_poly-right##42 9.854
R2341 Cin_to_XOR2___NAND2#26pmos@71_poly-right##42 Cin_to_XOR2___NAND2#26pmos@71_poly-right##43 9.854
R2342 Cin_to_XOR2___NAND2#26pmos@71_poly-right##43 Cin_to_XOR2___NAND2#26pmos@71_poly-right##44 9.854
R2343 Cin_to_XOR2___NAND2#26pmos@71_poly-right##44 Cin_to_XOR2___NAND2#26pmos@71_poly-right##45 9.854
R2344 Cin_to_XOR2___NAND2#26pmos@71_poly-right##45 Cin_to_XOR2___NAND2#26pmos@71_poly-right##46 9.854
R2345 Cin_to_XOR2___NAND2#26pmos@71_poly-right##46 Cin_to_XOR2___NAND2#26pmos@71_poly-right##47 9.854
R2346 Cin_to_XOR2___NAND2#26pmos@71_poly-right##47 Cin_to_XOR2___NAND2#26pmos@71_poly-right##48 9.854
R2347 Cin_to_XOR2___NAND2#26pmos@71_poly-right##48 Cin_to_XOR2___NAND2#26pmos@71_poly-right##49 9.854
R2348 Cin_to_XOR2___NAND2#26pmos@71_poly-right##49 Cin_to_XOR2___NAND2#26pmos@71_poly-right##50 9.854
R2349 Cin_to_XOR2___NAND2#26pmos@71_poly-right##50 Cin_to_XOR2___NAND2#26pmos@71_poly-right##51 9.854
R2350 Cin_to_XOR2___NAND2#26pmos@71_poly-right##51 Cin_to_XOR2___NAND2#26pmos@71_poly-right##52 9.854
R2351 Cin_to_XOR2___NAND2#26pmos@71_poly-right##52 Cin_to_XOR2___NAND2#26pmos@71_poly-right##53 9.854
R2352 Cin_to_XOR2___NAND2#26pmos@71_poly-right##53 Cin_to_XOR2___NAND2#26pmos@71_poly-right##54 9.854
R2353 Cin_to_XOR2___NAND2#26pmos@71_poly-right##54 Cin_to_XOR2___NAND2#15pin@368_polysilicon-1 9.854
R2354 net@1221 net@1221#2contact@505_metal-1-metal-2 4.797
R2355 XOR1_to_NAND2#9pmos@67_poly-left XOR1_to_NAND2#9pmos@67_poly-left##0 9.871
R2356 XOR1_to_NAND2#9pmos@67_poly-left##0 XOR1_to_NAND2#9pmos@67_poly-left##1 9.871
R2357 XOR1_to_NAND2#9pmos@67_poly-left##1 XOR1_to_NAND2#9pmos@67_poly-left##2 9.871
R2358 XOR1_to_NAND2#9pmos@67_poly-left##2 XOR1_to_NAND2#9pmos@67_poly-left##3 9.871
R2359 XOR1_to_NAND2#9pmos@67_poly-left##3 XOR1_to_NAND2#9pmos@67_poly-left##4 9.871
R2360 XOR1_to_NAND2#9pmos@67_poly-left##4 XOR1_to_NAND2#9pmos@67_poly-left##5 9.871
R2361 XOR1_to_NAND2#9pmos@67_poly-left##5 XOR1_to_NAND2#9pmos@67_poly-left##6 9.871
R2362 XOR1_to_NAND2#9pmos@67_poly-left##6 XOR1_to_NAND2#9pmos@67_poly-left##7 9.871
R2363 XOR1_to_NAND2#9pmos@67_poly-left##7 XOR1_to_NAND2#9pmos@67_poly-left##8 9.871
R2364 XOR1_to_NAND2#9pmos@67_poly-left##8 XOR1_to_NAND2#9pmos@67_poly-left##9 9.871
R2365 XOR1_to_NAND2#9pmos@67_poly-left##9 XOR1_to_NAND2#9pmos@67_poly-left##10 9.871
R2366 XOR1_to_NAND2#9pmos@67_poly-left##10 XOR1_to_NAND2#9pmos@67_poly-left##11 9.871
R2367 XOR1_to_NAND2#9pmos@67_poly-left##11 XOR1_to_NAND2#9pmos@67_poly-left##12 9.871
R2368 XOR1_to_NAND2#9pmos@67_poly-left##12 XOR1_to_NAND2#9pmos@67_poly-left##13 9.871
R2369 XOR1_to_NAND2#9pmos@67_poly-left##13 XOR1_to_NAND2#9pmos@67_poly-left##14 9.871
R2370 XOR1_to_NAND2#9pmos@67_poly-left##14 XOR1_to_NAND2#9pmos@67_poly-left##15 9.871
R2371 XOR1_to_NAND2#9pmos@67_poly-left##15 XOR1_to_NAND2#9pmos@67_poly-left##16 9.871
R2372 XOR1_to_NAND2#9pmos@67_poly-left##16 XOR1_to_NAND2#9pmos@67_poly-left##17 9.871
R2373 XOR1_to_NAND2#9pmos@67_poly-left##17 XOR1_to_NAND2#9pmos@67_poly-left##18 9.871
R2374 XOR1_to_NAND2#9pmos@67_poly-left##18 XOR1_to_NAND2#9pmos@67_poly-left##19 9.871
R2375 XOR1_to_NAND2#9pmos@67_poly-left##19 XOR1_to_NAND2#9pmos@67_poly-left##20 9.871
R2376 XOR1_to_NAND2#9pmos@67_poly-left##20 XOR1_to_NAND2#9pmos@67_poly-left##21 9.871
R2377 XOR1_to_NAND2#9pmos@67_poly-left##21 XOR1_to_NAND2#9pmos@67_poly-left##22 9.871
R2378 XOR1_to_NAND2#9pmos@67_poly-left##22 XOR1_to_NAND2#9pmos@67_poly-left##23 9.871
R2379 XOR1_to_NAND2#9pmos@67_poly-left##23 XOR1_to_NAND2#9pmos@67_poly-left##24 9.871
R2380 XOR1_to_NAND2#9pmos@67_poly-left##24 XOR1_to_NAND2#9pmos@67_poly-left##25 9.871
R2381 XOR1_to_NAND2#9pmos@67_poly-left##25 XOR1_to_NAND2#9pmos@67_poly-left##26 9.871
R2382 XOR1_to_NAND2#9pmos@67_poly-left##26 XOR1_to_NAND2#9pmos@67_poly-left##27 9.871
R2383 XOR1_to_NAND2#9pmos@67_poly-left##27 XOR1_to_NAND2#9pmos@67_poly-left##28 9.871
R2384 XOR1_to_NAND2#9pmos@67_poly-left##28 XOR1_to_NAND2#9pmos@67_poly-left##29 9.871
R2385 XOR1_to_NAND2#9pmos@67_poly-left##29 XOR1_to_NAND2#9pmos@67_poly-left##30 9.871
R2386 XOR1_to_NAND2#9pmos@67_poly-left##30 XOR1_to_NAND2#9pmos@67_poly-left##31 9.871
R2387 XOR1_to_NAND2#9pmos@67_poly-left##31 XOR1_to_NAND2#9pmos@67_poly-left##32 9.871
R2388 XOR1_to_NAND2#9pmos@67_poly-left##32 XOR1_to_NAND2#9pmos@67_poly-left##33 9.871
R2389 XOR1_to_NAND2#9pmos@67_poly-left##33 XOR1_to_NAND2#9pmos@67_poly-left##34 9.871
R2390 XOR1_to_NAND2#9pmos@67_poly-left##34 XOR1_to_NAND2#9pmos@67_poly-left##35 9.871
R2391 XOR1_to_NAND2#9pmos@67_poly-left##35 XOR1_to_NAND2#9pmos@67_poly-left##36 9.871
R2392 XOR1_to_NAND2#9pmos@67_poly-left##36 XOR1_to_NAND2#9pmos@67_poly-left##37 9.871
R2393 XOR1_to_NAND2#9pmos@67_poly-left##37 XOR1_to_NAND2#9pmos@67_poly-left##38 9.871
R2394 XOR1_to_NAND2#9pmos@67_poly-left##38 XOR1_to_NAND2#9pmos@67_poly-left##39 9.871
R2395 XOR1_to_NAND2#9pmos@67_poly-left##39 XOR1_to_NAND2#9pmos@67_poly-left##40 9.871
R2396 XOR1_to_NAND2#9pmos@67_poly-left##40 XOR1_to_NAND2#9pmos@67_poly-left##41 9.871
R2397 XOR1_to_NAND2#9pmos@67_poly-left##41 XOR1_to_NAND2#9pmos@67_poly-left##42 9.871
R2398 XOR1_to_NAND2#9pmos@67_poly-left##42 XOR1_to_NAND2#9pmos@67_poly-left##43 9.871
R2399 XOR1_to_NAND2#9pmos@67_poly-left##43 XOR1_to_NAND2#9pmos@67_poly-left##44 9.871
R2400 XOR1_to_NAND2#9pmos@67_poly-left##44 XOR1_to_NAND2#9pmos@67_poly-left##45 9.871
R2401 XOR1_to_NAND2#9pmos@67_poly-left##45 XOR1_to_NAND2#9pmos@67_poly-left##46 9.871
R2402 XOR1_to_NAND2#9pmos@67_poly-left##46 XOR1_to_NAND2#9pmos@67_poly-left##47 9.871
R2403 XOR1_to_NAND2#9pmos@67_poly-left##47 XOR1_to_NAND2#9pmos@67_poly-left##48 9.871
R2404 XOR1_to_NAND2#9pmos@67_poly-left##48 XOR1_to_NAND2#9pmos@67_poly-left##49 9.871
R2405 XOR1_to_NAND2#9pmos@67_poly-left##49 XOR1_to_NAND2#9pmos@67_poly-left##50 9.871
R2406 XOR1_to_NAND2#9pmos@67_poly-left##50 XOR1_to_NAND2#9pmos@67_poly-left##51 9.871
R2407 XOR1_to_NAND2#9pmos@67_poly-left##51 XOR1_to_NAND2#9pmos@67_poly-left##52 9.871
R2408 XOR1_to_NAND2#9pmos@67_poly-left##52 XOR1_to_NAND2#9pmos@67_poly-left##53 9.871
R2409 XOR1_to_NAND2#9pmos@67_poly-left##53 XOR1_to_NAND2#9pmos@67_poly-left##54 9.871
R2410 XOR1_to_NAND2#9pmos@67_poly-left##54 XOR1_to_NAND2#9pmos@67_poly-left##55 9.871
R2411 XOR1_to_NAND2#9pmos@67_poly-left##55 XOR1_to_NAND2#26nmos@67_poly-right 9.871
R2412 net@1211#7pmos@68_poly-left net@1211#7pmos@68_poly-left##0 9.871
R2413 net@1211#7pmos@68_poly-left##0 net@1211#7pmos@68_poly-left##1 9.871
R2414 net@1211#7pmos@68_poly-left##1 net@1211#7pmos@68_poly-left##2 9.871
R2415 net@1211#7pmos@68_poly-left##2 net@1211#7pmos@68_poly-left##3 9.871
R2416 net@1211#7pmos@68_poly-left##3 net@1211#7pmos@68_poly-left##4 9.871
R2417 net@1211#7pmos@68_poly-left##4 net@1211#7pmos@68_poly-left##5 9.871
R2418 net@1211#7pmos@68_poly-left##5 net@1211#7pmos@68_poly-left##6 9.871
R2419 net@1211#7pmos@68_poly-left##6 net@1211#7pmos@68_poly-left##7 9.871
R2420 net@1211#7pmos@68_poly-left##7 net@1211#7pmos@68_poly-left##8 9.871
R2421 net@1211#7pmos@68_poly-left##8 net@1211#7pmos@68_poly-left##9 9.871
R2422 net@1211#7pmos@68_poly-left##9 net@1211#7pmos@68_poly-left##10 9.871
R2423 net@1211#7pmos@68_poly-left##10 net@1211#7pmos@68_poly-left##11 9.871
R2424 net@1211#7pmos@68_poly-left##11 net@1211#7pmos@68_poly-left##12 9.871
R2425 net@1211#7pmos@68_poly-left##12 net@1211#7pmos@68_poly-left##13 9.871
R2426 net@1211#7pmos@68_poly-left##13 net@1211#7pmos@68_poly-left##14 9.871
R2427 net@1211#7pmos@68_poly-left##14 net@1211#7pmos@68_poly-left##15 9.871
R2428 net@1211#7pmos@68_poly-left##15 net@1211#7pmos@68_poly-left##16 9.871
R2429 net@1211#7pmos@68_poly-left##16 net@1211#7pmos@68_poly-left##17 9.871
R2430 net@1211#7pmos@68_poly-left##17 net@1211#7pmos@68_poly-left##18 9.871
R2431 net@1211#7pmos@68_poly-left##18 net@1211#7pmos@68_poly-left##19 9.871
R2432 net@1211#7pmos@68_poly-left##19 net@1211#7pmos@68_poly-left##20 9.871
R2433 net@1211#7pmos@68_poly-left##20 net@1211#7pmos@68_poly-left##21 9.871
R2434 net@1211#7pmos@68_poly-left##21 net@1211#7pmos@68_poly-left##22 9.871
R2435 net@1211#7pmos@68_poly-left##22 net@1211#7pmos@68_poly-left##23 9.871
R2436 net@1211#7pmos@68_poly-left##23 net@1211#7pmos@68_poly-left##24 9.871
R2437 net@1211#7pmos@68_poly-left##24 net@1211#7pmos@68_poly-left##25 9.871
R2438 net@1211#7pmos@68_poly-left##25 net@1211#7pmos@68_poly-left##26 9.871
R2439 net@1211#7pmos@68_poly-left##26 net@1211#7pmos@68_poly-left##27 9.871
R2440 net@1211#7pmos@68_poly-left##27 net@1211#7pmos@68_poly-left##28 9.871
R2441 net@1211#7pmos@68_poly-left##28 net@1211#7pmos@68_poly-left##29 9.871
R2442 net@1211#7pmos@68_poly-left##29 net@1211#7pmos@68_poly-left##30 9.871
R2443 net@1211#7pmos@68_poly-left##30 net@1211#7pmos@68_poly-left##31 9.871
R2444 net@1211#7pmos@68_poly-left##31 net@1211#7pmos@68_poly-left##32 9.871
R2445 net@1211#7pmos@68_poly-left##32 net@1211#7pmos@68_poly-left##33 9.871
R2446 net@1211#7pmos@68_poly-left##33 net@1211#7pmos@68_poly-left##34 9.871
R2447 net@1211#7pmos@68_poly-left##34 net@1211#7pmos@68_poly-left##35 9.871
R2448 net@1211#7pmos@68_poly-left##35 net@1211#7pmos@68_poly-left##36 9.871
R2449 net@1211#7pmos@68_poly-left##36 net@1211#7pmos@68_poly-left##37 9.871
R2450 net@1211#7pmos@68_poly-left##37 net@1211#7pmos@68_poly-left##38 9.871
R2451 net@1211#7pmos@68_poly-left##38 net@1211#7pmos@68_poly-left##39 9.871
R2452 net@1211#7pmos@68_poly-left##39 net@1211#7pmos@68_poly-left##40 9.871
R2453 net@1211#7pmos@68_poly-left##40 net@1211#7pmos@68_poly-left##41 9.871
R2454 net@1211#7pmos@68_poly-left##41 net@1211#7pmos@68_poly-left##42 9.871
R2455 net@1211#7pmos@68_poly-left##42 net@1211#7pmos@68_poly-left##43 9.871
R2456 net@1211#7pmos@68_poly-left##43 net@1211#7pmos@68_poly-left##44 9.871
R2457 net@1211#7pmos@68_poly-left##44 net@1211#7pmos@68_poly-left##45 9.871
R2458 net@1211#7pmos@68_poly-left##45 net@1211#7pmos@68_poly-left##46 9.871
R2459 net@1211#7pmos@68_poly-left##46 net@1211#7pmos@68_poly-left##47 9.871
R2460 net@1211#7pmos@68_poly-left##47 net@1211#7pmos@68_poly-left##48 9.871
R2461 net@1211#7pmos@68_poly-left##48 net@1211#7pmos@68_poly-left##49 9.871
R2462 net@1211#7pmos@68_poly-left##49 net@1211#7pmos@68_poly-left##50 9.871
R2463 net@1211#7pmos@68_poly-left##50 net@1211#7pmos@68_poly-left##51 9.871
R2464 net@1211#7pmos@68_poly-left##51 net@1211#7pmos@68_poly-left##52 9.871
R2465 net@1211#7pmos@68_poly-left##52 net@1211#7pmos@68_poly-left##53 9.871
R2466 net@1211#7pmos@68_poly-left##53 net@1211#7pmos@68_poly-left##54 9.871
R2467 net@1211#7pmos@68_poly-left##54 net@1211#7pmos@68_poly-left##55 9.871
R2468 net@1211#7pmos@68_poly-left##55 net@1211#11nmos@68_poly-right 9.871
R2469 Cin_to_XOR2___NAND2#27pmos@69_poly-right Cin_to_XOR2___NAND2#27pmos@69_poly-right##0 9.871
R2470 Cin_to_XOR2___NAND2#27pmos@69_poly-right##0 Cin_to_XOR2___NAND2#27pmos@69_poly-right##1 9.871
R2471 Cin_to_XOR2___NAND2#27pmos@69_poly-right##1 Cin_to_XOR2___NAND2#27pmos@69_poly-right##2 9.871
R2472 Cin_to_XOR2___NAND2#27pmos@69_poly-right##2 Cin_to_XOR2___NAND2#27pmos@69_poly-right##3 9.871
R2473 Cin_to_XOR2___NAND2#27pmos@69_poly-right##3 Cin_to_XOR2___NAND2#27pmos@69_poly-right##4 9.871
R2474 Cin_to_XOR2___NAND2#27pmos@69_poly-right##4 Cin_to_XOR2___NAND2#27pmos@69_poly-right##5 9.871
R2475 Cin_to_XOR2___NAND2#27pmos@69_poly-right##5 Cin_to_XOR2___NAND2#27pmos@69_poly-right##6 9.871
R2476 Cin_to_XOR2___NAND2#27pmos@69_poly-right##6 Cin_to_XOR2___NAND2#27pmos@69_poly-right##7 9.871
R2477 Cin_to_XOR2___NAND2#27pmos@69_poly-right##7 Cin_to_XOR2___NAND2#27pmos@69_poly-right##8 9.871
R2478 Cin_to_XOR2___NAND2#27pmos@69_poly-right##8 Cin_to_XOR2___NAND2#27pmos@69_poly-right##9 9.871
R2479 Cin_to_XOR2___NAND2#27pmos@69_poly-right##9 Cin_to_XOR2___NAND2#27pmos@69_poly-right##10 9.871
R2480 Cin_to_XOR2___NAND2#27pmos@69_poly-right##10 Cin_to_XOR2___NAND2#27pmos@69_poly-right##11 9.871
R2481 Cin_to_XOR2___NAND2#27pmos@69_poly-right##11 Cin_to_XOR2___NAND2#27pmos@69_poly-right##12 9.871
R2482 Cin_to_XOR2___NAND2#27pmos@69_poly-right##12 Cin_to_XOR2___NAND2#27pmos@69_poly-right##13 9.871
R2483 Cin_to_XOR2___NAND2#27pmos@69_poly-right##13 Cin_to_XOR2___NAND2#27pmos@69_poly-right##14 9.871
R2484 Cin_to_XOR2___NAND2#27pmos@69_poly-right##14 Cin_to_XOR2___NAND2#27pmos@69_poly-right##15 9.871
R2485 Cin_to_XOR2___NAND2#27pmos@69_poly-right##15 Cin_to_XOR2___NAND2#27pmos@69_poly-right##16 9.871
R2486 Cin_to_XOR2___NAND2#27pmos@69_poly-right##16 Cin_to_XOR2___NAND2#27pmos@69_poly-right##17 9.871
R2487 Cin_to_XOR2___NAND2#27pmos@69_poly-right##17 Cin_to_XOR2___NAND2#27pmos@69_poly-right##18 9.871
R2488 Cin_to_XOR2___NAND2#27pmos@69_poly-right##18 Cin_to_XOR2___NAND2#27pmos@69_poly-right##19 9.871
R2489 Cin_to_XOR2___NAND2#27pmos@69_poly-right##19 Cin_to_XOR2___NAND2#27pmos@69_poly-right##20 9.871
R2490 Cin_to_XOR2___NAND2#27pmos@69_poly-right##20 Cin_to_XOR2___NAND2#27pmos@69_poly-right##21 9.871
R2491 Cin_to_XOR2___NAND2#27pmos@69_poly-right##21 Cin_to_XOR2___NAND2#27pmos@69_poly-right##22 9.871
R2492 Cin_to_XOR2___NAND2#27pmos@69_poly-right##22 Cin_to_XOR2___NAND2#27pmos@69_poly-right##23 9.871
R2493 Cin_to_XOR2___NAND2#27pmos@69_poly-right##23 Cin_to_XOR2___NAND2#27pmos@69_poly-right##24 9.871
R2494 Cin_to_XOR2___NAND2#27pmos@69_poly-right##24 Cin_to_XOR2___NAND2#27pmos@69_poly-right##25 9.871
R2495 Cin_to_XOR2___NAND2#27pmos@69_poly-right##25 Cin_to_XOR2___NAND2#27pmos@69_poly-right##26 9.871
R2496 Cin_to_XOR2___NAND2#27pmos@69_poly-right##26 Cin_to_XOR2___NAND2#27pmos@69_poly-right##27 9.871
R2497 Cin_to_XOR2___NAND2#27pmos@69_poly-right##27 Cin_to_XOR2___NAND2#27pmos@69_poly-right##28 9.871
R2498 Cin_to_XOR2___NAND2#27pmos@69_poly-right##28 Cin_to_XOR2___NAND2#27pmos@69_poly-right##29 9.871
R2499 Cin_to_XOR2___NAND2#27pmos@69_poly-right##29 Cin_to_XOR2___NAND2#27pmos@69_poly-right##30 9.871
R2500 Cin_to_XOR2___NAND2#27pmos@69_poly-right##30 Cin_to_XOR2___NAND2#27pmos@69_poly-right##31 9.871
R2501 Cin_to_XOR2___NAND2#27pmos@69_poly-right##31 Cin_to_XOR2___NAND2#27pmos@69_poly-right##32 9.871
R2502 Cin_to_XOR2___NAND2#27pmos@69_poly-right##32 Cin_to_XOR2___NAND2#27pmos@69_poly-right##33 9.871
R2503 Cin_to_XOR2___NAND2#27pmos@69_poly-right##33 Cin_to_XOR2___NAND2#27pmos@69_poly-right##34 9.871
R2504 Cin_to_XOR2___NAND2#27pmos@69_poly-right##34 Cin_to_XOR2___NAND2#27pmos@69_poly-right##35 9.871
R2505 Cin_to_XOR2___NAND2#27pmos@69_poly-right##35 Cin_to_XOR2___NAND2#27pmos@69_poly-right##36 9.871
R2506 Cin_to_XOR2___NAND2#27pmos@69_poly-right##36 Cin_to_XOR2___NAND2#27pmos@69_poly-right##37 9.871
R2507 Cin_to_XOR2___NAND2#27pmos@69_poly-right##37 Cin_to_XOR2___NAND2#27pmos@69_poly-right##38 9.871
R2508 Cin_to_XOR2___NAND2#27pmos@69_poly-right##38 Cin_to_XOR2___NAND2#27pmos@69_poly-right##39 9.871
R2509 Cin_to_XOR2___NAND2#27pmos@69_poly-right##39 Cin_to_XOR2___NAND2#27pmos@69_poly-right##40 9.871
R2510 Cin_to_XOR2___NAND2#27pmos@69_poly-right##40 Cin_to_XOR2___NAND2#27pmos@69_poly-right##41 9.871
R2511 Cin_to_XOR2___NAND2#27pmos@69_poly-right##41 Cin_to_XOR2___NAND2#27pmos@69_poly-right##42 9.871
R2512 Cin_to_XOR2___NAND2#27pmos@69_poly-right##42 Cin_to_XOR2___NAND2#27pmos@69_poly-right##43 9.871
R2513 Cin_to_XOR2___NAND2#27pmos@69_poly-right##43 Cin_to_XOR2___NAND2#27pmos@69_poly-right##44 9.871
R2514 Cin_to_XOR2___NAND2#27pmos@69_poly-right##44 Cin_to_XOR2___NAND2#27pmos@69_poly-right##45 9.871
R2515 Cin_to_XOR2___NAND2#27pmos@69_poly-right##45 Cin_to_XOR2___NAND2#27pmos@69_poly-right##46 9.871
R2516 Cin_to_XOR2___NAND2#27pmos@69_poly-right##46 Cin_to_XOR2___NAND2#27pmos@69_poly-right##47 9.871
R2517 Cin_to_XOR2___NAND2#27pmos@69_poly-right##47 Cin_to_XOR2___NAND2#27pmos@69_poly-right##48 9.871
R2518 Cin_to_XOR2___NAND2#27pmos@69_poly-right##48 Cin_to_XOR2___NAND2#27pmos@69_poly-right##49 9.871
R2519 Cin_to_XOR2___NAND2#27pmos@69_poly-right##49 Cin_to_XOR2___NAND2#27pmos@69_poly-right##50 9.871
R2520 Cin_to_XOR2___NAND2#27pmos@69_poly-right##50 Cin_to_XOR2___NAND2#27pmos@69_poly-right##51 9.871
R2521 Cin_to_XOR2___NAND2#27pmos@69_poly-right##51 Cin_to_XOR2___NAND2#27pmos@69_poly-right##52 9.871
R2522 Cin_to_XOR2___NAND2#27pmos@69_poly-right##52 Cin_to_XOR2___NAND2#27pmos@69_poly-right##53 9.871
R2523 Cin_to_XOR2___NAND2#27pmos@69_poly-right##53 Cin_to_XOR2___NAND2#27pmos@69_poly-right##54 9.871
R2524 Cin_to_XOR2___NAND2#27pmos@69_poly-right##54 Cin_to_XOR2___NAND2#27pmos@69_poly-right##55 9.871
R2525 Cin_to_XOR2___NAND2#27pmos@69_poly-right##55 Cin_to_XOR2___NAND2#18nmos@69_poly-left 9.871
R2526 net@1221#14pmos@70_poly-right net@1221#14pmos@70_poly-right##0 9.871
R2527 net@1221#14pmos@70_poly-right##0 net@1221#14pmos@70_poly-right##1 9.871
R2528 net@1221#14pmos@70_poly-right##1 net@1221#14pmos@70_poly-right##2 9.871
R2529 net@1221#14pmos@70_poly-right##2 net@1221#14pmos@70_poly-right##3 9.871
R2530 net@1221#14pmos@70_poly-right##3 net@1221#14pmos@70_poly-right##4 9.871
R2531 net@1221#14pmos@70_poly-right##4 net@1221#14pmos@70_poly-right##5 9.871
R2532 net@1221#14pmos@70_poly-right##5 net@1221#14pmos@70_poly-right##6 9.871
R2533 net@1221#14pmos@70_poly-right##6 net@1221#14pmos@70_poly-right##7 9.871
R2534 net@1221#14pmos@70_poly-right##7 net@1221#14pmos@70_poly-right##8 9.871
R2535 net@1221#14pmos@70_poly-right##8 net@1221#14pmos@70_poly-right##9 9.871
R2536 net@1221#14pmos@70_poly-right##9 net@1221#14pmos@70_poly-right##10 9.871
R2537 net@1221#14pmos@70_poly-right##10 net@1221#14pmos@70_poly-right##11 9.871
R2538 net@1221#14pmos@70_poly-right##11 net@1221#14pmos@70_poly-right##12 9.871
R2539 net@1221#14pmos@70_poly-right##12 net@1221#14pmos@70_poly-right##13 9.871
R2540 net@1221#14pmos@70_poly-right##13 net@1221#14pmos@70_poly-right##14 9.871
R2541 net@1221#14pmos@70_poly-right##14 net@1221#14pmos@70_poly-right##15 9.871
R2542 net@1221#14pmos@70_poly-right##15 net@1221#14pmos@70_poly-right##16 9.871
R2543 net@1221#14pmos@70_poly-right##16 net@1221#14pmos@70_poly-right##17 9.871
R2544 net@1221#14pmos@70_poly-right##17 net@1221#14pmos@70_poly-right##18 9.871
R2545 net@1221#14pmos@70_poly-right##18 net@1221#14pmos@70_poly-right##19 9.871
R2546 net@1221#14pmos@70_poly-right##19 net@1221#14pmos@70_poly-right##20 9.871
R2547 net@1221#14pmos@70_poly-right##20 net@1221#14pmos@70_poly-right##21 9.871
R2548 net@1221#14pmos@70_poly-right##21 net@1221#14pmos@70_poly-right##22 9.871
R2549 net@1221#14pmos@70_poly-right##22 net@1221#14pmos@70_poly-right##23 9.871
R2550 net@1221#14pmos@70_poly-right##23 net@1221#14pmos@70_poly-right##24 9.871
R2551 net@1221#14pmos@70_poly-right##24 net@1221#14pmos@70_poly-right##25 9.871
R2552 net@1221#14pmos@70_poly-right##25 net@1221#14pmos@70_poly-right##26 9.871
R2553 net@1221#14pmos@70_poly-right##26 net@1221#14pmos@70_poly-right##27 9.871
R2554 net@1221#14pmos@70_poly-right##27 net@1221#14pmos@70_poly-right##28 9.871
R2555 net@1221#14pmos@70_poly-right##28 net@1221#14pmos@70_poly-right##29 9.871
R2556 net@1221#14pmos@70_poly-right##29 net@1221#14pmos@70_poly-right##30 9.871
R2557 net@1221#14pmos@70_poly-right##30 net@1221#14pmos@70_poly-right##31 9.871
R2558 net@1221#14pmos@70_poly-right##31 net@1221#14pmos@70_poly-right##32 9.871
R2559 net@1221#14pmos@70_poly-right##32 net@1221#14pmos@70_poly-right##33 9.871
R2560 net@1221#14pmos@70_poly-right##33 net@1221#14pmos@70_poly-right##34 9.871
R2561 net@1221#14pmos@70_poly-right##34 net@1221#14pmos@70_poly-right##35 9.871
R2562 net@1221#14pmos@70_poly-right##35 net@1221#14pmos@70_poly-right##36 9.871
R2563 net@1221#14pmos@70_poly-right##36 net@1221#14pmos@70_poly-right##37 9.871
R2564 net@1221#14pmos@70_poly-right##37 net@1221#14pmos@70_poly-right##38 9.871
R2565 net@1221#14pmos@70_poly-right##38 net@1221#14pmos@70_poly-right##39 9.871
R2566 net@1221#14pmos@70_poly-right##39 net@1221#14pmos@70_poly-right##40 9.871
R2567 net@1221#14pmos@70_poly-right##40 net@1221#14pmos@70_poly-right##41 9.871
R2568 net@1221#14pmos@70_poly-right##41 net@1221#14pmos@70_poly-right##42 9.871
R2569 net@1221#14pmos@70_poly-right##42 net@1221#14pmos@70_poly-right##43 9.871
R2570 net@1221#14pmos@70_poly-right##43 net@1221#14pmos@70_poly-right##44 9.871
R2571 net@1221#14pmos@70_poly-right##44 net@1221#14pmos@70_poly-right##45 9.871
R2572 net@1221#14pmos@70_poly-right##45 net@1221#14pmos@70_poly-right##46 9.871
R2573 net@1221#14pmos@70_poly-right##46 net@1221#14pmos@70_poly-right##47 9.871
R2574 net@1221#14pmos@70_poly-right##47 net@1221#14pmos@70_poly-right##48 9.871
R2575 net@1221#14pmos@70_poly-right##48 net@1221#14pmos@70_poly-right##49 9.871
R2576 net@1221#14pmos@70_poly-right##49 net@1221#14pmos@70_poly-right##50 9.871
R2577 net@1221#14pmos@70_poly-right##50 net@1221#14pmos@70_poly-right##51 9.871
R2578 net@1221#14pmos@70_poly-right##51 net@1221#14pmos@70_poly-right##52 9.871
R2579 net@1221#14pmos@70_poly-right##52 net@1221#14pmos@70_poly-right##53 9.871
R2580 net@1221#14pmos@70_poly-right##53 net@1221#14pmos@70_poly-right##54 9.871
R2581 net@1221#14pmos@70_poly-right##54 net@1221#14pmos@70_poly-right##55 9.871
R2582 net@1221#14pmos@70_poly-right##55 net@1221#9nmos@70_poly-left 9.871
R2583 net@1220#2contact@530_metal-1-polysilicon-1 net@1220 4.654
R2584 net@1220#12pmos@73_poly-right net@1220#12pmos@73_poly-right##0 9.931
R2585 net@1220#12pmos@73_poly-right##0 net@1220#12pmos@73_poly-right##1 9.931
R2586 net@1220#12pmos@73_poly-right##1 net@1220#12pmos@73_poly-right##2 9.931
R2587 net@1220#12pmos@73_poly-right##2 net@1220#12pmos@73_poly-right##3 9.931
R2588 net@1220#12pmos@73_poly-right##3 net@1220#12pmos@73_poly-right##4 9.931
R2589 net@1220#12pmos@73_poly-right##4 net@1220#12pmos@73_poly-right##5 9.931
R2590 net@1220#12pmos@73_poly-right##5 net@1220#12pmos@73_poly-right##6 9.931
R2591 net@1220#12pmos@73_poly-right##6 net@1220#12pmos@73_poly-right##7 9.931
R2592 net@1220#12pmos@73_poly-right##7 net@1220#12pmos@73_poly-right##8 9.931
R2593 net@1220#12pmos@73_poly-right##8 net@1220#12pmos@73_poly-right##9 9.931
R2594 net@1220#12pmos@73_poly-right##9 net@1220#12pmos@73_poly-right##10 9.931
R2595 net@1220#12pmos@73_poly-right##10 net@1220#12pmos@73_poly-right##11 9.931
R2596 net@1220#12pmos@73_poly-right##11 net@1220#12pmos@73_poly-right##12 9.931
R2597 net@1220#12pmos@73_poly-right##12 net@1220#12pmos@73_poly-right##13 9.931
R2598 net@1220#12pmos@73_poly-right##13 net@1220#12pmos@73_poly-right##14 9.931
R2599 net@1220#12pmos@73_poly-right##14 net@1220#12pmos@73_poly-right##15 9.931
R2600 net@1220#12pmos@73_poly-right##15 net@1220#12pmos@73_poly-right##16 9.931
R2601 net@1220#12pmos@73_poly-right##16 net@1220#12pmos@73_poly-right##17 9.931
R2602 net@1220#12pmos@73_poly-right##17 net@1220#12pmos@73_poly-right##18 9.931
R2603 net@1220#12pmos@73_poly-right##18 net@1220#12pmos@73_poly-right##19 9.931
R2604 net@1220#12pmos@73_poly-right##19 net@1220#12pmos@73_poly-right##20 9.931
R2605 net@1220#12pmos@73_poly-right##20 net@1220#12pmos@73_poly-right##21 9.931
R2606 net@1220#12pmos@73_poly-right##21 net@1220#12pmos@73_poly-right##22 9.931
R2607 net@1220#12pmos@73_poly-right##22 net@1220#12pmos@73_poly-right##23 9.931
R2608 net@1220#12pmos@73_poly-right##23 net@1220#12pmos@73_poly-right##24 9.931
R2609 net@1220#12pmos@73_poly-right##24 net@1220#12pmos@73_poly-right##25 9.931
R2610 net@1220#12pmos@73_poly-right##25 net@1220#12pmos@73_poly-right##26 9.931
R2611 net@1220#12pmos@73_poly-right##26 net@1220#12pmos@73_poly-right##27 9.931
R2612 net@1220#12pmos@73_poly-right##27 net@1220#12pmos@73_poly-right##28 9.931
R2613 net@1220#12pmos@73_poly-right##28 net@1220#12pmos@73_poly-right##29 9.931
R2614 net@1220#12pmos@73_poly-right##29 net@1220#12pmos@73_poly-right##30 9.931
R2615 net@1220#12pmos@73_poly-right##30 net@1220#12pmos@73_poly-right##31 9.931
R2616 net@1220#12pmos@73_poly-right##31 net@1220#12pmos@73_poly-right##32 9.931
R2617 net@1220#12pmos@73_poly-right##32 net@1220#12pmos@73_poly-right##33 9.931
R2618 net@1220#12pmos@73_poly-right##33 net@1220#12pmos@73_poly-right##34 9.931
R2619 net@1220#12pmos@73_poly-right##34 net@1220#12pmos@73_poly-right##35 9.931
R2620 net@1220#12pmos@73_poly-right##35 net@1220#12pmos@73_poly-right##36 9.931
R2621 net@1220#12pmos@73_poly-right##36 net@1220#12pmos@73_poly-right##37 9.931
R2622 net@1220#12pmos@73_poly-right##37 net@1220#12pmos@73_poly-right##38 9.931
R2623 net@1220#12pmos@73_poly-right##38 net@1220#12pmos@73_poly-right##39 9.931
R2624 net@1220#12pmos@73_poly-right##39 net@1220#12pmos@73_poly-right##40 9.931
R2625 net@1220#12pmos@73_poly-right##40 net@1220#12pmos@73_poly-right##41 9.931
R2626 net@1220#12pmos@73_poly-right##41 net@1220#12pmos@73_poly-right##42 9.931
R2627 net@1220#12pmos@73_poly-right##42 net@1220#12pmos@73_poly-right##43 9.931
R2628 net@1220#12pmos@73_poly-right##43 net@1220#12pmos@73_poly-right##44 9.931
R2629 net@1220#12pmos@73_poly-right##44 net@1220#12pmos@73_poly-right##45 9.931
R2630 net@1220#12pmos@73_poly-right##45 net@1220#12pmos@73_poly-right##46 9.931
R2631 net@1220#12pmos@73_poly-right##46 net@1220#12pmos@73_poly-right##47 9.931
R2632 net@1220#12pmos@73_poly-right##47 net@1220#12pmos@73_poly-right##48 9.931
R2633 net@1220#12pmos@73_poly-right##48 net@1220#12pmos@73_poly-right##49 9.931
R2634 net@1220#12pmos@73_poly-right##49 net@1220#12pmos@73_poly-right##50 9.931
R2635 net@1220#12pmos@73_poly-right##50 net@1220#12pmos@73_poly-right##51 9.931
R2636 net@1220#12pmos@73_poly-right##51 net@1220#12pmos@73_poly-right##52 9.931
R2637 net@1220#12pmos@73_poly-right##52 net@1220#5pin@370_polysilicon-1 9.931
R2638 Sum1#4pmos@73_diff-top Sum1 4.823
R2639 XOR1_to_NAND2#14pin@382_polysilicon-1 XOR1_to_NAND2#14pin@382_polysilicon-1##0 9.854
R2640 XOR1_to_NAND2#14pin@382_polysilicon-1##0 XOR1_to_NAND2#14pin@382_polysilicon-1##1 9.854
R2641 XOR1_to_NAND2#14pin@382_polysilicon-1##1 XOR1_to_NAND2#14pin@382_polysilicon-1##2 9.854
R2642 XOR1_to_NAND2#14pin@382_polysilicon-1##2 XOR1_to_NAND2#14pin@382_polysilicon-1##3 9.854
R2643 XOR1_to_NAND2#14pin@382_polysilicon-1##3 XOR1_to_NAND2#14pin@382_polysilicon-1##4 9.854
R2644 XOR1_to_NAND2#14pin@382_polysilicon-1##4 XOR1_to_NAND2#14pin@382_polysilicon-1##5 9.854
R2645 XOR1_to_NAND2#14pin@382_polysilicon-1##5 XOR1_to_NAND2#14pin@382_polysilicon-1##6 9.854
R2646 XOR1_to_NAND2#14pin@382_polysilicon-1##6 XOR1_to_NAND2#14pin@382_polysilicon-1##7 9.854
R2647 XOR1_to_NAND2#14pin@382_polysilicon-1##7 XOR1_to_NAND2#14pin@382_polysilicon-1##8 9.854
R2648 XOR1_to_NAND2#14pin@382_polysilicon-1##8 XOR1_to_NAND2#14pin@382_polysilicon-1##9 9.854
R2649 XOR1_to_NAND2#14pin@382_polysilicon-1##9 XOR1_to_NAND2#14pin@382_polysilicon-1##10 9.854
R2650 XOR1_to_NAND2#14pin@382_polysilicon-1##10 XOR1_to_NAND2#14pin@382_polysilicon-1##11 9.854
R2651 XOR1_to_NAND2#14pin@382_polysilicon-1##11 XOR1_to_NAND2#14pin@382_polysilicon-1##12 9.854
R2652 XOR1_to_NAND2#14pin@382_polysilicon-1##12 XOR1_to_NAND2#14pin@382_polysilicon-1##13 9.854
R2653 XOR1_to_NAND2#14pin@382_polysilicon-1##13 XOR1_to_NAND2#14pin@382_polysilicon-1##14 9.854
R2654 XOR1_to_NAND2#14pin@382_polysilicon-1##14 XOR1_to_NAND2#14pin@382_polysilicon-1##15 9.854
R2655 XOR1_to_NAND2#14pin@382_polysilicon-1##15 XOR1_to_NAND2#14pin@382_polysilicon-1##16 9.854
R2656 XOR1_to_NAND2#14pin@382_polysilicon-1##16 XOR1_to_NAND2#14pin@382_polysilicon-1##17 9.854
R2657 XOR1_to_NAND2#14pin@382_polysilicon-1##17 XOR1_to_NAND2#14pin@382_polysilicon-1##18 9.854
R2658 XOR1_to_NAND2#14pin@382_polysilicon-1##18 XOR1_to_NAND2#14pin@382_polysilicon-1##19 9.854
R2659 XOR1_to_NAND2#14pin@382_polysilicon-1##19 XOR1_to_NAND2#14pin@382_polysilicon-1##20 9.854
R2660 XOR1_to_NAND2#14pin@382_polysilicon-1##20 XOR1_to_NAND2#14pin@382_polysilicon-1##21 9.854
R2661 XOR1_to_NAND2#14pin@382_polysilicon-1##21 XOR1_to_NAND2#14pin@382_polysilicon-1##22 9.854
R2662 XOR1_to_NAND2#14pin@382_polysilicon-1##22 XOR1_to_NAND2#14pin@382_polysilicon-1##23 9.854
R2663 XOR1_to_NAND2#14pin@382_polysilicon-1##23 XOR1_to_NAND2#14pin@382_polysilicon-1##24 9.854
R2664 XOR1_to_NAND2#14pin@382_polysilicon-1##24 XOR1_to_NAND2#14pin@382_polysilicon-1##25 9.854
R2665 XOR1_to_NAND2#14pin@382_polysilicon-1##25 XOR1_to_NAND2#14pin@382_polysilicon-1##26 9.854
R2666 XOR1_to_NAND2#14pin@382_polysilicon-1##26 XOR1_to_NAND2#14pin@382_polysilicon-1##27 9.854
R2667 XOR1_to_NAND2#14pin@382_polysilicon-1##27 XOR1_to_NAND2#14pin@382_polysilicon-1##28 9.854
R2668 XOR1_to_NAND2#14pin@382_polysilicon-1##28 XOR1_to_NAND2#14pin@382_polysilicon-1##29 9.854
R2669 XOR1_to_NAND2#14pin@382_polysilicon-1##29 XOR1_to_NAND2#14pin@382_polysilicon-1##30 9.854
R2670 XOR1_to_NAND2#14pin@382_polysilicon-1##30 XOR1_to_NAND2#14pin@382_polysilicon-1##31 9.854
R2671 XOR1_to_NAND2#14pin@382_polysilicon-1##31 XOR1_to_NAND2#14pin@382_polysilicon-1##32 9.854
R2672 XOR1_to_NAND2#14pin@382_polysilicon-1##32 XOR1_to_NAND2#14pin@382_polysilicon-1##33 9.854
R2673 XOR1_to_NAND2#14pin@382_polysilicon-1##33 XOR1_to_NAND2#14pin@382_polysilicon-1##34 9.854
R2674 XOR1_to_NAND2#14pin@382_polysilicon-1##34 XOR1_to_NAND2#14pin@382_polysilicon-1##35 9.854
R2675 XOR1_to_NAND2#14pin@382_polysilicon-1##35 XOR1_to_NAND2#14pin@382_polysilicon-1##36 9.854
R2676 XOR1_to_NAND2#14pin@382_polysilicon-1##36 XOR1_to_NAND2#14pin@382_polysilicon-1##37 9.854
R2677 XOR1_to_NAND2#14pin@382_polysilicon-1##37 XOR1_to_NAND2#14pin@382_polysilicon-1##38 9.854
R2678 XOR1_to_NAND2#14pin@382_polysilicon-1##38 XOR1_to_NAND2#14pin@382_polysilicon-1##39 9.854
R2679 XOR1_to_NAND2#14pin@382_polysilicon-1##39 XOR1_to_NAND2#14pin@382_polysilicon-1##40 9.854
R2680 XOR1_to_NAND2#14pin@382_polysilicon-1##40 XOR1_to_NAND2#14pin@382_polysilicon-1##41 9.854
R2681 XOR1_to_NAND2#14pin@382_polysilicon-1##41 XOR1_to_NAND2#14pin@382_polysilicon-1##42 9.854
R2682 XOR1_to_NAND2#14pin@382_polysilicon-1##42 XOR1_to_NAND2#14pin@382_polysilicon-1##43 9.854
R2683 XOR1_to_NAND2#14pin@382_polysilicon-1##43 XOR1_to_NAND2#14pin@382_polysilicon-1##44 9.854
R2684 XOR1_to_NAND2#14pin@382_polysilicon-1##44 XOR1_to_NAND2#14pin@382_polysilicon-1##45 9.854
R2685 XOR1_to_NAND2#14pin@382_polysilicon-1##45 XOR1_to_NAND2#14pin@382_polysilicon-1##46 9.854
R2686 XOR1_to_NAND2#14pin@382_polysilicon-1##46 XOR1_to_NAND2#14pin@382_polysilicon-1##47 9.854
R2687 XOR1_to_NAND2#14pin@382_polysilicon-1##47 XOR1_to_NAND2#14pin@382_polysilicon-1##48 9.854
R2688 XOR1_to_NAND2#14pin@382_polysilicon-1##48 XOR1_to_NAND2#14pin@382_polysilicon-1##49 9.854
R2689 XOR1_to_NAND2#14pin@382_polysilicon-1##49 XOR1_to_NAND2#14pin@382_polysilicon-1##50 9.854
R2690 XOR1_to_NAND2#14pin@382_polysilicon-1##50 XOR1_to_NAND2#14pin@382_polysilicon-1##51 9.854
R2691 XOR1_to_NAND2#14pin@382_polysilicon-1##51 XOR1_to_NAND2#14pin@382_polysilicon-1##52 9.854
R2692 XOR1_to_NAND2#14pin@382_polysilicon-1##52 XOR1_to_NAND2#14pin@382_polysilicon-1##53 9.854
R2693 XOR1_to_NAND2#14pin@382_polysilicon-1##53 XOR1_to_NAND2#14pin@382_polysilicon-1##54 9.854
R2694 XOR1_to_NAND2#14pin@382_polysilicon-1##54 XOR1_to_NAND2#27nmos@74_poly-right 9.854
R2695 Cin_to_XOR2___NAND2#29pmos@75_poly-right Cin_to_XOR2___NAND2#29pmos@75_poly-right##0 9.877
R2696 Cin_to_XOR2___NAND2#29pmos@75_poly-right##0 Cin_to_XOR2___NAND2#29pmos@75_poly-right##1 9.877
R2697 Cin_to_XOR2___NAND2#29pmos@75_poly-right##1 Cin_to_XOR2___NAND2#29pmos@75_poly-right##2 9.877
R2698 Cin_to_XOR2___NAND2#29pmos@75_poly-right##2 Cin_to_XOR2___NAND2#29pmos@75_poly-right##3 9.877
R2699 Cin_to_XOR2___NAND2#29pmos@75_poly-right##3 Cin_to_XOR2___NAND2#29pmos@75_poly-right##4 9.877
R2700 Cin_to_XOR2___NAND2#29pmos@75_poly-right##4 Cin_to_XOR2___NAND2#29pmos@75_poly-right##5 9.877
R2701 Cin_to_XOR2___NAND2#29pmos@75_poly-right##5 Cin_to_XOR2___NAND2#29pmos@75_poly-right##6 9.877
R2702 Cin_to_XOR2___NAND2#29pmos@75_poly-right##6 Cin_to_XOR2___NAND2#29pmos@75_poly-right##7 9.877
R2703 Cin_to_XOR2___NAND2#29pmos@75_poly-right##7 Cin_to_XOR2___NAND2#29pmos@75_poly-right##8 9.877
R2704 Cin_to_XOR2___NAND2#29pmos@75_poly-right##8 Cin_to_XOR2___NAND2#29pmos@75_poly-right##9 9.877
R2705 Cin_to_XOR2___NAND2#29pmos@75_poly-right##9 Cin_to_XOR2___NAND2#29pmos@75_poly-right##10 9.877
R2706 Cin_to_XOR2___NAND2#29pmos@75_poly-right##10 Cin_to_XOR2___NAND2#29pmos@75_poly-right##11 9.877
R2707 Cin_to_XOR2___NAND2#29pmos@75_poly-right##11 Cin_to_XOR2___NAND2#29pmos@75_poly-right##12 9.877
R2708 Cin_to_XOR2___NAND2#29pmos@75_poly-right##12 Cin_to_XOR2___NAND2#29pmos@75_poly-right##13 9.877
R2709 Cin_to_XOR2___NAND2#29pmos@75_poly-right##13 Cin_to_XOR2___NAND2#29pmos@75_poly-right##14 9.877
R2710 Cin_to_XOR2___NAND2#29pmos@75_poly-right##14 Cin_to_XOR2___NAND2#29pmos@75_poly-right##15 9.877
R2711 Cin_to_XOR2___NAND2#29pmos@75_poly-right##15 Cin_to_XOR2___NAND2#29pmos@75_poly-right##16 9.877
R2712 Cin_to_XOR2___NAND2#29pmos@75_poly-right##16 Cin_to_XOR2___NAND2#29pmos@75_poly-right##17 9.877
R2713 Cin_to_XOR2___NAND2#29pmos@75_poly-right##17 Cin_to_XOR2___NAND2#29pmos@75_poly-right##18 9.877
R2714 Cin_to_XOR2___NAND2#29pmos@75_poly-right##18 Cin_to_XOR2___NAND2#29pmos@75_poly-right##19 9.877
R2715 Cin_to_XOR2___NAND2#29pmos@75_poly-right##19 Cin_to_XOR2___NAND2#29pmos@75_poly-right##20 9.877
R2716 Cin_to_XOR2___NAND2#29pmos@75_poly-right##20 Cin_to_XOR2___NAND2#29pmos@75_poly-right##21 9.877
R2717 Cin_to_XOR2___NAND2#29pmos@75_poly-right##21 Cin_to_XOR2___NAND2#29pmos@75_poly-right##22 9.877
R2718 Cin_to_XOR2___NAND2#29pmos@75_poly-right##22 Cin_to_XOR2___NAND2#29pmos@75_poly-right##23 9.877
R2719 Cin_to_XOR2___NAND2#29pmos@75_poly-right##23 Cin_to_XOR2___NAND2#29pmos@75_poly-right##24 9.877
R2720 Cin_to_XOR2___NAND2#29pmos@75_poly-right##24 Cin_to_XOR2___NAND2#29pmos@75_poly-right##25 9.877
R2721 Cin_to_XOR2___NAND2#29pmos@75_poly-right##25 Cin_to_XOR2___NAND2#29pmos@75_poly-right##26 9.877
R2722 Cin_to_XOR2___NAND2#29pmos@75_poly-right##26 Cin_to_XOR2___NAND2#29pmos@75_poly-right##27 9.877
R2723 Cin_to_XOR2___NAND2#29pmos@75_poly-right##27 Cin_to_XOR2___NAND2#29pmos@75_poly-right##28 9.877
R2724 Cin_to_XOR2___NAND2#29pmos@75_poly-right##28 Cin_to_XOR2___NAND2#29pmos@75_poly-right##29 9.877
R2725 Cin_to_XOR2___NAND2#29pmos@75_poly-right##29 Cin_to_XOR2___NAND2#29pmos@75_poly-right##30 9.877
R2726 Cin_to_XOR2___NAND2#29pmos@75_poly-right##30 Cin_to_XOR2___NAND2#29pmos@75_poly-right##31 9.877
R2727 Cin_to_XOR2___NAND2#29pmos@75_poly-right##31 Cin_to_XOR2___NAND2#29pmos@75_poly-right##32 9.877
R2728 Cin_to_XOR2___NAND2#29pmos@75_poly-right##32 Cin_to_XOR2___NAND2#29pmos@75_poly-right##33 9.877
R2729 Cin_to_XOR2___NAND2#29pmos@75_poly-right##33 Cin_to_XOR2___NAND2#29pmos@75_poly-right##34 9.877
R2730 Cin_to_XOR2___NAND2#29pmos@75_poly-right##34 Cin_to_XOR2___NAND2#29pmos@75_poly-right##35 9.877
R2731 Cin_to_XOR2___NAND2#29pmos@75_poly-right##35 Cin_to_XOR2___NAND2#29pmos@75_poly-right##36 9.877
R2732 Cin_to_XOR2___NAND2#29pmos@75_poly-right##36 Cin_to_XOR2___NAND2#29pmos@75_poly-right##37 9.877
R2733 Cin_to_XOR2___NAND2#29pmos@75_poly-right##37 Cin_to_XOR2___NAND2#29pmos@75_poly-right##38 9.877
R2734 Cin_to_XOR2___NAND2#29pmos@75_poly-right##38 Cin_to_XOR2___NAND2#29pmos@75_poly-right##39 9.877
R2735 Cin_to_XOR2___NAND2#29pmos@75_poly-right##39 Cin_to_XOR2___NAND2#29pmos@75_poly-right##40 9.877
R2736 Cin_to_XOR2___NAND2#29pmos@75_poly-right##40 Cin_to_XOR2___NAND2#29pmos@75_poly-right##41 9.877
R2737 Cin_to_XOR2___NAND2#29pmos@75_poly-right##41 Cin_to_XOR2___NAND2#29pmos@75_poly-right##42 9.877
R2738 Cin_to_XOR2___NAND2#29pmos@75_poly-right##42 Cin_to_XOR2___NAND2#29pmos@75_poly-right##43 9.877
R2739 Cin_to_XOR2___NAND2#29pmos@75_poly-right##43 Cin_to_XOR2___NAND2#29pmos@75_poly-right##44 9.877
R2740 Cin_to_XOR2___NAND2#29pmos@75_poly-right##44 Cin_to_XOR2___NAND2#29pmos@75_poly-right##45 9.877
R2741 Cin_to_XOR2___NAND2#29pmos@75_poly-right##45 Cin_to_XOR2___NAND2#29pmos@75_poly-right##46 9.877
R2742 Cin_to_XOR2___NAND2#29pmos@75_poly-right##46 Cin_to_XOR2___NAND2#29pmos@75_poly-right##47 9.877
R2743 Cin_to_XOR2___NAND2#29pmos@75_poly-right##47 Cin_to_XOR2___NAND2#29pmos@75_poly-right##48 9.877
R2744 Cin_to_XOR2___NAND2#29pmos@75_poly-right##48 Cin_to_XOR2___NAND2#29pmos@75_poly-right##49 9.877
R2745 Cin_to_XOR2___NAND2#29pmos@75_poly-right##49 Cin_to_XOR2___NAND2#23pin@386_polysilicon-1 9.877
R2746 NAND1_to_NAND4 NAND1_to_NAND4#4nmos@75_diff-bottom 4.823
R2747 A1#11pin@389_polysilicon-1 A1#11pin@389_polysilicon-1##0 9.938
R2748 A1#11pin@389_polysilicon-1##0 A1#11pin@389_polysilicon-1##1 9.938
R2749 A1#11pin@389_polysilicon-1##1 A1#11pin@389_polysilicon-1##2 9.938
R2750 A1#11pin@389_polysilicon-1##2 A1#11pin@389_polysilicon-1##3 9.938
R2751 A1#11pin@389_polysilicon-1##3 A1#11pin@389_polysilicon-1##4 9.938
R2752 A1#11pin@389_polysilicon-1##4 A1#11pin@389_polysilicon-1##5 9.938
R2753 A1#11pin@389_polysilicon-1##5 A1#11pin@389_polysilicon-1##6 9.938
R2754 A1#11pin@389_polysilicon-1##6 A1#11pin@389_polysilicon-1##7 9.938
R2755 A1#11pin@389_polysilicon-1##7 A1#11pin@389_polysilicon-1##8 9.938
R2756 A1#11pin@389_polysilicon-1##8 A1#11pin@389_polysilicon-1##9 9.938
R2757 A1#11pin@389_polysilicon-1##9 A1#11pin@389_polysilicon-1##10 9.938
R2758 A1#11pin@389_polysilicon-1##10 A1#11pin@389_polysilicon-1##11 9.938
R2759 A1#11pin@389_polysilicon-1##11 A1#11pin@389_polysilicon-1##12 9.938
R2760 A1#11pin@389_polysilicon-1##12 A1#11pin@389_polysilicon-1##13 9.938
R2761 A1#11pin@389_polysilicon-1##13 A1#11pin@389_polysilicon-1##14 9.938
R2762 A1#11pin@389_polysilicon-1##14 A1#11pin@389_polysilicon-1##15 9.938
R2763 A1#11pin@389_polysilicon-1##15 A1#11pin@389_polysilicon-1##16 9.938
R2764 A1#11pin@389_polysilicon-1##16 A1#11pin@389_polysilicon-1##17 9.938
R2765 A1#11pin@389_polysilicon-1##17 A1#11pin@389_polysilicon-1##18 9.938
R2766 A1#11pin@389_polysilicon-1##18 A1#11pin@389_polysilicon-1##19 9.938
R2767 A1#11pin@389_polysilicon-1##19 A1#11pin@389_polysilicon-1##20 9.938
R2768 A1#11pin@389_polysilicon-1##20 A1#11pin@389_polysilicon-1##21 9.938
R2769 A1#11pin@389_polysilicon-1##21 A1#11pin@389_polysilicon-1##22 9.938
R2770 A1#11pin@389_polysilicon-1##22 A1#11pin@389_polysilicon-1##23 9.938
R2771 A1#11pin@389_polysilicon-1##23 A1#11pin@389_polysilicon-1##24 9.938
R2772 A1#11pin@389_polysilicon-1##24 A1#11pin@389_polysilicon-1##25 9.938
R2773 A1#11pin@389_polysilicon-1##25 A1#11pin@389_polysilicon-1##26 9.938
R2774 A1#11pin@389_polysilicon-1##26 A1#11pin@389_polysilicon-1##27 9.938
R2775 A1#11pin@389_polysilicon-1##27 A1#11pin@389_polysilicon-1##28 9.938
R2776 A1#11pin@389_polysilicon-1##28 A1#11pin@389_polysilicon-1##29 9.938
R2777 A1#11pin@389_polysilicon-1##29 A1#11pin@389_polysilicon-1##30 9.938
R2778 A1#11pin@389_polysilicon-1##30 A1#11pin@389_polysilicon-1##31 9.938
R2779 A1#11pin@389_polysilicon-1##31 A1#11pin@389_polysilicon-1##32 9.938
R2780 A1#11pin@389_polysilicon-1##32 A1#11pin@389_polysilicon-1##33 9.938
R2781 A1#11pin@389_polysilicon-1##33 A1#11pin@389_polysilicon-1##34 9.938
R2782 A1#11pin@389_polysilicon-1##34 A1#11pin@389_polysilicon-1##35 9.938
R2783 A1#11pin@389_polysilicon-1##35 A1#11pin@389_polysilicon-1##36 9.938
R2784 A1#11pin@389_polysilicon-1##36 A1#11pin@389_polysilicon-1##37 9.938
R2785 A1#11pin@389_polysilicon-1##37 A1#11pin@389_polysilicon-1##38 9.938
R2786 A1#11pin@389_polysilicon-1##38 A1#11pin@389_polysilicon-1##39 9.938
R2787 A1#11pin@389_polysilicon-1##39 A1#11pin@389_polysilicon-1##40 9.938
R2788 A1#11pin@389_polysilicon-1##40 A1#11pin@389_polysilicon-1##41 9.938
R2789 A1#11pin@389_polysilicon-1##41 A1#11pin@389_polysilicon-1##42 9.938
R2790 A1#11pin@389_polysilicon-1##42 A1#11pin@389_polysilicon-1##43 9.938
R2791 A1#11pin@389_polysilicon-1##43 A1#11pin@389_polysilicon-1##44 9.938
R2792 A1#11pin@389_polysilicon-1##44 A1#11pin@389_polysilicon-1##45 9.938
R2793 A1#11pin@389_polysilicon-1##45 A1#11pin@389_polysilicon-1##46 9.938
R2794 A1#11pin@389_polysilicon-1##46 A1#11pin@389_polysilicon-1##47 9.938
R2795 A1#11pin@389_polysilicon-1##47 A1#11pin@389_polysilicon-1##48 9.938
R2796 A1#11pin@389_polysilicon-1##48 A1#11pin@389_polysilicon-1##49 9.938
R2797 A1#11pin@389_polysilicon-1##49 A1#20nmos@76_poly-right 9.938
R2798 B1#21pmos@77_poly-right B1#21pmos@77_poly-right##0 9.869
R2799 B1#21pmos@77_poly-right##0 B1#21pmos@77_poly-right##1 9.869
R2800 B1#21pmos@77_poly-right##1 B1#21pmos@77_poly-right##2 9.869
R2801 B1#21pmos@77_poly-right##2 B1#21pmos@77_poly-right##3 9.869
R2802 B1#21pmos@77_poly-right##3 B1#21pmos@77_poly-right##4 9.869
R2803 B1#21pmos@77_poly-right##4 B1#21pmos@77_poly-right##5 9.869
R2804 B1#21pmos@77_poly-right##5 B1#21pmos@77_poly-right##6 9.869
R2805 B1#21pmos@77_poly-right##6 B1#21pmos@77_poly-right##7 9.869
R2806 B1#21pmos@77_poly-right##7 B1#21pmos@77_poly-right##8 9.869
R2807 B1#21pmos@77_poly-right##8 B1#21pmos@77_poly-right##9 9.869
R2808 B1#21pmos@77_poly-right##9 B1#21pmos@77_poly-right##10 9.869
R2809 B1#21pmos@77_poly-right##10 B1#21pmos@77_poly-right##11 9.869
R2810 B1#21pmos@77_poly-right##11 B1#21pmos@77_poly-right##12 9.869
R2811 B1#21pmos@77_poly-right##12 B1#21pmos@77_poly-right##13 9.869
R2812 B1#21pmos@77_poly-right##13 B1#21pmos@77_poly-right##14 9.869
R2813 B1#21pmos@77_poly-right##14 B1#21pmos@77_poly-right##15 9.869
R2814 B1#21pmos@77_poly-right##15 B1#21pmos@77_poly-right##16 9.869
R2815 B1#21pmos@77_poly-right##16 B1#21pmos@77_poly-right##17 9.869
R2816 B1#21pmos@77_poly-right##17 B1#21pmos@77_poly-right##18 9.869
R2817 B1#21pmos@77_poly-right##18 B1#21pmos@77_poly-right##19 9.869
R2818 B1#21pmos@77_poly-right##19 B1#21pmos@77_poly-right##20 9.869
R2819 B1#21pmos@77_poly-right##20 B1#21pmos@77_poly-right##21 9.869
R2820 B1#21pmos@77_poly-right##21 B1#21pmos@77_poly-right##22 9.869
R2821 B1#21pmos@77_poly-right##22 B1#21pmos@77_poly-right##23 9.869
R2822 B1#21pmos@77_poly-right##23 B1#21pmos@77_poly-right##24 9.869
R2823 B1#21pmos@77_poly-right##24 B1#21pmos@77_poly-right##25 9.869
R2824 B1#21pmos@77_poly-right##25 B1#21pmos@77_poly-right##26 9.869
R2825 B1#21pmos@77_poly-right##26 B1#21pmos@77_poly-right##27 9.869
R2826 B1#21pmos@77_poly-right##27 B1#21pmos@77_poly-right##28 9.869
R2827 B1#21pmos@77_poly-right##28 B1#21pmos@77_poly-right##29 9.869
R2828 B1#21pmos@77_poly-right##29 B1#21pmos@77_poly-right##30 9.869
R2829 B1#21pmos@77_poly-right##30 B1#21pmos@77_poly-right##31 9.869
R2830 B1#21pmos@77_poly-right##31 B1#21pmos@77_poly-right##32 9.869
R2831 B1#21pmos@77_poly-right##32 B1#21pmos@77_poly-right##33 9.869
R2832 B1#21pmos@77_poly-right##33 B1#21pmos@77_poly-right##34 9.869
R2833 B1#21pmos@77_poly-right##34 B1#21pmos@77_poly-right##35 9.869
R2834 B1#21pmos@77_poly-right##35 B1#21pmos@77_poly-right##36 9.869
R2835 B1#21pmos@77_poly-right##36 B1#21pmos@77_poly-right##37 9.869
R2836 B1#21pmos@77_poly-right##37 B1#21pmos@77_poly-right##38 9.869
R2837 B1#21pmos@77_poly-right##38 B1#21pmos@77_poly-right##39 9.869
R2838 B1#21pmos@77_poly-right##39 B1#21pmos@77_poly-right##40 9.869
R2839 B1#21pmos@77_poly-right##40 B1#21pmos@77_poly-right##41 9.869
R2840 B1#21pmos@77_poly-right##41 B1#21pmos@77_poly-right##42 9.869
R2841 B1#21pmos@77_poly-right##42 B1#21pmos@77_poly-right##43 9.869
R2842 B1#21pmos@77_poly-right##43 B1#21pmos@77_poly-right##44 9.869
R2843 B1#21pmos@77_poly-right##44 B1#21pmos@77_poly-right##45 9.869
R2844 B1#21pmos@77_poly-right##45 B1#21pmos@77_poly-right##46 9.869
R2845 B1#21pmos@77_poly-right##46 B1#21pmos@77_poly-right##47 9.869
R2846 B1#21pmos@77_poly-right##47 B1#11pin@393_polysilicon-1 9.869
R2847 NAND2_to_Nand4#9pin@395_polysilicon-1 NAND2_to_Nand4#9pin@395_polysilicon-1##0 9.938
R2848 NAND2_to_Nand4#9pin@395_polysilicon-1##0 NAND2_to_Nand4#9pin@395_polysilicon-1##1 9.938
R2849 NAND2_to_Nand4#9pin@395_polysilicon-1##1 NAND2_to_Nand4#9pin@395_polysilicon-1##2 9.938
R2850 NAND2_to_Nand4#9pin@395_polysilicon-1##2 NAND2_to_Nand4#9pin@395_polysilicon-1##3 9.938
R2851 NAND2_to_Nand4#9pin@395_polysilicon-1##3 NAND2_to_Nand4#9pin@395_polysilicon-1##4 9.938
R2852 NAND2_to_Nand4#9pin@395_polysilicon-1##4 NAND2_to_Nand4#9pin@395_polysilicon-1##5 9.938
R2853 NAND2_to_Nand4#9pin@395_polysilicon-1##5 NAND2_to_Nand4#9pin@395_polysilicon-1##6 9.938
R2854 NAND2_to_Nand4#9pin@395_polysilicon-1##6 NAND2_to_Nand4#9pin@395_polysilicon-1##7 9.938
R2855 NAND2_to_Nand4#9pin@395_polysilicon-1##7 NAND2_to_Nand4#9pin@395_polysilicon-1##8 9.938
R2856 NAND2_to_Nand4#9pin@395_polysilicon-1##8 NAND2_to_Nand4#9pin@395_polysilicon-1##9 9.938
R2857 NAND2_to_Nand4#9pin@395_polysilicon-1##9 NAND2_to_Nand4#9pin@395_polysilicon-1##10 9.938
R2858 NAND2_to_Nand4#9pin@395_polysilicon-1##10 NAND2_to_Nand4#9pin@395_polysilicon-1##11 9.938
R2859 NAND2_to_Nand4#9pin@395_polysilicon-1##11 NAND2_to_Nand4#9pin@395_polysilicon-1##12 9.938
R2860 NAND2_to_Nand4#9pin@395_polysilicon-1##12 NAND2_to_Nand4#9pin@395_polysilicon-1##13 9.938
R2861 NAND2_to_Nand4#9pin@395_polysilicon-1##13 NAND2_to_Nand4#9pin@395_polysilicon-1##14 9.938
R2862 NAND2_to_Nand4#9pin@395_polysilicon-1##14 NAND2_to_Nand4#9pin@395_polysilicon-1##15 9.938
R2863 NAND2_to_Nand4#9pin@395_polysilicon-1##15 NAND2_to_Nand4#9pin@395_polysilicon-1##16 9.938
R2864 NAND2_to_Nand4#9pin@395_polysilicon-1##16 NAND2_to_Nand4#9pin@395_polysilicon-1##17 9.938
R2865 NAND2_to_Nand4#9pin@395_polysilicon-1##17 NAND2_to_Nand4#9pin@395_polysilicon-1##18 9.938
R2866 NAND2_to_Nand4#9pin@395_polysilicon-1##18 NAND2_to_Nand4#9pin@395_polysilicon-1##19 9.938
R2867 NAND2_to_Nand4#9pin@395_polysilicon-1##19 NAND2_to_Nand4#9pin@395_polysilicon-1##20 9.938
R2868 NAND2_to_Nand4#9pin@395_polysilicon-1##20 NAND2_to_Nand4#9pin@395_polysilicon-1##21 9.938
R2869 NAND2_to_Nand4#9pin@395_polysilicon-1##21 NAND2_to_Nand4#9pin@395_polysilicon-1##22 9.938
R2870 NAND2_to_Nand4#9pin@395_polysilicon-1##22 NAND2_to_Nand4#9pin@395_polysilicon-1##23 9.938
R2871 NAND2_to_Nand4#9pin@395_polysilicon-1##23 NAND2_to_Nand4#9pin@395_polysilicon-1##24 9.938
R2872 NAND2_to_Nand4#9pin@395_polysilicon-1##24 NAND2_to_Nand4#9pin@395_polysilicon-1##25 9.938
R2873 NAND2_to_Nand4#9pin@395_polysilicon-1##25 NAND2_to_Nand4#9pin@395_polysilicon-1##26 9.938
R2874 NAND2_to_Nand4#9pin@395_polysilicon-1##26 NAND2_to_Nand4#9pin@395_polysilicon-1##27 9.938
R2875 NAND2_to_Nand4#9pin@395_polysilicon-1##27 NAND2_to_Nand4#9pin@395_polysilicon-1##28 9.938
R2876 NAND2_to_Nand4#9pin@395_polysilicon-1##28 NAND2_to_Nand4#9pin@395_polysilicon-1##29 9.938
R2877 NAND2_to_Nand4#9pin@395_polysilicon-1##29 NAND2_to_Nand4#9pin@395_polysilicon-1##30 9.938
R2878 NAND2_to_Nand4#9pin@395_polysilicon-1##30 NAND2_to_Nand4#9pin@395_polysilicon-1##31 9.938
R2879 NAND2_to_Nand4#9pin@395_polysilicon-1##31 NAND2_to_Nand4#9pin@395_polysilicon-1##32 9.938
R2880 NAND2_to_Nand4#9pin@395_polysilicon-1##32 NAND2_to_Nand4#9pin@395_polysilicon-1##33 9.938
R2881 NAND2_to_Nand4#9pin@395_polysilicon-1##33 NAND2_to_Nand4#9pin@395_polysilicon-1##34 9.938
R2882 NAND2_to_Nand4#9pin@395_polysilicon-1##34 NAND2_to_Nand4#9pin@395_polysilicon-1##35 9.938
R2883 NAND2_to_Nand4#9pin@395_polysilicon-1##35 NAND2_to_Nand4#9pin@395_polysilicon-1##36 9.938
R2884 NAND2_to_Nand4#9pin@395_polysilicon-1##36 NAND2_to_Nand4#9pin@395_polysilicon-1##37 9.938
R2885 NAND2_to_Nand4#9pin@395_polysilicon-1##37 NAND2_to_Nand4#9pin@395_polysilicon-1##38 9.938
R2886 NAND2_to_Nand4#9pin@395_polysilicon-1##38 NAND2_to_Nand4#9pin@395_polysilicon-1##39 9.938
R2887 NAND2_to_Nand4#9pin@395_polysilicon-1##39 NAND2_to_Nand4#9pin@395_polysilicon-1##40 9.938
R2888 NAND2_to_Nand4#9pin@395_polysilicon-1##40 NAND2_to_Nand4#9pin@395_polysilicon-1##41 9.938
R2889 NAND2_to_Nand4#9pin@395_polysilicon-1##41 NAND2_to_Nand4#9pin@395_polysilicon-1##42 9.938
R2890 NAND2_to_Nand4#9pin@395_polysilicon-1##42 NAND2_to_Nand4#9pin@395_polysilicon-1##43 9.938
R2891 NAND2_to_Nand4#9pin@395_polysilicon-1##43 NAND2_to_Nand4#9pin@395_polysilicon-1##44 9.938
R2892 NAND2_to_Nand4#9pin@395_polysilicon-1##44 NAND2_to_Nand4#9pin@395_polysilicon-1##45 9.938
R2893 NAND2_to_Nand4#9pin@395_polysilicon-1##45 NAND2_to_Nand4#9pin@395_polysilicon-1##46 9.938
R2894 NAND2_to_Nand4#9pin@395_polysilicon-1##46 NAND2_to_Nand4#9pin@395_polysilicon-1##47 9.938
R2895 NAND2_to_Nand4#9pin@395_polysilicon-1##47 NAND2_to_Nand4#9pin@395_polysilicon-1##48 9.938
R2896 NAND2_to_Nand4#9pin@395_polysilicon-1##48 NAND2_to_Nand4#9pin@395_polysilicon-1##49 9.938
R2897 NAND2_to_Nand4#9pin@395_polysilicon-1##49 NAND2_to_Nand4#11nmos@78_poly-right 9.938
R2898 NAND1_to_NAND4#14nmos@79_poly-right NAND1_to_NAND4#14nmos@79_poly-right##0 9.898
R2899 NAND1_to_NAND4#14nmos@79_poly-right##0 NAND1_to_NAND4#14nmos@79_poly-right##1 9.898
R2900 NAND1_to_NAND4#14nmos@79_poly-right##1 NAND1_to_NAND4#14nmos@79_poly-right##2 9.898
R2901 NAND1_to_NAND4#14nmos@79_poly-right##2 NAND1_to_NAND4#14nmos@79_poly-right##3 9.898
R2902 NAND1_to_NAND4#14nmos@79_poly-right##3 NAND1_to_NAND4#14nmos@79_poly-right##4 9.898
R2903 NAND1_to_NAND4#14nmos@79_poly-right##4 NAND1_to_NAND4#14nmos@79_poly-right##5 9.898
R2904 NAND1_to_NAND4#14nmos@79_poly-right##5 NAND1_to_NAND4#14nmos@79_poly-right##6 9.898
R2905 NAND1_to_NAND4#14nmos@79_poly-right##6 NAND1_to_NAND4#14nmos@79_poly-right##7 9.898
R2906 NAND1_to_NAND4#14nmos@79_poly-right##7 NAND1_to_NAND4#14nmos@79_poly-right##8 9.898
R2907 NAND1_to_NAND4#14nmos@79_poly-right##8 NAND1_to_NAND4#14nmos@79_poly-right##9 9.898
R2908 NAND1_to_NAND4#14nmos@79_poly-right##9 NAND1_to_NAND4#14nmos@79_poly-right##10 9.898
R2909 NAND1_to_NAND4#14nmos@79_poly-right##10 NAND1_to_NAND4#14nmos@79_poly-right##11 9.898
R2910 NAND1_to_NAND4#14nmos@79_poly-right##11 NAND1_to_NAND4#14nmos@79_poly-right##12 9.898
R2911 NAND1_to_NAND4#14nmos@79_poly-right##12 NAND1_to_NAND4#14nmos@79_poly-right##13 9.898
R2912 NAND1_to_NAND4#14nmos@79_poly-right##13 NAND1_to_NAND4#14nmos@79_poly-right##14 9.898
R2913 NAND1_to_NAND4#14nmos@79_poly-right##14 NAND1_to_NAND4#14nmos@79_poly-right##15 9.898
R2914 NAND1_to_NAND4#14nmos@79_poly-right##15 NAND1_to_NAND4#14nmos@79_poly-right##16 9.898
R2915 NAND1_to_NAND4#14nmos@79_poly-right##16 NAND1_to_NAND4#14nmos@79_poly-right##17 9.898
R2916 NAND1_to_NAND4#14nmos@79_poly-right##17 NAND1_to_NAND4#14nmos@79_poly-right##18 9.898
R2917 NAND1_to_NAND4#14nmos@79_poly-right##18 NAND1_to_NAND4#14nmos@79_poly-right##19 9.898
R2918 NAND1_to_NAND4#14nmos@79_poly-right##19 NAND1_to_NAND4#14nmos@79_poly-right##20 9.898
R2919 NAND1_to_NAND4#14nmos@79_poly-right##20 NAND1_to_NAND4#14nmos@79_poly-right##21 9.898
R2920 NAND1_to_NAND4#14nmos@79_poly-right##21 NAND1_to_NAND4#14nmos@79_poly-right##22 9.898
R2921 NAND1_to_NAND4#14nmos@79_poly-right##22 NAND1_to_NAND4#14nmos@79_poly-right##23 9.898
R2922 NAND1_to_NAND4#14nmos@79_poly-right##23 NAND1_to_NAND4#14nmos@79_poly-right##24 9.898
R2923 NAND1_to_NAND4#14nmos@79_poly-right##24 NAND1_to_NAND4#14nmos@79_poly-right##25 9.898
R2924 NAND1_to_NAND4#14nmos@79_poly-right##25 NAND1_to_NAND4#14nmos@79_poly-right##26 9.898
R2925 NAND1_to_NAND4#14nmos@79_poly-right##26 NAND1_to_NAND4#14nmos@79_poly-right##27 9.898
R2926 NAND1_to_NAND4#14nmos@79_poly-right##27 NAND1_to_NAND4#14nmos@79_poly-right##28 9.898
R2927 NAND1_to_NAND4#14nmos@79_poly-right##28 NAND1_to_NAND4#14nmos@79_poly-right##29 9.898
R2928 NAND1_to_NAND4#14nmos@79_poly-right##29 NAND1_to_NAND4#14nmos@79_poly-right##30 9.898
R2929 NAND1_to_NAND4#14nmos@79_poly-right##30 NAND1_to_NAND4#14nmos@79_poly-right##31 9.898
R2930 NAND1_to_NAND4#14nmos@79_poly-right##31 NAND1_to_NAND4#14nmos@79_poly-right##32 9.898
R2931 NAND1_to_NAND4#14nmos@79_poly-right##32 NAND1_to_NAND4#14nmos@79_poly-right##33 9.898
R2932 NAND1_to_NAND4#14nmos@79_poly-right##33 NAND1_to_NAND4#14nmos@79_poly-right##34 9.898
R2933 NAND1_to_NAND4#14nmos@79_poly-right##34 NAND1_to_NAND4#14nmos@79_poly-right##35 9.898
R2934 NAND1_to_NAND4#14nmos@79_poly-right##35 NAND1_to_NAND4#14nmos@79_poly-right##36 9.898
R2935 NAND1_to_NAND4#14nmos@79_poly-right##36 NAND1_to_NAND4#14nmos@79_poly-right##37 9.898
R2936 NAND1_to_NAND4#14nmos@79_poly-right##37 NAND1_to_NAND4#14nmos@79_poly-right##38 9.898
R2937 NAND1_to_NAND4#14nmos@79_poly-right##38 NAND1_to_NAND4#14nmos@79_poly-right##39 9.898
R2938 NAND1_to_NAND4#14nmos@79_poly-right##39 NAND1_to_NAND4#14nmos@79_poly-right##40 9.898
R2939 NAND1_to_NAND4#14nmos@79_poly-right##40 NAND1_to_NAND4#14nmos@79_poly-right##41 9.898
R2940 NAND1_to_NAND4#14nmos@79_poly-right##41 NAND1_to_NAND4#14nmos@79_poly-right##42 9.898
R2941 NAND1_to_NAND4#14nmos@79_poly-right##42 NAND1_to_NAND4#14nmos@79_poly-right##43 9.898
R2942 NAND1_to_NAND4#14nmos@79_poly-right##43 NAND1_to_NAND4#14nmos@79_poly-right##44 9.898
R2943 NAND1_to_NAND4#14nmos@79_poly-right##44 NAND1_to_NAND4#14nmos@79_poly-right##45 9.898
R2944 NAND1_to_NAND4#14nmos@79_poly-right##45 NAND1_to_NAND4#14nmos@79_poly-right##46 9.898
R2945 NAND1_to_NAND4#14nmos@79_poly-right##46 NAND1_to_NAND4#14nmos@79_poly-right##47 9.898
R2946 NAND1_to_NAND4#14nmos@79_poly-right##47 NAND1_to_NAND4#14nmos@79_poly-right##48 9.898
R2947 NAND1_to_NAND4#14nmos@79_poly-right##48 NAND1_to_NAND4#14nmos@79_poly-right##49 9.898
R2948 NAND1_to_NAND4#14nmos@79_poly-right##49 NAND1_to_NAND4#14nmos@79_poly-right##50 9.898
R2949 NAND1_to_NAND4#14nmos@79_poly-right##50 NAND1_to_NAND4#14nmos@79_poly-right##51 9.898
R2950 NAND1_to_NAND4#14nmos@79_poly-right##51 NAND1_to_NAND4#14nmos@79_poly-right##52 9.898
R2951 NAND1_to_NAND4#14nmos@79_poly-right##52 NAND1_to_NAND4#14nmos@79_poly-right##53 9.898
R2952 NAND1_to_NAND4#14nmos@79_poly-right##53 NAND1_to_NAND4#14nmos@79_poly-right##54 9.898
R2953 NAND1_to_NAND4#14nmos@79_poly-right##54 NAND1_to_NAND4#14nmos@79_poly-right##55 9.898
R2954 NAND1_to_NAND4#14nmos@79_poly-right##55 NAND1_to_NAND4#11pmos@79_poly-right 9.898
R2955 NAND2_to_Nand4 NAND2_to_Nand4#4nmos@77_diff-bottom 4.42
R2956 B1 B1##0 5.018
C346 B1##0 0 5.383fF
R2957 B1##0 B1#0pin@508_metal-2 5.018
R2958 net@1809 net@1809##0 9.92
R2959 net@1809##0 net@1809##1 9.92
R2960 net@1809##1 net@1809##2 9.92
R2961 net@1809##2 net@1809##3 9.92
R2962 net@1809##3 net@1809##4 9.92
R2963 net@1809##4 net@1809##5 9.92
R2964 net@1809##5 net@1809##6 9.92
R2965 net@1809##6 net@1809##7 9.92
R2966 net@1809##7 net@1809##8 9.92
R2967 net@1809##8 net@1809##9 9.92
R2968 net@1809##9 net@1809##10 9.92
R2969 net@1809##10 net@1809##11 9.92
R2970 net@1809##11 net@1809##12 9.92
R2971 net@1809##12 net@1809##13 9.92
R2972 net@1809##13 net@1809##14 9.92
R2973 net@1809##14 net@1809##15 9.92
R2974 net@1809##15 net@1809##16 9.92
R2975 net@1809##16 net@1809##17 9.92
R2976 net@1809##17 net@1809##18 9.92
R2977 net@1809##18 net@1809#1pin@546_polysilicon-1 9.92
R2978 net@1811 net@1811##0 9.92
R2979 net@1811##0 net@1811##1 9.92
R2980 net@1811##1 net@1811##2 9.92
R2981 net@1811##2 net@1811##3 9.92
R2982 net@1811##3 net@1811##4 9.92
R2983 net@1811##4 net@1811##5 9.92
R2984 net@1811##5 net@1811##6 9.92
R2985 net@1811##6 net@1811##7 9.92
R2986 net@1811##7 net@1811##8 9.92
R2987 net@1811##8 net@1811##9 9.92
R2988 net@1811##9 net@1811##10 9.92
R2989 net@1811##10 net@1811##11 9.92
R2990 net@1811##11 net@1811##12 9.92
R2991 net@1811##12 net@1811##13 9.92
R2992 net@1811##13 net@1811##14 9.92
R2993 net@1811##14 net@1811##15 9.92
R2994 net@1811##15 net@1811##16 9.92
R2995 net@1811##16 net@1811##17 9.92
R2996 net@1811##17 net@1811##18 9.92
R2997 net@1811##18 net@1811#1pin@571_polysilicon-1 9.92
R2998 XOR1_to_NAND3#3pin@572_polysilicon-1 XOR1_to_NAND3#3pin@572_polysilicon-1##0 6.2
R2999 XOR1_to_NAND3#3pin@572_polysilicon-1##0 XOR1_to_NAND3#4pmos@92_poly-right 6.2
R3000 XOR1_to_NAND3#3pin@572_polysilicon-1 XOR1_to_NAND3#3pin@572_polysilicon-1##0 8.138
R3001 XOR1_to_NAND3#3pin@572_polysilicon-1##0 XOR1_to_NAND3#3pin@572_polysilicon-1##1 8.138
R3002 XOR1_to_NAND3#3pin@572_polysilicon-1##1 XOR1_to_NAND3#3pin@572_polysilicon-1##2 8.138
R3003 XOR1_to_NAND3#3pin@572_polysilicon-1##2 XOR1_to_NAND3#1contact@656_metal-1-metal-2 8.138
R3004 Cin_to_XOR2___NAND3#14nmos@91_poly-right Cin_to_XOR2___NAND3#14nmos@91_poly-right##0 5.425
R3005 Cin_to_XOR2___NAND3#14nmos@91_poly-right##0 Cin_to_XOR2___NAND3#15pin@562_polysilicon-1 5.425
R3006 Cin_to_XOR2___NAND3 Cin_to_XOR2___NAND3##0 8.99
R3007 Cin_to_XOR2___NAND3##0 Cin_to_XOR2___NAND3##1 8.99
R3008 Cin_to_XOR2___NAND3##1 Cin_to_XOR2___NAND3##2 8.99
R3009 Cin_to_XOR2___NAND3##2 Cin_to_XOR2___NAND3##3 8.99
R3010 Cin_to_XOR2___NAND3##3 Cin_to_XOR2___NAND3#15pin@562_polysilicon-1 8.99
R3011 A2#3pin@547_polysilicon-1 A2#3pin@547_polysilicon-1##0 6.2
R3012 A2#3pin@547_polysilicon-1##0 A2#4pmos@85_poly-right 6.2
R3013 XOR1_to_NAND3#9pmos@87_poly-left XOR1_to_NAND3#9pmos@87_poly-left##0 8.138
R3014 XOR1_to_NAND3#9pmos@87_poly-left##0 XOR1_to_NAND3#9pmos@87_poly-left##1 8.138
R3015 XOR1_to_NAND3#9pmos@87_poly-left##1 XOR1_to_NAND3#9pmos@87_poly-left##2 8.138
R3016 XOR1_to_NAND3#9pmos@87_poly-left##2 XOR1_to_NAND3#10pin@559_polysilicon-1 8.138
R3017 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##0 9.843
R3018 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##0 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##1 9.843
R3019 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##1 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##2 9.843
R3020 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##2 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##3 9.843
R3021 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##3 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##4 9.843
R3022 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##4 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##5 9.843
R3023 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##5 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##6 9.843
R3024 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##6 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##7 9.843
R3025 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##7 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##8 9.843
R3026 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##8 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##9 9.843
R3027 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##9 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##10 9.843
R3028 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##10 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##11 9.843
R3029 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##11 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##12 9.843
R3030 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##12 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##13 9.843
R3031 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##13 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##14 9.843
R3032 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##14 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##15 9.843
R3033 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##15 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##16 9.843
R3034 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##16 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##17 9.843
R3035 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##17 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##18 9.843
R3036 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##18 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1 9.843
R3037 net@1820#4nmos@93_poly-right net@1820#4nmos@93_poly-right##0 9.3
R3038 net@1820#4nmos@93_poly-right##0 net@1820#4nmos@93_poly-right##1 9.3
R3039 net@1820#4nmos@93_poly-right##1 net@1820#5pin@564_polysilicon-1 9.3
R3040 net@1820#2contact@642_metal-1-polysilicon-1 net@1820#2contact@642_metal-1-polysilicon-1##0 8.99
R3041 net@1820#2contact@642_metal-1-polysilicon-1##0 net@1820#2contact@642_metal-1-polysilicon-1##1 8.99
R3042 net@1820#2contact@642_metal-1-polysilicon-1##1 net@1820#2contact@642_metal-1-polysilicon-1##2 8.99
R3043 net@1820#2contact@642_metal-1-polysilicon-1##2 net@1820#2contact@642_metal-1-polysilicon-1##3 8.99
R3044 net@1820#2contact@642_metal-1-polysilicon-1##3 net@1820#5pin@564_polysilicon-1 8.99
R3045 A2#3pin@547_polysilicon-1 A2#3pin@547_polysilicon-1##0 8.138
R3046 A2#3pin@547_polysilicon-1##0 A2#3pin@547_polysilicon-1##1 8.138
R3047 A2#3pin@547_polysilicon-1##1 A2#3pin@547_polysilicon-1##2 8.138
R3048 A2#3pin@547_polysilicon-1##2 A2#1pin@586_metal-2 8.138
R3049 XOR1_to_NAND3#1contact@656_metal-1-metal-2 XOR1_to_NAND3#1contact@656_metal-1-metal-2##0 6.717
R3050 XOR1_to_NAND3#1contact@656_metal-1-metal-2##0 XOR1_to_NAND3#1contact@656_metal-1-metal-2##1 6.717
R3051 XOR1_to_NAND3#1contact@656_metal-1-metal-2##1 XOR1_to_NAND3#12pin@560_polysilicon-1 6.717
R3052 XOR1_to_NAND3#10pin@559_polysilicon-1 XOR1_to_NAND3#10pin@559_polysilicon-1##0 7.75
R3053 XOR1_to_NAND3#10pin@559_polysilicon-1##0 XOR1_to_NAND3#10pin@559_polysilicon-1##1 7.75
R3054 XOR1_to_NAND3#10pin@559_polysilicon-1##1 XOR1_to_NAND3#12pin@560_polysilicon-1 7.75
R3055 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1##0 9.743
R3056 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1##0 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1##1 9.743
R3057 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1##1 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1##2 9.743
R3058 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1##2 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1##3 9.743
R3059 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1##3 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1##4 9.743
R3060 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1##4 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1##5 9.743
R3061 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1##5 Cin_to_XOR2___NAND3 9.743
R3062 net@1811#7pmos@88_poly-left net@1811#7pmos@88_poly-left##0 7.75
R3063 net@1811#7pmos@88_poly-left##0 net@1811 7.75
R3064 Cin_to_XOR2___NAND3#18nmos@89_poly-left Cin_to_XOR2___NAND3#18nmos@89_poly-left##0 6.2
R3065 Cin_to_XOR2___NAND3#18nmos@89_poly-left##0 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1 6.2
R3066 net@1821#9nmos@90_poly-left net@1821#9nmos@90_poly-left##0 8.37
R3067 net@1821#9nmos@90_poly-left##0 net@1821#9nmos@90_poly-left##1 8.37
R3068 net@1821#9nmos@90_poly-left##1 net@1821#9nmos@90_poly-left##2 8.37
R3069 net@1821#9nmos@90_poly-left##2 net@1821#9nmos@90_poly-left##3 8.37
R3070 net@1821#9nmos@90_poly-left##3 net@1821#2contact@617_metal-1-metal-2 8.37
R3071 XOR1_to_NAND3 XOR1_to_NAND3##0 6.717
R3072 XOR1_to_NAND3##0 XOR1_to_NAND3##1 6.717
R3073 XOR1_to_NAND3##1 XOR1_to_NAND3#14pin@576_polysilicon-1 6.717
R3074 XOR1_to_NAND3#16pmos@94_poly-right XOR1_to_NAND3#16pmos@94_poly-right##0 6.2
R3075 XOR1_to_NAND3#16pmos@94_poly-right##0 XOR1_to_NAND3#14pin@576_polysilicon-1 6.2
R3076 Cin_to_XOR2___NAND3#23pin@580_polysilicon-1 Cin_to_XOR2___NAND3#23pin@580_polysilicon-1##0 9.688
R3077 Cin_to_XOR2___NAND3#23pin@580_polysilicon-1##0 Cin_to_XOR2___NAND3#23pin@580_polysilicon-1##1 9.688
R3078 Cin_to_XOR2___NAND3#23pin@580_polysilicon-1##1 Cin_to_XOR2___NAND3#23pin@580_polysilicon-1##2 9.688
R3079 Cin_to_XOR2___NAND3#23pin@580_polysilicon-1##2 Cin_to_XOR2___NAND3#20contact@655_metal-1-metal-2 9.688
R3080 Cin_to_XOR2___NAND3#20contact@655_metal-1-metal-2 Cin_to_XOR2___NAND3 4.953
R3081 A2#0contact@664_metal-1-metal-2 A2#0contact@664_metal-1-metal-2##0 6.717
R3082 A2#0contact@664_metal-1-metal-2##0 A2#0contact@664_metal-1-metal-2##1 6.717
R3083 A2#0contact@664_metal-1-metal-2##1 A2#10pin@583_polysilicon-1 6.717
R3084 A2#11pmos@96_poly-right A2#11pmos@96_poly-right##0 9.558
R3085 A2#11pmos@96_poly-right##0 A2#11pmos@96_poly-right##1 9.558
R3086 A2#11pmos@96_poly-right##1 A2#11pmos@96_poly-right##2 9.558
R3087 A2#11pmos@96_poly-right##2 A2#11pmos@96_poly-right##3 9.558
R3088 A2#11pmos@96_poly-right##3 A2#11pmos@96_poly-right##4 9.558
R3089 A2#11pmos@96_poly-right##4 A2#10pin@583_polysilicon-1 9.558
R3090 B2#10pin@587_polysilicon-1 B2#10pin@587_polysilicon-1##0 8.138
R3091 B2#10pin@587_polysilicon-1##0 B2#10pin@587_polysilicon-1##1 8.138
R3092 B2#10pin@587_polysilicon-1##1 B2#10pin@587_polysilicon-1##2 8.138
R3093 B2#10pin@587_polysilicon-1##2 B2#0contact@665_metal-1-metal-2 8.138
R3094 B2#11nmos@84_poly-right B2#11nmos@84_poly-right##0 5.425
R3095 B2#11nmos@84_poly-right##0 B2#12pin@537_polysilicon-1 5.425
R3096 NAND2_to_Nand5 NAND2_to_Nand5##0 6.717
R3097 NAND2_to_Nand5##0 NAND2_to_Nand5##1 6.717
R3098 NAND2_to_Nand5##1 NAND2_to_Nand5#9pin@589_polysilicon-1 6.717
R3099 NAND2_to_Nand5#10pmos@98_poly-right NAND2_to_Nand5#10pmos@98_poly-right##0 9.558
R3100 NAND2_to_Nand5#10pmos@98_poly-right##0 NAND2_to_Nand5#10pmos@98_poly-right##1 9.558
R3101 NAND2_to_Nand5#10pmos@98_poly-right##1 NAND2_to_Nand5#10pmos@98_poly-right##2 9.558
R3102 NAND2_to_Nand5#10pmos@98_poly-right##2 NAND2_to_Nand5#10pmos@98_poly-right##3 9.558
R3103 NAND2_to_Nand5#10pmos@98_poly-right##3 NAND2_to_Nand5#10pmos@98_poly-right##4 9.558
R3104 NAND2_to_Nand5#10pmos@98_poly-right##4 NAND2_to_Nand5#9pin@589_polysilicon-1 9.558
R3105 B2#1pin@588_metal-2 B2#1pin@588_metal-2##0 8.99
R3106 B2#1pin@588_metal-2##0 B2#1pin@588_metal-2##1 8.99
R3107 B2#1pin@588_metal-2##1 B2#1pin@588_metal-2##2 8.99
R3108 B2#1pin@588_metal-2##2 B2#1pin@588_metal-2##3 8.99
R3109 B2#1pin@588_metal-2##3 B2#12pin@537_polysilicon-1 8.99
R3110 NAND1_to_NAND5#11pmos@99_poly-right NAND1_to_NAND5#11pmos@99_poly-right##0 5.425
R3111 NAND1_to_NAND5#11pmos@99_poly-right##0 NAND1_to_NAND5#12pin@593_polysilicon-1 5.425
R3112 NAND1_to_NAND5#12pin@593_polysilicon-1 NAND1_to_NAND5#12pin@593_polysilicon-1##0 9.3
R3113 NAND1_to_NAND5#12pin@593_polysilicon-1##0 NAND1_to_NAND5#12pin@593_polysilicon-1##1 9.3
R3114 NAND1_to_NAND5#12pin@593_polysilicon-1##1 NAND1_to_NAND5 9.3
R3115 Cin_to_XOR2___NAND3#25nmos@95_poly-right Cin_to_XOR2___NAND3#25nmos@95_poly-right##0 8.636
R3116 Cin_to_XOR2___NAND3#25nmos@95_poly-right##0 Cin_to_XOR2___NAND3#25nmos@95_poly-right##1 8.636
R3117 Cin_to_XOR2___NAND3#25nmos@95_poly-right##1 Cin_to_XOR2___NAND3#25nmos@95_poly-right##2 8.636
R3118 Cin_to_XOR2___NAND3#25nmos@95_poly-right##2 Cin_to_XOR2___NAND3#25nmos@95_poly-right##3 8.636
R3119 Cin_to_XOR2___NAND3#25nmos@95_poly-right##3 Cin_to_XOR2___NAND3#25nmos@95_poly-right##4 8.636
R3120 Cin_to_XOR2___NAND3#25nmos@95_poly-right##4 Cin_to_XOR2___NAND3#25nmos@95_poly-right##5 8.636
R3121 Cin_to_XOR2___NAND3#25nmos@95_poly-right##5 Cin_to_XOR2___NAND3#23pin@580_polysilicon-1 8.636
R3122 B2#13nmos@97_poly-right B2#13nmos@97_poly-right##0 8.956
R3123 B2#13nmos@97_poly-right##0 B2#13nmos@97_poly-right##1 8.956
R3124 B2#13nmos@97_poly-right##1 B2#13nmos@97_poly-right##2 8.956
R3125 B2#13nmos@97_poly-right##2 B2#13nmos@97_poly-right##3 8.956
R3126 B2#13nmos@97_poly-right##3 B2#13nmos@97_poly-right##4 8.956
R3127 B2#13nmos@97_poly-right##4 B2#13nmos@97_poly-right##5 8.956
R3128 B2#13nmos@97_poly-right##5 B2#13nmos@97_poly-right##6 8.956
R3129 B2#13nmos@97_poly-right##6 B2#13nmos@97_poly-right##7 8.956
R3130 B2#13nmos@97_poly-right##7 B2#10pin@587_polysilicon-1 8.956
R3131 A2#12pmos@80_poly-left A2#12pmos@80_poly-left##0 8.138
R3132 A2#12pmos@80_poly-left##0 A2#12pmos@80_poly-left##1 8.138
R3133 A2#12pmos@80_poly-left##1 A2#12pmos@80_poly-left##2 8.138
R3134 A2#12pmos@80_poly-left##2 A2#13pin@534_polysilicon-1 8.138
R3135 B2#14pin@527_polysilicon-1 B2#14pin@527_polysilicon-1##0 9.843
R3136 B2#14pin@527_polysilicon-1##0 B2#14pin@527_polysilicon-1##1 9.843
R3137 B2#14pin@527_polysilicon-1##1 B2#14pin@527_polysilicon-1##2 9.843
R3138 B2#14pin@527_polysilicon-1##2 B2#14pin@527_polysilicon-1##3 9.843
R3139 B2#14pin@527_polysilicon-1##3 B2#14pin@527_polysilicon-1##4 9.843
R3140 B2#14pin@527_polysilicon-1##4 B2#14pin@527_polysilicon-1##5 9.843
R3141 B2#14pin@527_polysilicon-1##5 B2#14pin@527_polysilicon-1##6 9.843
R3142 B2#14pin@527_polysilicon-1##6 B2#14pin@527_polysilicon-1##7 9.843
R3143 B2#14pin@527_polysilicon-1##7 B2#14pin@527_polysilicon-1##8 9.843
R3144 B2#14pin@527_polysilicon-1##8 B2#14pin@527_polysilicon-1##9 9.843
R3145 B2#14pin@527_polysilicon-1##9 B2#14pin@527_polysilicon-1##10 9.843
R3146 B2#14pin@527_polysilicon-1##10 B2#14pin@527_polysilicon-1##11 9.843
R3147 B2#14pin@527_polysilicon-1##11 B2#14pin@527_polysilicon-1##12 9.843
R3148 B2#14pin@527_polysilicon-1##12 B2#14pin@527_polysilicon-1##13 9.843
R3149 B2#14pin@527_polysilicon-1##13 B2#14pin@527_polysilicon-1##14 9.843
R3150 B2#14pin@527_polysilicon-1##14 B2#14pin@527_polysilicon-1##15 9.843
R3151 B2#14pin@527_polysilicon-1##15 B2#14pin@527_polysilicon-1##16 9.843
R3152 B2#14pin@527_polysilicon-1##16 B2#14pin@527_polysilicon-1##17 9.843
R3153 B2#14pin@527_polysilicon-1##17 B2#14pin@527_polysilicon-1##18 9.843
R3154 B2#14pin@527_polysilicon-1##18 B2#15pin@544_polysilicon-1 9.843
R3155 net@1907#4nmos@86_poly-right net@1907#4nmos@86_poly-right##0 7.233
R3156 net@1907#4nmos@86_poly-right##0 net@1907#4nmos@86_poly-right##1 7.233
R3157 net@1907#4nmos@86_poly-right##1 net@1907#5pin@539_polysilicon-1 7.233
R3158 net@1907#2contact@603_metal-1-polysilicon-1 net@1907#2contact@603_metal-1-polysilicon-1##0 8.99
R3159 net@1907#2contact@603_metal-1-polysilicon-1##0 net@1907#2contact@603_metal-1-polysilicon-1##1 8.99
R3160 net@1907#2contact@603_metal-1-polysilicon-1##1 net@1907#2contact@603_metal-1-polysilicon-1##2 8.99
R3161 net@1907#2contact@603_metal-1-polysilicon-1##2 net@1907#2contact@603_metal-1-polysilicon-1##3 8.99
R3162 net@1907#2contact@603_metal-1-polysilicon-1##3 net@1907#5pin@539_polysilicon-1 8.99
R3163 A2#1pin@586_metal-2 A2#1pin@586_metal-2##0 6.717
R3164 A2#1pin@586_metal-2##0 A2#1pin@586_metal-2##1 6.717
R3165 A2#1pin@586_metal-2##1 A2#15pin@535_polysilicon-1 6.717
R3166 A2#13pin@534_polysilicon-1 A2#13pin@534_polysilicon-1##0 7.75
R3167 A2#13pin@534_polysilicon-1##0 A2#13pin@534_polysilicon-1##1 7.75
R3168 A2#13pin@534_polysilicon-1##1 A2#15pin@535_polysilicon-1 7.75
R3169 B2#15pin@544_polysilicon-1 B2#15pin@544_polysilicon-1##0 9.743
R3170 B2#15pin@544_polysilicon-1##0 B2#15pin@544_polysilicon-1##1 9.743
R3171 B2#15pin@544_polysilicon-1##1 B2#15pin@544_polysilicon-1##2 9.743
R3172 B2#15pin@544_polysilicon-1##2 B2#15pin@544_polysilicon-1##3 9.743
R3173 B2#15pin@544_polysilicon-1##3 B2#15pin@544_polysilicon-1##4 9.743
R3174 B2#15pin@544_polysilicon-1##4 B2#15pin@544_polysilicon-1##5 9.743
R3175 B2#15pin@544_polysilicon-1##5 B2#1pin@588_metal-2 9.743
R3176 net@1809#7pmos@81_poly-left net@1809#7pmos@81_poly-left##0 7.75
R3177 net@1809#7pmos@81_poly-left##0 net@1809 7.75
R3178 B2#16nmos@82_poly-left B2#16nmos@82_poly-left##0 6.2
R3179 B2#16nmos@82_poly-left##0 B2#14pin@527_polysilicon-1 6.2
R3180 net@1914#9nmos@83_poly-left net@1914#9nmos@83_poly-left##0 8.37
R3181 net@1914#9nmos@83_poly-left##0 net@1914#9nmos@83_poly-left##1 8.37
R3182 net@1914#9nmos@83_poly-left##1 net@1914#9nmos@83_poly-left##2 8.37
R3183 net@1914#9nmos@83_poly-left##2 net@1914#9nmos@83_poly-left##3 8.37
R3184 net@1914#9nmos@83_poly-left##3 net@1914#2contact@579_metal-1-metal-2 8.37
R3185 A2#3pin@547_polysilicon-1 A2#3pin@547_polysilicon-1##0 9.881
R3186 A2#3pin@547_polysilicon-1##0 A2#3pin@547_polysilicon-1##1 9.881
R3187 A2#3pin@547_polysilicon-1##1 A2#3pin@547_polysilicon-1##2 9.881
R3188 A2#3pin@547_polysilicon-1##2 A2#3pin@547_polysilicon-1##3 9.881
R3189 A2#3pin@547_polysilicon-1##3 A2#3pin@547_polysilicon-1##4 9.881
R3190 A2#3pin@547_polysilicon-1##4 A2#3pin@547_polysilicon-1##5 9.881
R3191 A2#3pin@547_polysilicon-1##5 A2#3pin@547_polysilicon-1##6 9.881
R3192 A2#3pin@547_polysilicon-1##6 A2#3pin@547_polysilicon-1##7 9.881
R3193 A2#3pin@547_polysilicon-1##7 A2#3pin@547_polysilicon-1##8 9.881
R3194 A2#3pin@547_polysilicon-1##8 A2#3pin@547_polysilicon-1##9 9.881
R3195 A2#3pin@547_polysilicon-1##9 A2#3pin@547_polysilicon-1##10 9.881
R3196 A2#3pin@547_polysilicon-1##10 A2#3pin@547_polysilicon-1##11 9.881
R3197 A2#3pin@547_polysilicon-1##11 A2#3pin@547_polysilicon-1##12 9.881
R3198 A2#3pin@547_polysilicon-1##12 A2#3pin@547_polysilicon-1##13 9.881
R3199 A2#3pin@547_polysilicon-1##13 A2#3pin@547_polysilicon-1##14 9.881
R3200 A2#3pin@547_polysilicon-1##14 A2#3pin@547_polysilicon-1##15 9.881
R3201 A2#3pin@547_polysilicon-1##15 A2#3pin@547_polysilicon-1##16 9.881
R3202 A2#3pin@547_polysilicon-1##16 A2#3pin@547_polysilicon-1##17 9.881
R3203 A2#3pin@547_polysilicon-1##17 A2#3pin@547_polysilicon-1##18 9.881
R3204 A2#3pin@547_polysilicon-1##18 A2#3pin@547_polysilicon-1##19 9.881
R3205 A2#3pin@547_polysilicon-1##19 A2#3pin@547_polysilicon-1##20 9.881
R3206 A2#3pin@547_polysilicon-1##20 A2#3pin@547_polysilicon-1##21 9.881
R3207 A2#3pin@547_polysilicon-1##21 A2#3pin@547_polysilicon-1##22 9.881
R3208 A2#3pin@547_polysilicon-1##22 A2#3pin@547_polysilicon-1##23 9.881
R3209 A2#3pin@547_polysilicon-1##23 A2#3pin@547_polysilicon-1##24 9.881
R3210 A2#3pin@547_polysilicon-1##24 A2#3pin@547_polysilicon-1##25 9.881
R3211 A2#3pin@547_polysilicon-1##25 A2#3pin@547_polysilicon-1##26 9.881
R3212 A2#3pin@547_polysilicon-1##26 A2#3pin@547_polysilicon-1##27 9.881
R3213 A2#3pin@547_polysilicon-1##27 A2#3pin@547_polysilicon-1##28 9.881
R3214 A2#3pin@547_polysilicon-1##28 A2#3pin@547_polysilicon-1##29 9.881
R3215 A2#3pin@547_polysilicon-1##29 A2#3pin@547_polysilicon-1##30 9.881
R3216 A2#3pin@547_polysilicon-1##30 A2#3pin@547_polysilicon-1##31 9.881
R3217 A2#3pin@547_polysilicon-1##31 A2#3pin@547_polysilicon-1##32 9.881
R3218 A2#3pin@547_polysilicon-1##32 A2#3pin@547_polysilicon-1##33 9.881
R3219 A2#3pin@547_polysilicon-1##33 A2#3pin@547_polysilicon-1##34 9.881
R3220 A2#3pin@547_polysilicon-1##34 A2#3pin@547_polysilicon-1##35 9.881
R3221 A2#3pin@547_polysilicon-1##35 A2#3pin@547_polysilicon-1##36 9.881
R3222 A2#3pin@547_polysilicon-1##36 A2#3pin@547_polysilicon-1##37 9.881
R3223 A2#3pin@547_polysilicon-1##37 A2#3pin@547_polysilicon-1##38 9.881
R3224 A2#3pin@547_polysilicon-1##38 A2#3pin@547_polysilicon-1##39 9.881
R3225 A2#3pin@547_polysilicon-1##39 A2#3pin@547_polysilicon-1##40 9.881
R3226 A2#3pin@547_polysilicon-1##40 A2#3pin@547_polysilicon-1##41 9.881
R3227 A2#3pin@547_polysilicon-1##41 A2#3pin@547_polysilicon-1##42 9.881
R3228 A2#3pin@547_polysilicon-1##42 A2#3pin@547_polysilicon-1##43 9.881
R3229 A2#3pin@547_polysilicon-1##43 A2#3pin@547_polysilicon-1##44 9.881
R3230 A2#3pin@547_polysilicon-1##44 A2#3pin@547_polysilicon-1##45 9.881
R3231 A2#3pin@547_polysilicon-1##45 A2#3pin@547_polysilicon-1##46 9.881
R3232 A2#3pin@547_polysilicon-1##46 A2#3pin@547_polysilicon-1##47 9.881
R3233 A2#3pin@547_polysilicon-1##47 A2#3pin@547_polysilicon-1##48 9.881
R3234 A2#3pin@547_polysilicon-1##48 A2#3pin@547_polysilicon-1##49 9.881
R3235 A2#3pin@547_polysilicon-1##49 A2#3pin@547_polysilicon-1##50 9.881
R3236 A2#3pin@547_polysilicon-1##50 A2#3pin@547_polysilicon-1##51 9.881
R3237 A2#3pin@547_polysilicon-1##51 A2#3pin@547_polysilicon-1##52 9.881
R3238 A2#3pin@547_polysilicon-1##52 A2#3pin@547_polysilicon-1##53 9.881
R3239 A2#3pin@547_polysilicon-1##53 A2#3pin@547_polysilicon-1##54 9.881
R3240 A2#3pin@547_polysilicon-1##54 A2#16nmos@85_poly-right 9.881
R3241 net@1809#5pmos@85_diff-top net@1809#2pin@536_metal-1 4.81
R3242 net@1809#1pin@546_polysilicon-1 net@1809#1pin@546_polysilicon-1##0 9.85
R3243 net@1809#1pin@546_polysilicon-1##0 net@1809#1pin@546_polysilicon-1##1 9.85
R3244 net@1809#1pin@546_polysilicon-1##1 net@1809#1pin@546_polysilicon-1##2 9.85
R3245 net@1809#1pin@546_polysilicon-1##2 net@1809#1pin@546_polysilicon-1##3 9.85
R3246 net@1809#1pin@546_polysilicon-1##3 net@1809#1pin@546_polysilicon-1##4 9.85
R3247 net@1809#1pin@546_polysilicon-1##4 net@1809#1pin@546_polysilicon-1##5 9.85
R3248 net@1809#1pin@546_polysilicon-1##5 net@1809#1pin@546_polysilicon-1##6 9.85
R3249 net@1809#1pin@546_polysilicon-1##6 net@1809#1pin@546_polysilicon-1##7 9.85
R3250 net@1809#1pin@546_polysilicon-1##7 net@1809#1pin@546_polysilicon-1##8 9.85
R3251 net@1809#1pin@546_polysilicon-1##8 net@1809#1pin@546_polysilicon-1##9 9.85
R3252 net@1809#1pin@546_polysilicon-1##9 net@1809#1pin@546_polysilicon-1##10 9.85
R3253 net@1809#1pin@546_polysilicon-1##10 net@1809#1pin@546_polysilicon-1##11 9.85
R3254 net@1809#1pin@546_polysilicon-1##11 net@1809#1pin@546_polysilicon-1##12 9.85
R3255 net@1809#1pin@546_polysilicon-1##12 net@1809#1pin@546_polysilicon-1##13 9.85
R3256 net@1809#1pin@546_polysilicon-1##13 net@1809#1pin@546_polysilicon-1##14 9.85
R3257 net@1809#1pin@546_polysilicon-1##14 net@1809#1pin@546_polysilicon-1##15 9.85
R3258 net@1809#1pin@546_polysilicon-1##15 net@1809#1pin@546_polysilicon-1##16 9.85
R3259 net@1809#1pin@546_polysilicon-1##16 net@1809#1pin@546_polysilicon-1##17 9.85
R3260 net@1809#1pin@546_polysilicon-1##17 net@1809#1pin@546_polysilicon-1##18 9.85
R3261 net@1809#1pin@546_polysilicon-1##18 net@1809#1pin@546_polysilicon-1##19 9.85
R3262 net@1809#1pin@546_polysilicon-1##19 net@1809#1pin@546_polysilicon-1##20 9.85
R3263 net@1809#1pin@546_polysilicon-1##20 net@1809#1pin@546_polysilicon-1##21 9.85
R3264 net@1809#1pin@546_polysilicon-1##21 net@1809#1pin@546_polysilicon-1##22 9.85
R3265 net@1809#1pin@546_polysilicon-1##22 net@1809#1pin@546_polysilicon-1##23 9.85
R3266 net@1809#1pin@546_polysilicon-1##23 net@1809#1pin@546_polysilicon-1##24 9.85
R3267 net@1809#1pin@546_polysilicon-1##24 net@1809#1pin@546_polysilicon-1##25 9.85
R3268 net@1809#1pin@546_polysilicon-1##25 net@1809#1pin@546_polysilicon-1##26 9.85
R3269 net@1809#1pin@546_polysilicon-1##26 net@1809#1pin@546_polysilicon-1##27 9.85
R3270 net@1809#1pin@546_polysilicon-1##27 net@1809#1pin@546_polysilicon-1##28 9.85
R3271 net@1809#1pin@546_polysilicon-1##28 net@1809#1pin@546_polysilicon-1##29 9.85
R3272 net@1809#1pin@546_polysilicon-1##29 net@1809#1pin@546_polysilicon-1##30 9.85
R3273 net@1809#1pin@546_polysilicon-1##30 net@1809#1pin@546_polysilicon-1##31 9.85
R3274 net@1809#1pin@546_polysilicon-1##31 net@1809#1pin@546_polysilicon-1##32 9.85
R3275 net@1809#1pin@546_polysilicon-1##32 net@1809#1pin@546_polysilicon-1##33 9.85
R3276 net@1809#1pin@546_polysilicon-1##33 net@1809#1pin@546_polysilicon-1##34 9.85
R3277 net@1809#1pin@546_polysilicon-1##34 net@1809#1pin@546_polysilicon-1##35 9.85
R3278 net@1809#1pin@546_polysilicon-1##35 net@1809#1pin@546_polysilicon-1##36 9.85
R3279 net@1809#1pin@546_polysilicon-1##36 net@1809#1pin@546_polysilicon-1##37 9.85
R3280 net@1809#1pin@546_polysilicon-1##37 net@1809#1pin@546_polysilicon-1##38 9.85
R3281 net@1809#1pin@546_polysilicon-1##38 net@1809#1pin@546_polysilicon-1##39 9.85
R3282 net@1809#1pin@546_polysilicon-1##39 net@1809#1pin@546_polysilicon-1##40 9.85
R3283 net@1809#1pin@546_polysilicon-1##40 net@1809#1pin@546_polysilicon-1##41 9.85
R3284 net@1809#1pin@546_polysilicon-1##41 net@1809#1pin@546_polysilicon-1##42 9.85
R3285 net@1809#1pin@546_polysilicon-1##42 net@1809#1pin@546_polysilicon-1##43 9.85
R3286 net@1809#1pin@546_polysilicon-1##43 net@1809#1pin@546_polysilicon-1##44 9.85
R3287 net@1809#1pin@546_polysilicon-1##44 net@1809#1pin@546_polysilicon-1##45 9.85
R3288 net@1809#1pin@546_polysilicon-1##45 net@1809#1pin@546_polysilicon-1##46 9.85
R3289 net@1809#1pin@546_polysilicon-1##46 net@1809#1pin@546_polysilicon-1##47 9.85
R3290 net@1809#1pin@546_polysilicon-1##47 net@1809#1pin@546_polysilicon-1##48 9.85
R3291 net@1809#1pin@546_polysilicon-1##48 net@1809#1pin@546_polysilicon-1##49 9.85
R3292 net@1809#1pin@546_polysilicon-1##49 net@1809#1pin@546_polysilicon-1##50 9.85
R3293 net@1809#1pin@546_polysilicon-1##50 net@1809#1pin@546_polysilicon-1##51 9.85
R3294 net@1809#1pin@546_polysilicon-1##51 net@1809#1pin@546_polysilicon-1##52 9.85
R3295 net@1809#1pin@546_polysilicon-1##52 net@1809#1pin@546_polysilicon-1##53 9.85
R3296 net@1809#1pin@546_polysilicon-1##53 net@1809#1pin@546_polysilicon-1##54 9.85
R3297 net@1809#1pin@546_polysilicon-1##54 net@1809#1pin@546_polysilicon-1##55 9.85
R3298 net@1809#1pin@546_polysilicon-1##55 net@1809#1pin@546_polysilicon-1##56 9.85
R3299 net@1809#1pin@546_polysilicon-1##56 net@1809#1pin@546_polysilicon-1##57 9.85
R3300 net@1809#1pin@546_polysilicon-1##57 net@1809#1pin@546_polysilicon-1##58 9.85
R3301 net@1809#1pin@546_polysilicon-1##58 net@1809#1pin@546_polysilicon-1##59 9.85
R3302 net@1809#1pin@546_polysilicon-1##59 net@1809#1pin@546_polysilicon-1##60 9.85
R3303 net@1809#1pin@546_polysilicon-1##60 net@1809#2pin@536_metal-1 9.85
R3304 B2#17pmos@84_poly-right B2#17pmos@84_poly-right##0 9.854
R3305 B2#17pmos@84_poly-right##0 B2#17pmos@84_poly-right##1 9.854
R3306 B2#17pmos@84_poly-right##1 B2#17pmos@84_poly-right##2 9.854
R3307 B2#17pmos@84_poly-right##2 B2#17pmos@84_poly-right##3 9.854
R3308 B2#17pmos@84_poly-right##3 B2#17pmos@84_poly-right##4 9.854
R3309 B2#17pmos@84_poly-right##4 B2#17pmos@84_poly-right##5 9.854
R3310 B2#17pmos@84_poly-right##5 B2#17pmos@84_poly-right##6 9.854
R3311 B2#17pmos@84_poly-right##6 B2#17pmos@84_poly-right##7 9.854
R3312 B2#17pmos@84_poly-right##7 B2#17pmos@84_poly-right##8 9.854
R3313 B2#17pmos@84_poly-right##8 B2#17pmos@84_poly-right##9 9.854
R3314 B2#17pmos@84_poly-right##9 B2#17pmos@84_poly-right##10 9.854
R3315 B2#17pmos@84_poly-right##10 B2#17pmos@84_poly-right##11 9.854
R3316 B2#17pmos@84_poly-right##11 B2#17pmos@84_poly-right##12 9.854
R3317 B2#17pmos@84_poly-right##12 B2#17pmos@84_poly-right##13 9.854
R3318 B2#17pmos@84_poly-right##13 B2#17pmos@84_poly-right##14 9.854
R3319 B2#17pmos@84_poly-right##14 B2#17pmos@84_poly-right##15 9.854
R3320 B2#17pmos@84_poly-right##15 B2#17pmos@84_poly-right##16 9.854
R3321 B2#17pmos@84_poly-right##16 B2#17pmos@84_poly-right##17 9.854
R3322 B2#17pmos@84_poly-right##17 B2#17pmos@84_poly-right##18 9.854
R3323 B2#17pmos@84_poly-right##18 B2#17pmos@84_poly-right##19 9.854
R3324 B2#17pmos@84_poly-right##19 B2#17pmos@84_poly-right##20 9.854
R3325 B2#17pmos@84_poly-right##20 B2#17pmos@84_poly-right##21 9.854
R3326 B2#17pmos@84_poly-right##21 B2#17pmos@84_poly-right##22 9.854
R3327 B2#17pmos@84_poly-right##22 B2#17pmos@84_poly-right##23 9.854
R3328 B2#17pmos@84_poly-right##23 B2#17pmos@84_poly-right##24 9.854
R3329 B2#17pmos@84_poly-right##24 B2#17pmos@84_poly-right##25 9.854
R3330 B2#17pmos@84_poly-right##25 B2#17pmos@84_poly-right##26 9.854
R3331 B2#17pmos@84_poly-right##26 B2#17pmos@84_poly-right##27 9.854
R3332 B2#17pmos@84_poly-right##27 B2#17pmos@84_poly-right##28 9.854
R3333 B2#17pmos@84_poly-right##28 B2#17pmos@84_poly-right##29 9.854
R3334 B2#17pmos@84_poly-right##29 B2#17pmos@84_poly-right##30 9.854
R3335 B2#17pmos@84_poly-right##30 B2#17pmos@84_poly-right##31 9.854
R3336 B2#17pmos@84_poly-right##31 B2#17pmos@84_poly-right##32 9.854
R3337 B2#17pmos@84_poly-right##32 B2#17pmos@84_poly-right##33 9.854
R3338 B2#17pmos@84_poly-right##33 B2#17pmos@84_poly-right##34 9.854
R3339 B2#17pmos@84_poly-right##34 B2#17pmos@84_poly-right##35 9.854
R3340 B2#17pmos@84_poly-right##35 B2#17pmos@84_poly-right##36 9.854
R3341 B2#17pmos@84_poly-right##36 B2#17pmos@84_poly-right##37 9.854
R3342 B2#17pmos@84_poly-right##37 B2#17pmos@84_poly-right##38 9.854
R3343 B2#17pmos@84_poly-right##38 B2#17pmos@84_poly-right##39 9.854
R3344 B2#17pmos@84_poly-right##39 B2#17pmos@84_poly-right##40 9.854
R3345 B2#17pmos@84_poly-right##40 B2#17pmos@84_poly-right##41 9.854
R3346 B2#17pmos@84_poly-right##41 B2#17pmos@84_poly-right##42 9.854
R3347 B2#17pmos@84_poly-right##42 B2#17pmos@84_poly-right##43 9.854
R3348 B2#17pmos@84_poly-right##43 B2#17pmos@84_poly-right##44 9.854
R3349 B2#17pmos@84_poly-right##44 B2#17pmos@84_poly-right##45 9.854
R3350 B2#17pmos@84_poly-right##45 B2#17pmos@84_poly-right##46 9.854
R3351 B2#17pmos@84_poly-right##46 B2#17pmos@84_poly-right##47 9.854
R3352 B2#17pmos@84_poly-right##47 B2#17pmos@84_poly-right##48 9.854
R3353 B2#17pmos@84_poly-right##48 B2#17pmos@84_poly-right##49 9.854
R3354 B2#17pmos@84_poly-right##49 B2#17pmos@84_poly-right##50 9.854
R3355 B2#17pmos@84_poly-right##50 B2#17pmos@84_poly-right##51 9.854
R3356 B2#17pmos@84_poly-right##51 B2#17pmos@84_poly-right##52 9.854
R3357 B2#17pmos@84_poly-right##52 B2#17pmos@84_poly-right##53 9.854
R3358 B2#17pmos@84_poly-right##53 B2#17pmos@84_poly-right##54 9.854
R3359 B2#17pmos@84_poly-right##54 B2#12pin@537_polysilicon-1 9.854
R3360 net@1914 net@1914#2contact@579_metal-1-metal-2 4.797
R3361 A2#17nmos@80_poly-right A2#17nmos@80_poly-right##0 9.871
R3362 A2#17nmos@80_poly-right##0 A2#17nmos@80_poly-right##1 9.871
R3363 A2#17nmos@80_poly-right##1 A2#17nmos@80_poly-right##2 9.871
R3364 A2#17nmos@80_poly-right##2 A2#17nmos@80_poly-right##3 9.871
R3365 A2#17nmos@80_poly-right##3 A2#17nmos@80_poly-right##4 9.871
R3366 A2#17nmos@80_poly-right##4 A2#17nmos@80_poly-right##5 9.871
R3367 A2#17nmos@80_poly-right##5 A2#17nmos@80_poly-right##6 9.871
R3368 A2#17nmos@80_poly-right##6 A2#17nmos@80_poly-right##7 9.871
R3369 A2#17nmos@80_poly-right##7 A2#17nmos@80_poly-right##8 9.871
R3370 A2#17nmos@80_poly-right##8 A2#17nmos@80_poly-right##9 9.871
R3371 A2#17nmos@80_poly-right##9 A2#17nmos@80_poly-right##10 9.871
R3372 A2#17nmos@80_poly-right##10 A2#17nmos@80_poly-right##11 9.871
R3373 A2#17nmos@80_poly-right##11 A2#17nmos@80_poly-right##12 9.871
R3374 A2#17nmos@80_poly-right##12 A2#17nmos@80_poly-right##13 9.871
R3375 A2#17nmos@80_poly-right##13 A2#17nmos@80_poly-right##14 9.871
R3376 A2#17nmos@80_poly-right##14 A2#17nmos@80_poly-right##15 9.871
R3377 A2#17nmos@80_poly-right##15 A2#17nmos@80_poly-right##16 9.871
R3378 A2#17nmos@80_poly-right##16 A2#17nmos@80_poly-right##17 9.871
R3379 A2#17nmos@80_poly-right##17 A2#17nmos@80_poly-right##18 9.871
R3380 A2#17nmos@80_poly-right##18 A2#17nmos@80_poly-right##19 9.871
R3381 A2#17nmos@80_poly-right##19 A2#17nmos@80_poly-right##20 9.871
R3382 A2#17nmos@80_poly-right##20 A2#17nmos@80_poly-right##21 9.871
R3383 A2#17nmos@80_poly-right##21 A2#17nmos@80_poly-right##22 9.871
R3384 A2#17nmos@80_poly-right##22 A2#17nmos@80_poly-right##23 9.871
R3385 A2#17nmos@80_poly-right##23 A2#17nmos@80_poly-right##24 9.871
R3386 A2#17nmos@80_poly-right##24 A2#17nmos@80_poly-right##25 9.871
R3387 A2#17nmos@80_poly-right##25 A2#17nmos@80_poly-right##26 9.871
R3388 A2#17nmos@80_poly-right##26 A2#17nmos@80_poly-right##27 9.871
R3389 A2#17nmos@80_poly-right##27 A2#17nmos@80_poly-right##28 9.871
R3390 A2#17nmos@80_poly-right##28 A2#17nmos@80_poly-right##29 9.871
R3391 A2#17nmos@80_poly-right##29 A2#17nmos@80_poly-right##30 9.871
R3392 A2#17nmos@80_poly-right##30 A2#17nmos@80_poly-right##31 9.871
R3393 A2#17nmos@80_poly-right##31 A2#17nmos@80_poly-right##32 9.871
R3394 A2#17nmos@80_poly-right##32 A2#17nmos@80_poly-right##33 9.871
R3395 A2#17nmos@80_poly-right##33 A2#17nmos@80_poly-right##34 9.871
R3396 A2#17nmos@80_poly-right##34 A2#17nmos@80_poly-right##35 9.871
R3397 A2#17nmos@80_poly-right##35 A2#17nmos@80_poly-right##36 9.871
R3398 A2#17nmos@80_poly-right##36 A2#17nmos@80_poly-right##37 9.871
R3399 A2#17nmos@80_poly-right##37 A2#17nmos@80_poly-right##38 9.871
R3400 A2#17nmos@80_poly-right##38 A2#17nmos@80_poly-right##39 9.871
R3401 A2#17nmos@80_poly-right##39 A2#17nmos@80_poly-right##40 9.871
R3402 A2#17nmos@80_poly-right##40 A2#17nmos@80_poly-right##41 9.871
R3403 A2#17nmos@80_poly-right##41 A2#17nmos@80_poly-right##42 9.871
R3404 A2#17nmos@80_poly-right##42 A2#17nmos@80_poly-right##43 9.871
R3405 A2#17nmos@80_poly-right##43 A2#17nmos@80_poly-right##44 9.871
R3406 A2#17nmos@80_poly-right##44 A2#17nmos@80_poly-right##45 9.871
R3407 A2#17nmos@80_poly-right##45 A2#17nmos@80_poly-right##46 9.871
R3408 A2#17nmos@80_poly-right##46 A2#17nmos@80_poly-right##47 9.871
R3409 A2#17nmos@80_poly-right##47 A2#17nmos@80_poly-right##48 9.871
R3410 A2#17nmos@80_poly-right##48 A2#17nmos@80_poly-right##49 9.871
R3411 A2#17nmos@80_poly-right##49 A2#17nmos@80_poly-right##50 9.871
R3412 A2#17nmos@80_poly-right##50 A2#17nmos@80_poly-right##51 9.871
R3413 A2#17nmos@80_poly-right##51 A2#17nmos@80_poly-right##52 9.871
R3414 A2#17nmos@80_poly-right##52 A2#17nmos@80_poly-right##53 9.871
R3415 A2#17nmos@80_poly-right##53 A2#17nmos@80_poly-right##54 9.871
R3416 A2#17nmos@80_poly-right##54 A2#17nmos@80_poly-right##55 9.871
R3417 A2#17nmos@80_poly-right##55 A2#12pmos@80_poly-left 9.871
R3418 net@1809#7pmos@81_poly-left net@1809#7pmos@81_poly-left##0 9.871
R3419 net@1809#7pmos@81_poly-left##0 net@1809#7pmos@81_poly-left##1 9.871
R3420 net@1809#7pmos@81_poly-left##1 net@1809#7pmos@81_poly-left##2 9.871
R3421 net@1809#7pmos@81_poly-left##2 net@1809#7pmos@81_poly-left##3 9.871
R3422 net@1809#7pmos@81_poly-left##3 net@1809#7pmos@81_poly-left##4 9.871
R3423 net@1809#7pmos@81_poly-left##4 net@1809#7pmos@81_poly-left##5 9.871
R3424 net@1809#7pmos@81_poly-left##5 net@1809#7pmos@81_poly-left##6 9.871
R3425 net@1809#7pmos@81_poly-left##6 net@1809#7pmos@81_poly-left##7 9.871
R3426 net@1809#7pmos@81_poly-left##7 net@1809#7pmos@81_poly-left##8 9.871
R3427 net@1809#7pmos@81_poly-left##8 net@1809#7pmos@81_poly-left##9 9.871
R3428 net@1809#7pmos@81_poly-left##9 net@1809#7pmos@81_poly-left##10 9.871
R3429 net@1809#7pmos@81_poly-left##10 net@1809#7pmos@81_poly-left##11 9.871
R3430 net@1809#7pmos@81_poly-left##11 net@1809#7pmos@81_poly-left##12 9.871
R3431 net@1809#7pmos@81_poly-left##12 net@1809#7pmos@81_poly-left##13 9.871
R3432 net@1809#7pmos@81_poly-left##13 net@1809#7pmos@81_poly-left##14 9.871
R3433 net@1809#7pmos@81_poly-left##14 net@1809#7pmos@81_poly-left##15 9.871
R3434 net@1809#7pmos@81_poly-left##15 net@1809#7pmos@81_poly-left##16 9.871
R3435 net@1809#7pmos@81_poly-left##16 net@1809#7pmos@81_poly-left##17 9.871
R3436 net@1809#7pmos@81_poly-left##17 net@1809#7pmos@81_poly-left##18 9.871
R3437 net@1809#7pmos@81_poly-left##18 net@1809#7pmos@81_poly-left##19 9.871
R3438 net@1809#7pmos@81_poly-left##19 net@1809#7pmos@81_poly-left##20 9.871
R3439 net@1809#7pmos@81_poly-left##20 net@1809#7pmos@81_poly-left##21 9.871
R3440 net@1809#7pmos@81_poly-left##21 net@1809#7pmos@81_poly-left##22 9.871
R3441 net@1809#7pmos@81_poly-left##22 net@1809#7pmos@81_poly-left##23 9.871
R3442 net@1809#7pmos@81_poly-left##23 net@1809#7pmos@81_poly-left##24 9.871
R3443 net@1809#7pmos@81_poly-left##24 net@1809#7pmos@81_poly-left##25 9.871
R3444 net@1809#7pmos@81_poly-left##25 net@1809#7pmos@81_poly-left##26 9.871
R3445 net@1809#7pmos@81_poly-left##26 net@1809#7pmos@81_poly-left##27 9.871
R3446 net@1809#7pmos@81_poly-left##27 net@1809#7pmos@81_poly-left##28 9.871
R3447 net@1809#7pmos@81_poly-left##28 net@1809#7pmos@81_poly-left##29 9.871
R3448 net@1809#7pmos@81_poly-left##29 net@1809#7pmos@81_poly-left##30 9.871
R3449 net@1809#7pmos@81_poly-left##30 net@1809#7pmos@81_poly-left##31 9.871
R3450 net@1809#7pmos@81_poly-left##31 net@1809#7pmos@81_poly-left##32 9.871
R3451 net@1809#7pmos@81_poly-left##32 net@1809#7pmos@81_poly-left##33 9.871
R3452 net@1809#7pmos@81_poly-left##33 net@1809#7pmos@81_poly-left##34 9.871
R3453 net@1809#7pmos@81_poly-left##34 net@1809#7pmos@81_poly-left##35 9.871
R3454 net@1809#7pmos@81_poly-left##35 net@1809#7pmos@81_poly-left##36 9.871
R3455 net@1809#7pmos@81_poly-left##36 net@1809#7pmos@81_poly-left##37 9.871
R3456 net@1809#7pmos@81_poly-left##37 net@1809#7pmos@81_poly-left##38 9.871
R3457 net@1809#7pmos@81_poly-left##38 net@1809#7pmos@81_poly-left##39 9.871
R3458 net@1809#7pmos@81_poly-left##39 net@1809#7pmos@81_poly-left##40 9.871
R3459 net@1809#7pmos@81_poly-left##40 net@1809#7pmos@81_poly-left##41 9.871
R3460 net@1809#7pmos@81_poly-left##41 net@1809#7pmos@81_poly-left##42 9.871
R3461 net@1809#7pmos@81_poly-left##42 net@1809#7pmos@81_poly-left##43 9.871
R3462 net@1809#7pmos@81_poly-left##43 net@1809#7pmos@81_poly-left##44 9.871
R3463 net@1809#7pmos@81_poly-left##44 net@1809#7pmos@81_poly-left##45 9.871
R3464 net@1809#7pmos@81_poly-left##45 net@1809#7pmos@81_poly-left##46 9.871
R3465 net@1809#7pmos@81_poly-left##46 net@1809#7pmos@81_poly-left##47 9.871
R3466 net@1809#7pmos@81_poly-left##47 net@1809#7pmos@81_poly-left##48 9.871
R3467 net@1809#7pmos@81_poly-left##48 net@1809#7pmos@81_poly-left##49 9.871
R3468 net@1809#7pmos@81_poly-left##49 net@1809#7pmos@81_poly-left##50 9.871
R3469 net@1809#7pmos@81_poly-left##50 net@1809#7pmos@81_poly-left##51 9.871
R3470 net@1809#7pmos@81_poly-left##51 net@1809#7pmos@81_poly-left##52 9.871
R3471 net@1809#7pmos@81_poly-left##52 net@1809#7pmos@81_poly-left##53 9.871
R3472 net@1809#7pmos@81_poly-left##53 net@1809#7pmos@81_poly-left##54 9.871
R3473 net@1809#7pmos@81_poly-left##54 net@1809#7pmos@81_poly-left##55 9.871
R3474 net@1809#7pmos@81_poly-left##55 net@1809#11nmos@81_poly-right 9.871
R3475 B2#18pmos@82_poly-right B2#18pmos@82_poly-right##0 9.871
R3476 B2#18pmos@82_poly-right##0 B2#18pmos@82_poly-right##1 9.871
R3477 B2#18pmos@82_poly-right##1 B2#18pmos@82_poly-right##2 9.871
R3478 B2#18pmos@82_poly-right##2 B2#18pmos@82_poly-right##3 9.871
R3479 B2#18pmos@82_poly-right##3 B2#18pmos@82_poly-right##4 9.871
R3480 B2#18pmos@82_poly-right##4 B2#18pmos@82_poly-right##5 9.871
R3481 B2#18pmos@82_poly-right##5 B2#18pmos@82_poly-right##6 9.871
R3482 B2#18pmos@82_poly-right##6 B2#18pmos@82_poly-right##7 9.871
R3483 B2#18pmos@82_poly-right##7 B2#18pmos@82_poly-right##8 9.871
R3484 B2#18pmos@82_poly-right##8 B2#18pmos@82_poly-right##9 9.871
R3485 B2#18pmos@82_poly-right##9 B2#18pmos@82_poly-right##10 9.871
R3486 B2#18pmos@82_poly-right##10 B2#18pmos@82_poly-right##11 9.871
R3487 B2#18pmos@82_poly-right##11 B2#18pmos@82_poly-right##12 9.871
R3488 B2#18pmos@82_poly-right##12 B2#18pmos@82_poly-right##13 9.871
R3489 B2#18pmos@82_poly-right##13 B2#18pmos@82_poly-right##14 9.871
R3490 B2#18pmos@82_poly-right##14 B2#18pmos@82_poly-right##15 9.871
R3491 B2#18pmos@82_poly-right##15 B2#18pmos@82_poly-right##16 9.871
R3492 B2#18pmos@82_poly-right##16 B2#18pmos@82_poly-right##17 9.871
R3493 B2#18pmos@82_poly-right##17 B2#18pmos@82_poly-right##18 9.871
R3494 B2#18pmos@82_poly-right##18 B2#18pmos@82_poly-right##19 9.871
R3495 B2#18pmos@82_poly-right##19 B2#18pmos@82_poly-right##20 9.871
R3496 B2#18pmos@82_poly-right##20 B2#18pmos@82_poly-right##21 9.871
R3497 B2#18pmos@82_poly-right##21 B2#18pmos@82_poly-right##22 9.871
R3498 B2#18pmos@82_poly-right##22 B2#18pmos@82_poly-right##23 9.871
R3499 B2#18pmos@82_poly-right##23 B2#18pmos@82_poly-right##24 9.871
R3500 B2#18pmos@82_poly-right##24 B2#18pmos@82_poly-right##25 9.871
R3501 B2#18pmos@82_poly-right##25 B2#18pmos@82_poly-right##26 9.871
R3502 B2#18pmos@82_poly-right##26 B2#18pmos@82_poly-right##27 9.871
R3503 B2#18pmos@82_poly-right##27 B2#18pmos@82_poly-right##28 9.871
R3504 B2#18pmos@82_poly-right##28 B2#18pmos@82_poly-right##29 9.871
R3505 B2#18pmos@82_poly-right##29 B2#18pmos@82_poly-right##30 9.871
R3506 B2#18pmos@82_poly-right##30 B2#18pmos@82_poly-right##31 9.871
R3507 B2#18pmos@82_poly-right##31 B2#18pmos@82_poly-right##32 9.871
R3508 B2#18pmos@82_poly-right##32 B2#18pmos@82_poly-right##33 9.871
R3509 B2#18pmos@82_poly-right##33 B2#18pmos@82_poly-right##34 9.871
R3510 B2#18pmos@82_poly-right##34 B2#18pmos@82_poly-right##35 9.871
R3511 B2#18pmos@82_poly-right##35 B2#18pmos@82_poly-right##36 9.871
R3512 B2#18pmos@82_poly-right##36 B2#18pmos@82_poly-right##37 9.871
R3513 B2#18pmos@82_poly-right##37 B2#18pmos@82_poly-right##38 9.871
R3514 B2#18pmos@82_poly-right##38 B2#18pmos@82_poly-right##39 9.871
R3515 B2#18pmos@82_poly-right##39 B2#18pmos@82_poly-right##40 9.871
R3516 B2#18pmos@82_poly-right##40 B2#18pmos@82_poly-right##41 9.871
R3517 B2#18pmos@82_poly-right##41 B2#18pmos@82_poly-right##42 9.871
R3518 B2#18pmos@82_poly-right##42 B2#18pmos@82_poly-right##43 9.871
R3519 B2#18pmos@82_poly-right##43 B2#18pmos@82_poly-right##44 9.871
R3520 B2#18pmos@82_poly-right##44 B2#18pmos@82_poly-right##45 9.871
R3521 B2#18pmos@82_poly-right##45 B2#18pmos@82_poly-right##46 9.871
R3522 B2#18pmos@82_poly-right##46 B2#18pmos@82_poly-right##47 9.871
R3523 B2#18pmos@82_poly-right##47 B2#18pmos@82_poly-right##48 9.871
R3524 B2#18pmos@82_poly-right##48 B2#18pmos@82_poly-right##49 9.871
R3525 B2#18pmos@82_poly-right##49 B2#18pmos@82_poly-right##50 9.871
R3526 B2#18pmos@82_poly-right##50 B2#18pmos@82_poly-right##51 9.871
R3527 B2#18pmos@82_poly-right##51 B2#18pmos@82_poly-right##52 9.871
R3528 B2#18pmos@82_poly-right##52 B2#18pmos@82_poly-right##53 9.871
R3529 B2#18pmos@82_poly-right##53 B2#18pmos@82_poly-right##54 9.871
R3530 B2#18pmos@82_poly-right##54 B2#18pmos@82_poly-right##55 9.871
R3531 B2#18pmos@82_poly-right##55 B2#16nmos@82_poly-left 9.871
R3532 net@1914#14pmos@83_poly-right net@1914#14pmos@83_poly-right##0 9.871
R3533 net@1914#14pmos@83_poly-right##0 net@1914#14pmos@83_poly-right##1 9.871
R3534 net@1914#14pmos@83_poly-right##1 net@1914#14pmos@83_poly-right##2 9.871
R3535 net@1914#14pmos@83_poly-right##2 net@1914#14pmos@83_poly-right##3 9.871
R3536 net@1914#14pmos@83_poly-right##3 net@1914#14pmos@83_poly-right##4 9.871
R3537 net@1914#14pmos@83_poly-right##4 net@1914#14pmos@83_poly-right##5 9.871
R3538 net@1914#14pmos@83_poly-right##5 net@1914#14pmos@83_poly-right##6 9.871
R3539 net@1914#14pmos@83_poly-right##6 net@1914#14pmos@83_poly-right##7 9.871
R3540 net@1914#14pmos@83_poly-right##7 net@1914#14pmos@83_poly-right##8 9.871
R3541 net@1914#14pmos@83_poly-right##8 net@1914#14pmos@83_poly-right##9 9.871
R3542 net@1914#14pmos@83_poly-right##9 net@1914#14pmos@83_poly-right##10 9.871
R3543 net@1914#14pmos@83_poly-right##10 net@1914#14pmos@83_poly-right##11 9.871
R3544 net@1914#14pmos@83_poly-right##11 net@1914#14pmos@83_poly-right##12 9.871
R3545 net@1914#14pmos@83_poly-right##12 net@1914#14pmos@83_poly-right##13 9.871
R3546 net@1914#14pmos@83_poly-right##13 net@1914#14pmos@83_poly-right##14 9.871
R3547 net@1914#14pmos@83_poly-right##14 net@1914#14pmos@83_poly-right##15 9.871
R3548 net@1914#14pmos@83_poly-right##15 net@1914#14pmos@83_poly-right##16 9.871
R3549 net@1914#14pmos@83_poly-right##16 net@1914#14pmos@83_poly-right##17 9.871
R3550 net@1914#14pmos@83_poly-right##17 net@1914#14pmos@83_poly-right##18 9.871
R3551 net@1914#14pmos@83_poly-right##18 net@1914#14pmos@83_poly-right##19 9.871
R3552 net@1914#14pmos@83_poly-right##19 net@1914#14pmos@83_poly-right##20 9.871
R3553 net@1914#14pmos@83_poly-right##20 net@1914#14pmos@83_poly-right##21 9.871
R3554 net@1914#14pmos@83_poly-right##21 net@1914#14pmos@83_poly-right##22 9.871
R3555 net@1914#14pmos@83_poly-right##22 net@1914#14pmos@83_poly-right##23 9.871
R3556 net@1914#14pmos@83_poly-right##23 net@1914#14pmos@83_poly-right##24 9.871
R3557 net@1914#14pmos@83_poly-right##24 net@1914#14pmos@83_poly-right##25 9.871
R3558 net@1914#14pmos@83_poly-right##25 net@1914#14pmos@83_poly-right##26 9.871
R3559 net@1914#14pmos@83_poly-right##26 net@1914#14pmos@83_poly-right##27 9.871
R3560 net@1914#14pmos@83_poly-right##27 net@1914#14pmos@83_poly-right##28 9.871
R3561 net@1914#14pmos@83_poly-right##28 net@1914#14pmos@83_poly-right##29 9.871
R3562 net@1914#14pmos@83_poly-right##29 net@1914#14pmos@83_poly-right##30 9.871
R3563 net@1914#14pmos@83_poly-right##30 net@1914#14pmos@83_poly-right##31 9.871
R3564 net@1914#14pmos@83_poly-right##31 net@1914#14pmos@83_poly-right##32 9.871
R3565 net@1914#14pmos@83_poly-right##32 net@1914#14pmos@83_poly-right##33 9.871
R3566 net@1914#14pmos@83_poly-right##33 net@1914#14pmos@83_poly-right##34 9.871
R3567 net@1914#14pmos@83_poly-right##34 net@1914#14pmos@83_poly-right##35 9.871
R3568 net@1914#14pmos@83_poly-right##35 net@1914#14pmos@83_poly-right##36 9.871
R3569 net@1914#14pmos@83_poly-right##36 net@1914#14pmos@83_poly-right##37 9.871
R3570 net@1914#14pmos@83_poly-right##37 net@1914#14pmos@83_poly-right##38 9.871
R3571 net@1914#14pmos@83_poly-right##38 net@1914#14pmos@83_poly-right##39 9.871
R3572 net@1914#14pmos@83_poly-right##39 net@1914#14pmos@83_poly-right##40 9.871
R3573 net@1914#14pmos@83_poly-right##40 net@1914#14pmos@83_poly-right##41 9.871
R3574 net@1914#14pmos@83_poly-right##41 net@1914#14pmos@83_poly-right##42 9.871
R3575 net@1914#14pmos@83_poly-right##42 net@1914#14pmos@83_poly-right##43 9.871
R3576 net@1914#14pmos@83_poly-right##43 net@1914#14pmos@83_poly-right##44 9.871
R3577 net@1914#14pmos@83_poly-right##44 net@1914#14pmos@83_poly-right##45 9.871
R3578 net@1914#14pmos@83_poly-right##45 net@1914#14pmos@83_poly-right##46 9.871
R3579 net@1914#14pmos@83_poly-right##46 net@1914#14pmos@83_poly-right##47 9.871
R3580 net@1914#14pmos@83_poly-right##47 net@1914#14pmos@83_poly-right##48 9.871
R3581 net@1914#14pmos@83_poly-right##48 net@1914#14pmos@83_poly-right##49 9.871
R3582 net@1914#14pmos@83_poly-right##49 net@1914#14pmos@83_poly-right##50 9.871
R3583 net@1914#14pmos@83_poly-right##50 net@1914#14pmos@83_poly-right##51 9.871
R3584 net@1914#14pmos@83_poly-right##51 net@1914#14pmos@83_poly-right##52 9.871
R3585 net@1914#14pmos@83_poly-right##52 net@1914#14pmos@83_poly-right##53 9.871
R3586 net@1914#14pmos@83_poly-right##53 net@1914#14pmos@83_poly-right##54 9.871
R3587 net@1914#14pmos@83_poly-right##54 net@1914#14pmos@83_poly-right##55 9.871
R3588 net@1914#14pmos@83_poly-right##55 net@1914#9nmos@83_poly-left 9.871
R3589 net@1907#2contact@603_metal-1-polysilicon-1 net@1907 4.706
R3590 net@1907#12pmos@86_poly-right net@1907#12pmos@86_poly-right##0 9.864
R3591 net@1907#12pmos@86_poly-right##0 net@1907#12pmos@86_poly-right##1 9.864
R3592 net@1907#12pmos@86_poly-right##1 net@1907#12pmos@86_poly-right##2 9.864
R3593 net@1907#12pmos@86_poly-right##2 net@1907#12pmos@86_poly-right##3 9.864
R3594 net@1907#12pmos@86_poly-right##3 net@1907#12pmos@86_poly-right##4 9.864
R3595 net@1907#12pmos@86_poly-right##4 net@1907#12pmos@86_poly-right##5 9.864
R3596 net@1907#12pmos@86_poly-right##5 net@1907#12pmos@86_poly-right##6 9.864
R3597 net@1907#12pmos@86_poly-right##6 net@1907#12pmos@86_poly-right##7 9.864
R3598 net@1907#12pmos@86_poly-right##7 net@1907#12pmos@86_poly-right##8 9.864
R3599 net@1907#12pmos@86_poly-right##8 net@1907#12pmos@86_poly-right##9 9.864
R3600 net@1907#12pmos@86_poly-right##9 net@1907#12pmos@86_poly-right##10 9.864
R3601 net@1907#12pmos@86_poly-right##10 net@1907#12pmos@86_poly-right##11 9.864
R3602 net@1907#12pmos@86_poly-right##11 net@1907#12pmos@86_poly-right##12 9.864
R3603 net@1907#12pmos@86_poly-right##12 net@1907#12pmos@86_poly-right##13 9.864
R3604 net@1907#12pmos@86_poly-right##13 net@1907#12pmos@86_poly-right##14 9.864
R3605 net@1907#12pmos@86_poly-right##14 net@1907#12pmos@86_poly-right##15 9.864
R3606 net@1907#12pmos@86_poly-right##15 net@1907#12pmos@86_poly-right##16 9.864
R3607 net@1907#12pmos@86_poly-right##16 net@1907#12pmos@86_poly-right##17 9.864
R3608 net@1907#12pmos@86_poly-right##17 net@1907#12pmos@86_poly-right##18 9.864
R3609 net@1907#12pmos@86_poly-right##18 net@1907#12pmos@86_poly-right##19 9.864
R3610 net@1907#12pmos@86_poly-right##19 net@1907#12pmos@86_poly-right##20 9.864
R3611 net@1907#12pmos@86_poly-right##20 net@1907#12pmos@86_poly-right##21 9.864
R3612 net@1907#12pmos@86_poly-right##21 net@1907#12pmos@86_poly-right##22 9.864
R3613 net@1907#12pmos@86_poly-right##22 net@1907#12pmos@86_poly-right##23 9.864
R3614 net@1907#12pmos@86_poly-right##23 net@1907#12pmos@86_poly-right##24 9.864
R3615 net@1907#12pmos@86_poly-right##24 net@1907#12pmos@86_poly-right##25 9.864
R3616 net@1907#12pmos@86_poly-right##25 net@1907#12pmos@86_poly-right##26 9.864
R3617 net@1907#12pmos@86_poly-right##26 net@1907#12pmos@86_poly-right##27 9.864
R3618 net@1907#12pmos@86_poly-right##27 net@1907#12pmos@86_poly-right##28 9.864
R3619 net@1907#12pmos@86_poly-right##28 net@1907#12pmos@86_poly-right##29 9.864
R3620 net@1907#12pmos@86_poly-right##29 net@1907#12pmos@86_poly-right##30 9.864
R3621 net@1907#12pmos@86_poly-right##30 net@1907#12pmos@86_poly-right##31 9.864
R3622 net@1907#12pmos@86_poly-right##31 net@1907#12pmos@86_poly-right##32 9.864
R3623 net@1907#12pmos@86_poly-right##32 net@1907#12pmos@86_poly-right##33 9.864
R3624 net@1907#12pmos@86_poly-right##33 net@1907#12pmos@86_poly-right##34 9.864
R3625 net@1907#12pmos@86_poly-right##34 net@1907#12pmos@86_poly-right##35 9.864
R3626 net@1907#12pmos@86_poly-right##35 net@1907#12pmos@86_poly-right##36 9.864
R3627 net@1907#12pmos@86_poly-right##36 net@1907#12pmos@86_poly-right##37 9.864
R3628 net@1907#12pmos@86_poly-right##37 net@1907#12pmos@86_poly-right##38 9.864
R3629 net@1907#12pmos@86_poly-right##38 net@1907#12pmos@86_poly-right##39 9.864
R3630 net@1907#12pmos@86_poly-right##39 net@1907#12pmos@86_poly-right##40 9.864
R3631 net@1907#12pmos@86_poly-right##40 net@1907#12pmos@86_poly-right##41 9.864
R3632 net@1907#12pmos@86_poly-right##41 net@1907#12pmos@86_poly-right##42 9.864
R3633 net@1907#12pmos@86_poly-right##42 net@1907#12pmos@86_poly-right##43 9.864
R3634 net@1907#12pmos@86_poly-right##43 net@1907#12pmos@86_poly-right##44 9.864
R3635 net@1907#12pmos@86_poly-right##44 net@1907#12pmos@86_poly-right##45 9.864
R3636 net@1907#12pmos@86_poly-right##45 net@1907#12pmos@86_poly-right##46 9.864
R3637 net@1907#12pmos@86_poly-right##46 net@1907#12pmos@86_poly-right##47 9.864
R3638 net@1907#12pmos@86_poly-right##47 net@1907#12pmos@86_poly-right##48 9.864
R3639 net@1907#12pmos@86_poly-right##48 net@1907#12pmos@86_poly-right##49 9.864
R3640 net@1907#12pmos@86_poly-right##49 net@1907#12pmos@86_poly-right##50 9.864
R3641 net@1907#12pmos@86_poly-right##50 net@1907#12pmos@86_poly-right##51 9.864
R3642 net@1907#12pmos@86_poly-right##51 net@1907#12pmos@86_poly-right##52 9.864
R3643 net@1907#12pmos@86_poly-right##52 net@1907#12pmos@86_poly-right##53 9.864
R3644 net@1907#12pmos@86_poly-right##53 net@1907#5pin@539_polysilicon-1 9.864
R3645 XOR1_to_NAND3#22pmos@86_diff-top XOR1_to_NAND3#1contact@656_metal-1-metal-2 4.862
R3646 XOR1_to_NAND3#3pin@572_polysilicon-1 XOR1_to_NAND3#3pin@572_polysilicon-1##0 9.881
R3647 XOR1_to_NAND3#3pin@572_polysilicon-1##0 XOR1_to_NAND3#3pin@572_polysilicon-1##1 9.881
R3648 XOR1_to_NAND3#3pin@572_polysilicon-1##1 XOR1_to_NAND3#3pin@572_polysilicon-1##2 9.881
R3649 XOR1_to_NAND3#3pin@572_polysilicon-1##2 XOR1_to_NAND3#3pin@572_polysilicon-1##3 9.881
R3650 XOR1_to_NAND3#3pin@572_polysilicon-1##3 XOR1_to_NAND3#3pin@572_polysilicon-1##4 9.881
R3651 XOR1_to_NAND3#3pin@572_polysilicon-1##4 XOR1_to_NAND3#3pin@572_polysilicon-1##5 9.881
R3652 XOR1_to_NAND3#3pin@572_polysilicon-1##5 XOR1_to_NAND3#3pin@572_polysilicon-1##6 9.881
R3653 XOR1_to_NAND3#3pin@572_polysilicon-1##6 XOR1_to_NAND3#3pin@572_polysilicon-1##7 9.881
R3654 XOR1_to_NAND3#3pin@572_polysilicon-1##7 XOR1_to_NAND3#3pin@572_polysilicon-1##8 9.881
R3655 XOR1_to_NAND3#3pin@572_polysilicon-1##8 XOR1_to_NAND3#3pin@572_polysilicon-1##9 9.881
R3656 XOR1_to_NAND3#3pin@572_polysilicon-1##9 XOR1_to_NAND3#3pin@572_polysilicon-1##10 9.881
R3657 XOR1_to_NAND3#3pin@572_polysilicon-1##10 XOR1_to_NAND3#3pin@572_polysilicon-1##11 9.881
R3658 XOR1_to_NAND3#3pin@572_polysilicon-1##11 XOR1_to_NAND3#3pin@572_polysilicon-1##12 9.881
R3659 XOR1_to_NAND3#3pin@572_polysilicon-1##12 XOR1_to_NAND3#3pin@572_polysilicon-1##13 9.881
R3660 XOR1_to_NAND3#3pin@572_polysilicon-1##13 XOR1_to_NAND3#3pin@572_polysilicon-1##14 9.881
R3661 XOR1_to_NAND3#3pin@572_polysilicon-1##14 XOR1_to_NAND3#3pin@572_polysilicon-1##15 9.881
R3662 XOR1_to_NAND3#3pin@572_polysilicon-1##15 XOR1_to_NAND3#3pin@572_polysilicon-1##16 9.881
R3663 XOR1_to_NAND3#3pin@572_polysilicon-1##16 XOR1_to_NAND3#3pin@572_polysilicon-1##17 9.881
R3664 XOR1_to_NAND3#3pin@572_polysilicon-1##17 XOR1_to_NAND3#3pin@572_polysilicon-1##18 9.881
R3665 XOR1_to_NAND3#3pin@572_polysilicon-1##18 XOR1_to_NAND3#3pin@572_polysilicon-1##19 9.881
R3666 XOR1_to_NAND3#3pin@572_polysilicon-1##19 XOR1_to_NAND3#3pin@572_polysilicon-1##20 9.881
R3667 XOR1_to_NAND3#3pin@572_polysilicon-1##20 XOR1_to_NAND3#3pin@572_polysilicon-1##21 9.881
R3668 XOR1_to_NAND3#3pin@572_polysilicon-1##21 XOR1_to_NAND3#3pin@572_polysilicon-1##22 9.881
R3669 XOR1_to_NAND3#3pin@572_polysilicon-1##22 XOR1_to_NAND3#3pin@572_polysilicon-1##23 9.881
R3670 XOR1_to_NAND3#3pin@572_polysilicon-1##23 XOR1_to_NAND3#3pin@572_polysilicon-1##24 9.881
R3671 XOR1_to_NAND3#3pin@572_polysilicon-1##24 XOR1_to_NAND3#3pin@572_polysilicon-1##25 9.881
R3672 XOR1_to_NAND3#3pin@572_polysilicon-1##25 XOR1_to_NAND3#3pin@572_polysilicon-1##26 9.881
R3673 XOR1_to_NAND3#3pin@572_polysilicon-1##26 XOR1_to_NAND3#3pin@572_polysilicon-1##27 9.881
R3674 XOR1_to_NAND3#3pin@572_polysilicon-1##27 XOR1_to_NAND3#3pin@572_polysilicon-1##28 9.881
R3675 XOR1_to_NAND3#3pin@572_polysilicon-1##28 XOR1_to_NAND3#3pin@572_polysilicon-1##29 9.881
R3676 XOR1_to_NAND3#3pin@572_polysilicon-1##29 XOR1_to_NAND3#3pin@572_polysilicon-1##30 9.881
R3677 XOR1_to_NAND3#3pin@572_polysilicon-1##30 XOR1_to_NAND3#3pin@572_polysilicon-1##31 9.881
R3678 XOR1_to_NAND3#3pin@572_polysilicon-1##31 XOR1_to_NAND3#3pin@572_polysilicon-1##32 9.881
R3679 XOR1_to_NAND3#3pin@572_polysilicon-1##32 XOR1_to_NAND3#3pin@572_polysilicon-1##33 9.881
R3680 XOR1_to_NAND3#3pin@572_polysilicon-1##33 XOR1_to_NAND3#3pin@572_polysilicon-1##34 9.881
R3681 XOR1_to_NAND3#3pin@572_polysilicon-1##34 XOR1_to_NAND3#3pin@572_polysilicon-1##35 9.881
R3682 XOR1_to_NAND3#3pin@572_polysilicon-1##35 XOR1_to_NAND3#3pin@572_polysilicon-1##36 9.881
R3683 XOR1_to_NAND3#3pin@572_polysilicon-1##36 XOR1_to_NAND3#3pin@572_polysilicon-1##37 9.881
R3684 XOR1_to_NAND3#3pin@572_polysilicon-1##37 XOR1_to_NAND3#3pin@572_polysilicon-1##38 9.881
R3685 XOR1_to_NAND3#3pin@572_polysilicon-1##38 XOR1_to_NAND3#3pin@572_polysilicon-1##39 9.881
R3686 XOR1_to_NAND3#3pin@572_polysilicon-1##39 XOR1_to_NAND3#3pin@572_polysilicon-1##40 9.881
R3687 XOR1_to_NAND3#3pin@572_polysilicon-1##40 XOR1_to_NAND3#3pin@572_polysilicon-1##41 9.881
R3688 XOR1_to_NAND3#3pin@572_polysilicon-1##41 XOR1_to_NAND3#3pin@572_polysilicon-1##42 9.881
R3689 XOR1_to_NAND3#3pin@572_polysilicon-1##42 XOR1_to_NAND3#3pin@572_polysilicon-1##43 9.881
R3690 XOR1_to_NAND3#3pin@572_polysilicon-1##43 XOR1_to_NAND3#3pin@572_polysilicon-1##44 9.881
R3691 XOR1_to_NAND3#3pin@572_polysilicon-1##44 XOR1_to_NAND3#3pin@572_polysilicon-1##45 9.881
R3692 XOR1_to_NAND3#3pin@572_polysilicon-1##45 XOR1_to_NAND3#3pin@572_polysilicon-1##46 9.881
R3693 XOR1_to_NAND3#3pin@572_polysilicon-1##46 XOR1_to_NAND3#3pin@572_polysilicon-1##47 9.881
R3694 XOR1_to_NAND3#3pin@572_polysilicon-1##47 XOR1_to_NAND3#3pin@572_polysilicon-1##48 9.881
R3695 XOR1_to_NAND3#3pin@572_polysilicon-1##48 XOR1_to_NAND3#3pin@572_polysilicon-1##49 9.881
R3696 XOR1_to_NAND3#3pin@572_polysilicon-1##49 XOR1_to_NAND3#3pin@572_polysilicon-1##50 9.881
R3697 XOR1_to_NAND3#3pin@572_polysilicon-1##50 XOR1_to_NAND3#3pin@572_polysilicon-1##51 9.881
R3698 XOR1_to_NAND3#3pin@572_polysilicon-1##51 XOR1_to_NAND3#3pin@572_polysilicon-1##52 9.881
R3699 XOR1_to_NAND3#3pin@572_polysilicon-1##52 XOR1_to_NAND3#3pin@572_polysilicon-1##53 9.881
R3700 XOR1_to_NAND3#3pin@572_polysilicon-1##53 XOR1_to_NAND3#3pin@572_polysilicon-1##54 9.881
R3701 XOR1_to_NAND3#3pin@572_polysilicon-1##54 XOR1_to_NAND3#24nmos@92_poly-right 9.881
R3702 net@1811#5pmos@92_diff-top net@1811#2pin@561_metal-1 4.81
R3703 net@1811#1pin@571_polysilicon-1 net@1811#1pin@571_polysilicon-1##0 9.85
R3704 net@1811#1pin@571_polysilicon-1##0 net@1811#1pin@571_polysilicon-1##1 9.85
R3705 net@1811#1pin@571_polysilicon-1##1 net@1811#1pin@571_polysilicon-1##2 9.85
R3706 net@1811#1pin@571_polysilicon-1##2 net@1811#1pin@571_polysilicon-1##3 9.85
R3707 net@1811#1pin@571_polysilicon-1##3 net@1811#1pin@571_polysilicon-1##4 9.85
R3708 net@1811#1pin@571_polysilicon-1##4 net@1811#1pin@571_polysilicon-1##5 9.85
R3709 net@1811#1pin@571_polysilicon-1##5 net@1811#1pin@571_polysilicon-1##6 9.85
R3710 net@1811#1pin@571_polysilicon-1##6 net@1811#1pin@571_polysilicon-1##7 9.85
R3711 net@1811#1pin@571_polysilicon-1##7 net@1811#1pin@571_polysilicon-1##8 9.85
R3712 net@1811#1pin@571_polysilicon-1##8 net@1811#1pin@571_polysilicon-1##9 9.85
R3713 net@1811#1pin@571_polysilicon-1##9 net@1811#1pin@571_polysilicon-1##10 9.85
R3714 net@1811#1pin@571_polysilicon-1##10 net@1811#1pin@571_polysilicon-1##11 9.85
R3715 net@1811#1pin@571_polysilicon-1##11 net@1811#1pin@571_polysilicon-1##12 9.85
R3716 net@1811#1pin@571_polysilicon-1##12 net@1811#1pin@571_polysilicon-1##13 9.85
R3717 net@1811#1pin@571_polysilicon-1##13 net@1811#1pin@571_polysilicon-1##14 9.85
R3718 net@1811#1pin@571_polysilicon-1##14 net@1811#1pin@571_polysilicon-1##15 9.85
R3719 net@1811#1pin@571_polysilicon-1##15 net@1811#1pin@571_polysilicon-1##16 9.85
R3720 net@1811#1pin@571_polysilicon-1##16 net@1811#1pin@571_polysilicon-1##17 9.85
R3721 net@1811#1pin@571_polysilicon-1##17 net@1811#1pin@571_polysilicon-1##18 9.85
R3722 net@1811#1pin@571_polysilicon-1##18 net@1811#1pin@571_polysilicon-1##19 9.85
R3723 net@1811#1pin@571_polysilicon-1##19 net@1811#1pin@571_polysilicon-1##20 9.85
R3724 net@1811#1pin@571_polysilicon-1##20 net@1811#1pin@571_polysilicon-1##21 9.85
R3725 net@1811#1pin@571_polysilicon-1##21 net@1811#1pin@571_polysilicon-1##22 9.85
R3726 net@1811#1pin@571_polysilicon-1##22 net@1811#1pin@571_polysilicon-1##23 9.85
R3727 net@1811#1pin@571_polysilicon-1##23 net@1811#1pin@571_polysilicon-1##24 9.85
R3728 net@1811#1pin@571_polysilicon-1##24 net@1811#1pin@571_polysilicon-1##25 9.85
R3729 net@1811#1pin@571_polysilicon-1##25 net@1811#1pin@571_polysilicon-1##26 9.85
R3730 net@1811#1pin@571_polysilicon-1##26 net@1811#1pin@571_polysilicon-1##27 9.85
R3731 net@1811#1pin@571_polysilicon-1##27 net@1811#1pin@571_polysilicon-1##28 9.85
R3732 net@1811#1pin@571_polysilicon-1##28 net@1811#1pin@571_polysilicon-1##29 9.85
R3733 net@1811#1pin@571_polysilicon-1##29 net@1811#1pin@571_polysilicon-1##30 9.85
R3734 net@1811#1pin@571_polysilicon-1##30 net@1811#1pin@571_polysilicon-1##31 9.85
R3735 net@1811#1pin@571_polysilicon-1##31 net@1811#1pin@571_polysilicon-1##32 9.85
R3736 net@1811#1pin@571_polysilicon-1##32 net@1811#1pin@571_polysilicon-1##33 9.85
R3737 net@1811#1pin@571_polysilicon-1##33 net@1811#1pin@571_polysilicon-1##34 9.85
R3738 net@1811#1pin@571_polysilicon-1##34 net@1811#1pin@571_polysilicon-1##35 9.85
R3739 net@1811#1pin@571_polysilicon-1##35 net@1811#1pin@571_polysilicon-1##36 9.85
R3740 net@1811#1pin@571_polysilicon-1##36 net@1811#1pin@571_polysilicon-1##37 9.85
R3741 net@1811#1pin@571_polysilicon-1##37 net@1811#1pin@571_polysilicon-1##38 9.85
R3742 net@1811#1pin@571_polysilicon-1##38 net@1811#1pin@571_polysilicon-1##39 9.85
R3743 net@1811#1pin@571_polysilicon-1##39 net@1811#1pin@571_polysilicon-1##40 9.85
R3744 net@1811#1pin@571_polysilicon-1##40 net@1811#1pin@571_polysilicon-1##41 9.85
R3745 net@1811#1pin@571_polysilicon-1##41 net@1811#1pin@571_polysilicon-1##42 9.85
R3746 net@1811#1pin@571_polysilicon-1##42 net@1811#1pin@571_polysilicon-1##43 9.85
R3747 net@1811#1pin@571_polysilicon-1##43 net@1811#1pin@571_polysilicon-1##44 9.85
R3748 net@1811#1pin@571_polysilicon-1##44 net@1811#1pin@571_polysilicon-1##45 9.85
R3749 net@1811#1pin@571_polysilicon-1##45 net@1811#1pin@571_polysilicon-1##46 9.85
R3750 net@1811#1pin@571_polysilicon-1##46 net@1811#1pin@571_polysilicon-1##47 9.85
R3751 net@1811#1pin@571_polysilicon-1##47 net@1811#1pin@571_polysilicon-1##48 9.85
R3752 net@1811#1pin@571_polysilicon-1##48 net@1811#1pin@571_polysilicon-1##49 9.85
R3753 net@1811#1pin@571_polysilicon-1##49 net@1811#1pin@571_polysilicon-1##50 9.85
R3754 net@1811#1pin@571_polysilicon-1##50 net@1811#1pin@571_polysilicon-1##51 9.85
R3755 net@1811#1pin@571_polysilicon-1##51 net@1811#1pin@571_polysilicon-1##52 9.85
R3756 net@1811#1pin@571_polysilicon-1##52 net@1811#1pin@571_polysilicon-1##53 9.85
R3757 net@1811#1pin@571_polysilicon-1##53 net@1811#1pin@571_polysilicon-1##54 9.85
R3758 net@1811#1pin@571_polysilicon-1##54 net@1811#1pin@571_polysilicon-1##55 9.85
R3759 net@1811#1pin@571_polysilicon-1##55 net@1811#1pin@571_polysilicon-1##56 9.85
R3760 net@1811#1pin@571_polysilicon-1##56 net@1811#1pin@571_polysilicon-1##57 9.85
R3761 net@1811#1pin@571_polysilicon-1##57 net@1811#1pin@571_polysilicon-1##58 9.85
R3762 net@1811#1pin@571_polysilicon-1##58 net@1811#1pin@571_polysilicon-1##59 9.85
R3763 net@1811#1pin@571_polysilicon-1##59 net@1811#1pin@571_polysilicon-1##60 9.85
R3764 net@1811#1pin@571_polysilicon-1##60 net@1811#2pin@561_metal-1 9.85
R3765 Cin_to_XOR2___NAND3#26pmos@91_poly-right Cin_to_XOR2___NAND3#26pmos@91_poly-right##0 9.854
R3766 Cin_to_XOR2___NAND3#26pmos@91_poly-right##0 Cin_to_XOR2___NAND3#26pmos@91_poly-right##1 9.854
R3767 Cin_to_XOR2___NAND3#26pmos@91_poly-right##1 Cin_to_XOR2___NAND3#26pmos@91_poly-right##2 9.854
R3768 Cin_to_XOR2___NAND3#26pmos@91_poly-right##2 Cin_to_XOR2___NAND3#26pmos@91_poly-right##3 9.854
R3769 Cin_to_XOR2___NAND3#26pmos@91_poly-right##3 Cin_to_XOR2___NAND3#26pmos@91_poly-right##4 9.854
R3770 Cin_to_XOR2___NAND3#26pmos@91_poly-right##4 Cin_to_XOR2___NAND3#26pmos@91_poly-right##5 9.854
R3771 Cin_to_XOR2___NAND3#26pmos@91_poly-right##5 Cin_to_XOR2___NAND3#26pmos@91_poly-right##6 9.854
R3772 Cin_to_XOR2___NAND3#26pmos@91_poly-right##6 Cin_to_XOR2___NAND3#26pmos@91_poly-right##7 9.854
R3773 Cin_to_XOR2___NAND3#26pmos@91_poly-right##7 Cin_to_XOR2___NAND3#26pmos@91_poly-right##8 9.854
R3774 Cin_to_XOR2___NAND3#26pmos@91_poly-right##8 Cin_to_XOR2___NAND3#26pmos@91_poly-right##9 9.854
R3775 Cin_to_XOR2___NAND3#26pmos@91_poly-right##9 Cin_to_XOR2___NAND3#26pmos@91_poly-right##10 9.854
R3776 Cin_to_XOR2___NAND3#26pmos@91_poly-right##10 Cin_to_XOR2___NAND3#26pmos@91_poly-right##11 9.854
R3777 Cin_to_XOR2___NAND3#26pmos@91_poly-right##11 Cin_to_XOR2___NAND3#26pmos@91_poly-right##12 9.854
R3778 Cin_to_XOR2___NAND3#26pmos@91_poly-right##12 Cin_to_XOR2___NAND3#26pmos@91_poly-right##13 9.854
R3779 Cin_to_XOR2___NAND3#26pmos@91_poly-right##13 Cin_to_XOR2___NAND3#26pmos@91_poly-right##14 9.854
R3780 Cin_to_XOR2___NAND3#26pmos@91_poly-right##14 Cin_to_XOR2___NAND3#26pmos@91_poly-right##15 9.854
R3781 Cin_to_XOR2___NAND3#26pmos@91_poly-right##15 Cin_to_XOR2___NAND3#26pmos@91_poly-right##16 9.854
R3782 Cin_to_XOR2___NAND3#26pmos@91_poly-right##16 Cin_to_XOR2___NAND3#26pmos@91_poly-right##17 9.854
R3783 Cin_to_XOR2___NAND3#26pmos@91_poly-right##17 Cin_to_XOR2___NAND3#26pmos@91_poly-right##18 9.854
R3784 Cin_to_XOR2___NAND3#26pmos@91_poly-right##18 Cin_to_XOR2___NAND3#26pmos@91_poly-right##19 9.854
R3785 Cin_to_XOR2___NAND3#26pmos@91_poly-right##19 Cin_to_XOR2___NAND3#26pmos@91_poly-right##20 9.854
R3786 Cin_to_XOR2___NAND3#26pmos@91_poly-right##20 Cin_to_XOR2___NAND3#26pmos@91_poly-right##21 9.854
R3787 Cin_to_XOR2___NAND3#26pmos@91_poly-right##21 Cin_to_XOR2___NAND3#26pmos@91_poly-right##22 9.854
R3788 Cin_to_XOR2___NAND3#26pmos@91_poly-right##22 Cin_to_XOR2___NAND3#26pmos@91_poly-right##23 9.854
R3789 Cin_to_XOR2___NAND3#26pmos@91_poly-right##23 Cin_to_XOR2___NAND3#26pmos@91_poly-right##24 9.854
R3790 Cin_to_XOR2___NAND3#26pmos@91_poly-right##24 Cin_to_XOR2___NAND3#26pmos@91_poly-right##25 9.854
R3791 Cin_to_XOR2___NAND3#26pmos@91_poly-right##25 Cin_to_XOR2___NAND3#26pmos@91_poly-right##26 9.854
R3792 Cin_to_XOR2___NAND3#26pmos@91_poly-right##26 Cin_to_XOR2___NAND3#26pmos@91_poly-right##27 9.854
R3793 Cin_to_XOR2___NAND3#26pmos@91_poly-right##27 Cin_to_XOR2___NAND3#26pmos@91_poly-right##28 9.854
R3794 Cin_to_XOR2___NAND3#26pmos@91_poly-right##28 Cin_to_XOR2___NAND3#26pmos@91_poly-right##29 9.854
R3795 Cin_to_XOR2___NAND3#26pmos@91_poly-right##29 Cin_to_XOR2___NAND3#26pmos@91_poly-right##30 9.854
R3796 Cin_to_XOR2___NAND3#26pmos@91_poly-right##30 Cin_to_XOR2___NAND3#26pmos@91_poly-right##31 9.854
R3797 Cin_to_XOR2___NAND3#26pmos@91_poly-right##31 Cin_to_XOR2___NAND3#26pmos@91_poly-right##32 9.854
R3798 Cin_to_XOR2___NAND3#26pmos@91_poly-right##32 Cin_to_XOR2___NAND3#26pmos@91_poly-right##33 9.854
R3799 Cin_to_XOR2___NAND3#26pmos@91_poly-right##33 Cin_to_XOR2___NAND3#26pmos@91_poly-right##34 9.854
R3800 Cin_to_XOR2___NAND3#26pmos@91_poly-right##34 Cin_to_XOR2___NAND3#26pmos@91_poly-right##35 9.854
R3801 Cin_to_XOR2___NAND3#26pmos@91_poly-right##35 Cin_to_XOR2___NAND3#26pmos@91_poly-right##36 9.854
R3802 Cin_to_XOR2___NAND3#26pmos@91_poly-right##36 Cin_to_XOR2___NAND3#26pmos@91_poly-right##37 9.854
R3803 Cin_to_XOR2___NAND3#26pmos@91_poly-right##37 Cin_to_XOR2___NAND3#26pmos@91_poly-right##38 9.854
R3804 Cin_to_XOR2___NAND3#26pmos@91_poly-right##38 Cin_to_XOR2___NAND3#26pmos@91_poly-right##39 9.854
R3805 Cin_to_XOR2___NAND3#26pmos@91_poly-right##39 Cin_to_XOR2___NAND3#26pmos@91_poly-right##40 9.854
R3806 Cin_to_XOR2___NAND3#26pmos@91_poly-right##40 Cin_to_XOR2___NAND3#26pmos@91_poly-right##41 9.854
R3807 Cin_to_XOR2___NAND3#26pmos@91_poly-right##41 Cin_to_XOR2___NAND3#26pmos@91_poly-right##42 9.854
R3808 Cin_to_XOR2___NAND3#26pmos@91_poly-right##42 Cin_to_XOR2___NAND3#26pmos@91_poly-right##43 9.854
R3809 Cin_to_XOR2___NAND3#26pmos@91_poly-right##43 Cin_to_XOR2___NAND3#26pmos@91_poly-right##44 9.854
R3810 Cin_to_XOR2___NAND3#26pmos@91_poly-right##44 Cin_to_XOR2___NAND3#26pmos@91_poly-right##45 9.854
R3811 Cin_to_XOR2___NAND3#26pmos@91_poly-right##45 Cin_to_XOR2___NAND3#26pmos@91_poly-right##46 9.854
R3812 Cin_to_XOR2___NAND3#26pmos@91_poly-right##46 Cin_to_XOR2___NAND3#26pmos@91_poly-right##47 9.854
R3813 Cin_to_XOR2___NAND3#26pmos@91_poly-right##47 Cin_to_XOR2___NAND3#26pmos@91_poly-right##48 9.854
R3814 Cin_to_XOR2___NAND3#26pmos@91_poly-right##48 Cin_to_XOR2___NAND3#26pmos@91_poly-right##49 9.854
R3815 Cin_to_XOR2___NAND3#26pmos@91_poly-right##49 Cin_to_XOR2___NAND3#26pmos@91_poly-right##50 9.854
R3816 Cin_to_XOR2___NAND3#26pmos@91_poly-right##50 Cin_to_XOR2___NAND3#26pmos@91_poly-right##51 9.854
R3817 Cin_to_XOR2___NAND3#26pmos@91_poly-right##51 Cin_to_XOR2___NAND3#26pmos@91_poly-right##52 9.854
R3818 Cin_to_XOR2___NAND3#26pmos@91_poly-right##52 Cin_to_XOR2___NAND3#26pmos@91_poly-right##53 9.854
R3819 Cin_to_XOR2___NAND3#26pmos@91_poly-right##53 Cin_to_XOR2___NAND3#26pmos@91_poly-right##54 9.854
R3820 Cin_to_XOR2___NAND3#26pmos@91_poly-right##54 Cin_to_XOR2___NAND3#15pin@562_polysilicon-1 9.854
R3821 net@1821 net@1821#2contact@617_metal-1-metal-2 4.797
R3822 XOR1_to_NAND3#9pmos@87_poly-left XOR1_to_NAND3#9pmos@87_poly-left##0 9.871
R3823 XOR1_to_NAND3#9pmos@87_poly-left##0 XOR1_to_NAND3#9pmos@87_poly-left##1 9.871
R3824 XOR1_to_NAND3#9pmos@87_poly-left##1 XOR1_to_NAND3#9pmos@87_poly-left##2 9.871
R3825 XOR1_to_NAND3#9pmos@87_poly-left##2 XOR1_to_NAND3#9pmos@87_poly-left##3 9.871
R3826 XOR1_to_NAND3#9pmos@87_poly-left##3 XOR1_to_NAND3#9pmos@87_poly-left##4 9.871
R3827 XOR1_to_NAND3#9pmos@87_poly-left##4 XOR1_to_NAND3#9pmos@87_poly-left##5 9.871
R3828 XOR1_to_NAND3#9pmos@87_poly-left##5 XOR1_to_NAND3#9pmos@87_poly-left##6 9.871
R3829 XOR1_to_NAND3#9pmos@87_poly-left##6 XOR1_to_NAND3#9pmos@87_poly-left##7 9.871
R3830 XOR1_to_NAND3#9pmos@87_poly-left##7 XOR1_to_NAND3#9pmos@87_poly-left##8 9.871
R3831 XOR1_to_NAND3#9pmos@87_poly-left##8 XOR1_to_NAND3#9pmos@87_poly-left##9 9.871
R3832 XOR1_to_NAND3#9pmos@87_poly-left##9 XOR1_to_NAND3#9pmos@87_poly-left##10 9.871
R3833 XOR1_to_NAND3#9pmos@87_poly-left##10 XOR1_to_NAND3#9pmos@87_poly-left##11 9.871
R3834 XOR1_to_NAND3#9pmos@87_poly-left##11 XOR1_to_NAND3#9pmos@87_poly-left##12 9.871
R3835 XOR1_to_NAND3#9pmos@87_poly-left##12 XOR1_to_NAND3#9pmos@87_poly-left##13 9.871
R3836 XOR1_to_NAND3#9pmos@87_poly-left##13 XOR1_to_NAND3#9pmos@87_poly-left##14 9.871
R3837 XOR1_to_NAND3#9pmos@87_poly-left##14 XOR1_to_NAND3#9pmos@87_poly-left##15 9.871
R3838 XOR1_to_NAND3#9pmos@87_poly-left##15 XOR1_to_NAND3#9pmos@87_poly-left##16 9.871
R3839 XOR1_to_NAND3#9pmos@87_poly-left##16 XOR1_to_NAND3#9pmos@87_poly-left##17 9.871
R3840 XOR1_to_NAND3#9pmos@87_poly-left##17 XOR1_to_NAND3#9pmos@87_poly-left##18 9.871
R3841 XOR1_to_NAND3#9pmos@87_poly-left##18 XOR1_to_NAND3#9pmos@87_poly-left##19 9.871
R3842 XOR1_to_NAND3#9pmos@87_poly-left##19 XOR1_to_NAND3#9pmos@87_poly-left##20 9.871
R3843 XOR1_to_NAND3#9pmos@87_poly-left##20 XOR1_to_NAND3#9pmos@87_poly-left##21 9.871
R3844 XOR1_to_NAND3#9pmos@87_poly-left##21 XOR1_to_NAND3#9pmos@87_poly-left##22 9.871
R3845 XOR1_to_NAND3#9pmos@87_poly-left##22 XOR1_to_NAND3#9pmos@87_poly-left##23 9.871
R3846 XOR1_to_NAND3#9pmos@87_poly-left##23 XOR1_to_NAND3#9pmos@87_poly-left##24 9.871
R3847 XOR1_to_NAND3#9pmos@87_poly-left##24 XOR1_to_NAND3#9pmos@87_poly-left##25 9.871
R3848 XOR1_to_NAND3#9pmos@87_poly-left##25 XOR1_to_NAND3#9pmos@87_poly-left##26 9.871
R3849 XOR1_to_NAND3#9pmos@87_poly-left##26 XOR1_to_NAND3#9pmos@87_poly-left##27 9.871
R3850 XOR1_to_NAND3#9pmos@87_poly-left##27 XOR1_to_NAND3#9pmos@87_poly-left##28 9.871
R3851 XOR1_to_NAND3#9pmos@87_poly-left##28 XOR1_to_NAND3#9pmos@87_poly-left##29 9.871
R3852 XOR1_to_NAND3#9pmos@87_poly-left##29 XOR1_to_NAND3#9pmos@87_poly-left##30 9.871
R3853 XOR1_to_NAND3#9pmos@87_poly-left##30 XOR1_to_NAND3#9pmos@87_poly-left##31 9.871
R3854 XOR1_to_NAND3#9pmos@87_poly-left##31 XOR1_to_NAND3#9pmos@87_poly-left##32 9.871
R3855 XOR1_to_NAND3#9pmos@87_poly-left##32 XOR1_to_NAND3#9pmos@87_poly-left##33 9.871
R3856 XOR1_to_NAND3#9pmos@87_poly-left##33 XOR1_to_NAND3#9pmos@87_poly-left##34 9.871
R3857 XOR1_to_NAND3#9pmos@87_poly-left##34 XOR1_to_NAND3#9pmos@87_poly-left##35 9.871
R3858 XOR1_to_NAND3#9pmos@87_poly-left##35 XOR1_to_NAND3#9pmos@87_poly-left##36 9.871
R3859 XOR1_to_NAND3#9pmos@87_poly-left##36 XOR1_to_NAND3#9pmos@87_poly-left##37 9.871
R3860 XOR1_to_NAND3#9pmos@87_poly-left##37 XOR1_to_NAND3#9pmos@87_poly-left##38 9.871
R3861 XOR1_to_NAND3#9pmos@87_poly-left##38 XOR1_to_NAND3#9pmos@87_poly-left##39 9.871
R3862 XOR1_to_NAND3#9pmos@87_poly-left##39 XOR1_to_NAND3#9pmos@87_poly-left##40 9.871
R3863 XOR1_to_NAND3#9pmos@87_poly-left##40 XOR1_to_NAND3#9pmos@87_poly-left##41 9.871
R3864 XOR1_to_NAND3#9pmos@87_poly-left##41 XOR1_to_NAND3#9pmos@87_poly-left##42 9.871
R3865 XOR1_to_NAND3#9pmos@87_poly-left##42 XOR1_to_NAND3#9pmos@87_poly-left##43 9.871
R3866 XOR1_to_NAND3#9pmos@87_poly-left##43 XOR1_to_NAND3#9pmos@87_poly-left##44 9.871
R3867 XOR1_to_NAND3#9pmos@87_poly-left##44 XOR1_to_NAND3#9pmos@87_poly-left##45 9.871
R3868 XOR1_to_NAND3#9pmos@87_poly-left##45 XOR1_to_NAND3#9pmos@87_poly-left##46 9.871
R3869 XOR1_to_NAND3#9pmos@87_poly-left##46 XOR1_to_NAND3#9pmos@87_poly-left##47 9.871
R3870 XOR1_to_NAND3#9pmos@87_poly-left##47 XOR1_to_NAND3#9pmos@87_poly-left##48 9.871
R3871 XOR1_to_NAND3#9pmos@87_poly-left##48 XOR1_to_NAND3#9pmos@87_poly-left##49 9.871
R3872 XOR1_to_NAND3#9pmos@87_poly-left##49 XOR1_to_NAND3#9pmos@87_poly-left##50 9.871
R3873 XOR1_to_NAND3#9pmos@87_poly-left##50 XOR1_to_NAND3#9pmos@87_poly-left##51 9.871
R3874 XOR1_to_NAND3#9pmos@87_poly-left##51 XOR1_to_NAND3#9pmos@87_poly-left##52 9.871
R3875 XOR1_to_NAND3#9pmos@87_poly-left##52 XOR1_to_NAND3#9pmos@87_poly-left##53 9.871
R3876 XOR1_to_NAND3#9pmos@87_poly-left##53 XOR1_to_NAND3#9pmos@87_poly-left##54 9.871
R3877 XOR1_to_NAND3#9pmos@87_poly-left##54 XOR1_to_NAND3#9pmos@87_poly-left##55 9.871
R3878 XOR1_to_NAND3#9pmos@87_poly-left##55 XOR1_to_NAND3#26nmos@87_poly-right 9.871
R3879 net@1811#7pmos@88_poly-left net@1811#7pmos@88_poly-left##0 9.871
R3880 net@1811#7pmos@88_poly-left##0 net@1811#7pmos@88_poly-left##1 9.871
R3881 net@1811#7pmos@88_poly-left##1 net@1811#7pmos@88_poly-left##2 9.871
R3882 net@1811#7pmos@88_poly-left##2 net@1811#7pmos@88_poly-left##3 9.871
R3883 net@1811#7pmos@88_poly-left##3 net@1811#7pmos@88_poly-left##4 9.871
R3884 net@1811#7pmos@88_poly-left##4 net@1811#7pmos@88_poly-left##5 9.871
R3885 net@1811#7pmos@88_poly-left##5 net@1811#7pmos@88_poly-left##6 9.871
R3886 net@1811#7pmos@88_poly-left##6 net@1811#7pmos@88_poly-left##7 9.871
R3887 net@1811#7pmos@88_poly-left##7 net@1811#7pmos@88_poly-left##8 9.871
R3888 net@1811#7pmos@88_poly-left##8 net@1811#7pmos@88_poly-left##9 9.871
R3889 net@1811#7pmos@88_poly-left##9 net@1811#7pmos@88_poly-left##10 9.871
R3890 net@1811#7pmos@88_poly-left##10 net@1811#7pmos@88_poly-left##11 9.871
R3891 net@1811#7pmos@88_poly-left##11 net@1811#7pmos@88_poly-left##12 9.871
R3892 net@1811#7pmos@88_poly-left##12 net@1811#7pmos@88_poly-left##13 9.871
R3893 net@1811#7pmos@88_poly-left##13 net@1811#7pmos@88_poly-left##14 9.871
R3894 net@1811#7pmos@88_poly-left##14 net@1811#7pmos@88_poly-left##15 9.871
R3895 net@1811#7pmos@88_poly-left##15 net@1811#7pmos@88_poly-left##16 9.871
R3896 net@1811#7pmos@88_poly-left##16 net@1811#7pmos@88_poly-left##17 9.871
R3897 net@1811#7pmos@88_poly-left##17 net@1811#7pmos@88_poly-left##18 9.871
R3898 net@1811#7pmos@88_poly-left##18 net@1811#7pmos@88_poly-left##19 9.871
R3899 net@1811#7pmos@88_poly-left##19 net@1811#7pmos@88_poly-left##20 9.871
R3900 net@1811#7pmos@88_poly-left##20 net@1811#7pmos@88_poly-left##21 9.871
R3901 net@1811#7pmos@88_poly-left##21 net@1811#7pmos@88_poly-left##22 9.871
R3902 net@1811#7pmos@88_poly-left##22 net@1811#7pmos@88_poly-left##23 9.871
R3903 net@1811#7pmos@88_poly-left##23 net@1811#7pmos@88_poly-left##24 9.871
R3904 net@1811#7pmos@88_poly-left##24 net@1811#7pmos@88_poly-left##25 9.871
R3905 net@1811#7pmos@88_poly-left##25 net@1811#7pmos@88_poly-left##26 9.871
R3906 net@1811#7pmos@88_poly-left##26 net@1811#7pmos@88_poly-left##27 9.871
R3907 net@1811#7pmos@88_poly-left##27 net@1811#7pmos@88_poly-left##28 9.871
R3908 net@1811#7pmos@88_poly-left##28 net@1811#7pmos@88_poly-left##29 9.871
R3909 net@1811#7pmos@88_poly-left##29 net@1811#7pmos@88_poly-left##30 9.871
R3910 net@1811#7pmos@88_poly-left##30 net@1811#7pmos@88_poly-left##31 9.871
R3911 net@1811#7pmos@88_poly-left##31 net@1811#7pmos@88_poly-left##32 9.871
R3912 net@1811#7pmos@88_poly-left##32 net@1811#7pmos@88_poly-left##33 9.871
R3913 net@1811#7pmos@88_poly-left##33 net@1811#7pmos@88_poly-left##34 9.871
R3914 net@1811#7pmos@88_poly-left##34 net@1811#7pmos@88_poly-left##35 9.871
R3915 net@1811#7pmos@88_poly-left##35 net@1811#7pmos@88_poly-left##36 9.871
R3916 net@1811#7pmos@88_poly-left##36 net@1811#7pmos@88_poly-left##37 9.871
R3917 net@1811#7pmos@88_poly-left##37 net@1811#7pmos@88_poly-left##38 9.871
R3918 net@1811#7pmos@88_poly-left##38 net@1811#7pmos@88_poly-left##39 9.871
R3919 net@1811#7pmos@88_poly-left##39 net@1811#7pmos@88_poly-left##40 9.871
R3920 net@1811#7pmos@88_poly-left##40 net@1811#7pmos@88_poly-left##41 9.871
R3921 net@1811#7pmos@88_poly-left##41 net@1811#7pmos@88_poly-left##42 9.871
R3922 net@1811#7pmos@88_poly-left##42 net@1811#7pmos@88_poly-left##43 9.871
R3923 net@1811#7pmos@88_poly-left##43 net@1811#7pmos@88_poly-left##44 9.871
R3924 net@1811#7pmos@88_poly-left##44 net@1811#7pmos@88_poly-left##45 9.871
R3925 net@1811#7pmos@88_poly-left##45 net@1811#7pmos@88_poly-left##46 9.871
R3926 net@1811#7pmos@88_poly-left##46 net@1811#7pmos@88_poly-left##47 9.871
R3927 net@1811#7pmos@88_poly-left##47 net@1811#7pmos@88_poly-left##48 9.871
R3928 net@1811#7pmos@88_poly-left##48 net@1811#7pmos@88_poly-left##49 9.871
R3929 net@1811#7pmos@88_poly-left##49 net@1811#7pmos@88_poly-left##50 9.871
R3930 net@1811#7pmos@88_poly-left##50 net@1811#7pmos@88_poly-left##51 9.871
R3931 net@1811#7pmos@88_poly-left##51 net@1811#7pmos@88_poly-left##52 9.871
R3932 net@1811#7pmos@88_poly-left##52 net@1811#7pmos@88_poly-left##53 9.871
R3933 net@1811#7pmos@88_poly-left##53 net@1811#7pmos@88_poly-left##54 9.871
R3934 net@1811#7pmos@88_poly-left##54 net@1811#7pmos@88_poly-left##55 9.871
R3935 net@1811#7pmos@88_poly-left##55 net@1811#11nmos@88_poly-right 9.871
R3936 Cin_to_XOR2___NAND3#27pmos@89_poly-right Cin_to_XOR2___NAND3#27pmos@89_poly-right##0 9.871
R3937 Cin_to_XOR2___NAND3#27pmos@89_poly-right##0 Cin_to_XOR2___NAND3#27pmos@89_poly-right##1 9.871
R3938 Cin_to_XOR2___NAND3#27pmos@89_poly-right##1 Cin_to_XOR2___NAND3#27pmos@89_poly-right##2 9.871
R3939 Cin_to_XOR2___NAND3#27pmos@89_poly-right##2 Cin_to_XOR2___NAND3#27pmos@89_poly-right##3 9.871
R3940 Cin_to_XOR2___NAND3#27pmos@89_poly-right##3 Cin_to_XOR2___NAND3#27pmos@89_poly-right##4 9.871
R3941 Cin_to_XOR2___NAND3#27pmos@89_poly-right##4 Cin_to_XOR2___NAND3#27pmos@89_poly-right##5 9.871
R3942 Cin_to_XOR2___NAND3#27pmos@89_poly-right##5 Cin_to_XOR2___NAND3#27pmos@89_poly-right##6 9.871
R3943 Cin_to_XOR2___NAND3#27pmos@89_poly-right##6 Cin_to_XOR2___NAND3#27pmos@89_poly-right##7 9.871
R3944 Cin_to_XOR2___NAND3#27pmos@89_poly-right##7 Cin_to_XOR2___NAND3#27pmos@89_poly-right##8 9.871
R3945 Cin_to_XOR2___NAND3#27pmos@89_poly-right##8 Cin_to_XOR2___NAND3#27pmos@89_poly-right##9 9.871
R3946 Cin_to_XOR2___NAND3#27pmos@89_poly-right##9 Cin_to_XOR2___NAND3#27pmos@89_poly-right##10 9.871
R3947 Cin_to_XOR2___NAND3#27pmos@89_poly-right##10 Cin_to_XOR2___NAND3#27pmos@89_poly-right##11 9.871
R3948 Cin_to_XOR2___NAND3#27pmos@89_poly-right##11 Cin_to_XOR2___NAND3#27pmos@89_poly-right##12 9.871
R3949 Cin_to_XOR2___NAND3#27pmos@89_poly-right##12 Cin_to_XOR2___NAND3#27pmos@89_poly-right##13 9.871
R3950 Cin_to_XOR2___NAND3#27pmos@89_poly-right##13 Cin_to_XOR2___NAND3#27pmos@89_poly-right##14 9.871
R3951 Cin_to_XOR2___NAND3#27pmos@89_poly-right##14 Cin_to_XOR2___NAND3#27pmos@89_poly-right##15 9.871
R3952 Cin_to_XOR2___NAND3#27pmos@89_poly-right##15 Cin_to_XOR2___NAND3#27pmos@89_poly-right##16 9.871
R3953 Cin_to_XOR2___NAND3#27pmos@89_poly-right##16 Cin_to_XOR2___NAND3#27pmos@89_poly-right##17 9.871
R3954 Cin_to_XOR2___NAND3#27pmos@89_poly-right##17 Cin_to_XOR2___NAND3#27pmos@89_poly-right##18 9.871
R3955 Cin_to_XOR2___NAND3#27pmos@89_poly-right##18 Cin_to_XOR2___NAND3#27pmos@89_poly-right##19 9.871
R3956 Cin_to_XOR2___NAND3#27pmos@89_poly-right##19 Cin_to_XOR2___NAND3#27pmos@89_poly-right##20 9.871
R3957 Cin_to_XOR2___NAND3#27pmos@89_poly-right##20 Cin_to_XOR2___NAND3#27pmos@89_poly-right##21 9.871
R3958 Cin_to_XOR2___NAND3#27pmos@89_poly-right##21 Cin_to_XOR2___NAND3#27pmos@89_poly-right##22 9.871
R3959 Cin_to_XOR2___NAND3#27pmos@89_poly-right##22 Cin_to_XOR2___NAND3#27pmos@89_poly-right##23 9.871
R3960 Cin_to_XOR2___NAND3#27pmos@89_poly-right##23 Cin_to_XOR2___NAND3#27pmos@89_poly-right##24 9.871
R3961 Cin_to_XOR2___NAND3#27pmos@89_poly-right##24 Cin_to_XOR2___NAND3#27pmos@89_poly-right##25 9.871
R3962 Cin_to_XOR2___NAND3#27pmos@89_poly-right##25 Cin_to_XOR2___NAND3#27pmos@89_poly-right##26 9.871
R3963 Cin_to_XOR2___NAND3#27pmos@89_poly-right##26 Cin_to_XOR2___NAND3#27pmos@89_poly-right##27 9.871
R3964 Cin_to_XOR2___NAND3#27pmos@89_poly-right##27 Cin_to_XOR2___NAND3#27pmos@89_poly-right##28 9.871
R3965 Cin_to_XOR2___NAND3#27pmos@89_poly-right##28 Cin_to_XOR2___NAND3#27pmos@89_poly-right##29 9.871
R3966 Cin_to_XOR2___NAND3#27pmos@89_poly-right##29 Cin_to_XOR2___NAND3#27pmos@89_poly-right##30 9.871
R3967 Cin_to_XOR2___NAND3#27pmos@89_poly-right##30 Cin_to_XOR2___NAND3#27pmos@89_poly-right##31 9.871
R3968 Cin_to_XOR2___NAND3#27pmos@89_poly-right##31 Cin_to_XOR2___NAND3#27pmos@89_poly-right##32 9.871
R3969 Cin_to_XOR2___NAND3#27pmos@89_poly-right##32 Cin_to_XOR2___NAND3#27pmos@89_poly-right##33 9.871
R3970 Cin_to_XOR2___NAND3#27pmos@89_poly-right##33 Cin_to_XOR2___NAND3#27pmos@89_poly-right##34 9.871
R3971 Cin_to_XOR2___NAND3#27pmos@89_poly-right##34 Cin_to_XOR2___NAND3#27pmos@89_poly-right##35 9.871
R3972 Cin_to_XOR2___NAND3#27pmos@89_poly-right##35 Cin_to_XOR2___NAND3#27pmos@89_poly-right##36 9.871
R3973 Cin_to_XOR2___NAND3#27pmos@89_poly-right##36 Cin_to_XOR2___NAND3#27pmos@89_poly-right##37 9.871
R3974 Cin_to_XOR2___NAND3#27pmos@89_poly-right##37 Cin_to_XOR2___NAND3#27pmos@89_poly-right##38 9.871
R3975 Cin_to_XOR2___NAND3#27pmos@89_poly-right##38 Cin_to_XOR2___NAND3#27pmos@89_poly-right##39 9.871
R3976 Cin_to_XOR2___NAND3#27pmos@89_poly-right##39 Cin_to_XOR2___NAND3#27pmos@89_poly-right##40 9.871
R3977 Cin_to_XOR2___NAND3#27pmos@89_poly-right##40 Cin_to_XOR2___NAND3#27pmos@89_poly-right##41 9.871
R3978 Cin_to_XOR2___NAND3#27pmos@89_poly-right##41 Cin_to_XOR2___NAND3#27pmos@89_poly-right##42 9.871
R3979 Cin_to_XOR2___NAND3#27pmos@89_poly-right##42 Cin_to_XOR2___NAND3#27pmos@89_poly-right##43 9.871
R3980 Cin_to_XOR2___NAND3#27pmos@89_poly-right##43 Cin_to_XOR2___NAND3#27pmos@89_poly-right##44 9.871
R3981 Cin_to_XOR2___NAND3#27pmos@89_poly-right##44 Cin_to_XOR2___NAND3#27pmos@89_poly-right##45 9.871
R3982 Cin_to_XOR2___NAND3#27pmos@89_poly-right##45 Cin_to_XOR2___NAND3#27pmos@89_poly-right##46 9.871
R3983 Cin_to_XOR2___NAND3#27pmos@89_poly-right##46 Cin_to_XOR2___NAND3#27pmos@89_poly-right##47 9.871
R3984 Cin_to_XOR2___NAND3#27pmos@89_poly-right##47 Cin_to_XOR2___NAND3#27pmos@89_poly-right##48 9.871
R3985 Cin_to_XOR2___NAND3#27pmos@89_poly-right##48 Cin_to_XOR2___NAND3#27pmos@89_poly-right##49 9.871
R3986 Cin_to_XOR2___NAND3#27pmos@89_poly-right##49 Cin_to_XOR2___NAND3#27pmos@89_poly-right##50 9.871
R3987 Cin_to_XOR2___NAND3#27pmos@89_poly-right##50 Cin_to_XOR2___NAND3#27pmos@89_poly-right##51 9.871
R3988 Cin_to_XOR2___NAND3#27pmos@89_poly-right##51 Cin_to_XOR2___NAND3#27pmos@89_poly-right##52 9.871
R3989 Cin_to_XOR2___NAND3#27pmos@89_poly-right##52 Cin_to_XOR2___NAND3#27pmos@89_poly-right##53 9.871
R3990 Cin_to_XOR2___NAND3#27pmos@89_poly-right##53 Cin_to_XOR2___NAND3#27pmos@89_poly-right##54 9.871
R3991 Cin_to_XOR2___NAND3#27pmos@89_poly-right##54 Cin_to_XOR2___NAND3#27pmos@89_poly-right##55 9.871
R3992 Cin_to_XOR2___NAND3#27pmos@89_poly-right##55 Cin_to_XOR2___NAND3#18nmos@89_poly-left 9.871
R3993 net@1821#14pmos@90_poly-right net@1821#14pmos@90_poly-right##0 9.871
R3994 net@1821#14pmos@90_poly-right##0 net@1821#14pmos@90_poly-right##1 9.871
R3995 net@1821#14pmos@90_poly-right##1 net@1821#14pmos@90_poly-right##2 9.871
R3996 net@1821#14pmos@90_poly-right##2 net@1821#14pmos@90_poly-right##3 9.871
R3997 net@1821#14pmos@90_poly-right##3 net@1821#14pmos@90_poly-right##4 9.871
R3998 net@1821#14pmos@90_poly-right##4 net@1821#14pmos@90_poly-right##5 9.871
R3999 net@1821#14pmos@90_poly-right##5 net@1821#14pmos@90_poly-right##6 9.871
R4000 net@1821#14pmos@90_poly-right##6 net@1821#14pmos@90_poly-right##7 9.871
R4001 net@1821#14pmos@90_poly-right##7 net@1821#14pmos@90_poly-right##8 9.871
R4002 net@1821#14pmos@90_poly-right##8 net@1821#14pmos@90_poly-right##9 9.871
R4003 net@1821#14pmos@90_poly-right##9 net@1821#14pmos@90_poly-right##10 9.871
R4004 net@1821#14pmos@90_poly-right##10 net@1821#14pmos@90_poly-right##11 9.871
R4005 net@1821#14pmos@90_poly-right##11 net@1821#14pmos@90_poly-right##12 9.871
R4006 net@1821#14pmos@90_poly-right##12 net@1821#14pmos@90_poly-right##13 9.871
R4007 net@1821#14pmos@90_poly-right##13 net@1821#14pmos@90_poly-right##14 9.871
R4008 net@1821#14pmos@90_poly-right##14 net@1821#14pmos@90_poly-right##15 9.871
R4009 net@1821#14pmos@90_poly-right##15 net@1821#14pmos@90_poly-right##16 9.871
R4010 net@1821#14pmos@90_poly-right##16 net@1821#14pmos@90_poly-right##17 9.871
R4011 net@1821#14pmos@90_poly-right##17 net@1821#14pmos@90_poly-right##18 9.871
R4012 net@1821#14pmos@90_poly-right##18 net@1821#14pmos@90_poly-right##19 9.871
R4013 net@1821#14pmos@90_poly-right##19 net@1821#14pmos@90_poly-right##20 9.871
R4014 net@1821#14pmos@90_poly-right##20 net@1821#14pmos@90_poly-right##21 9.871
R4015 net@1821#14pmos@90_poly-right##21 net@1821#14pmos@90_poly-right##22 9.871
R4016 net@1821#14pmos@90_poly-right##22 net@1821#14pmos@90_poly-right##23 9.871
R4017 net@1821#14pmos@90_poly-right##23 net@1821#14pmos@90_poly-right##24 9.871
R4018 net@1821#14pmos@90_poly-right##24 net@1821#14pmos@90_poly-right##25 9.871
R4019 net@1821#14pmos@90_poly-right##25 net@1821#14pmos@90_poly-right##26 9.871
R4020 net@1821#14pmos@90_poly-right##26 net@1821#14pmos@90_poly-right##27 9.871
R4021 net@1821#14pmos@90_poly-right##27 net@1821#14pmos@90_poly-right##28 9.871
R4022 net@1821#14pmos@90_poly-right##28 net@1821#14pmos@90_poly-right##29 9.871
R4023 net@1821#14pmos@90_poly-right##29 net@1821#14pmos@90_poly-right##30 9.871
R4024 net@1821#14pmos@90_poly-right##30 net@1821#14pmos@90_poly-right##31 9.871
R4025 net@1821#14pmos@90_poly-right##31 net@1821#14pmos@90_poly-right##32 9.871
R4026 net@1821#14pmos@90_poly-right##32 net@1821#14pmos@90_poly-right##33 9.871
R4027 net@1821#14pmos@90_poly-right##33 net@1821#14pmos@90_poly-right##34 9.871
R4028 net@1821#14pmos@90_poly-right##34 net@1821#14pmos@90_poly-right##35 9.871
R4029 net@1821#14pmos@90_poly-right##35 net@1821#14pmos@90_poly-right##36 9.871
R4030 net@1821#14pmos@90_poly-right##36 net@1821#14pmos@90_poly-right##37 9.871
R4031 net@1821#14pmos@90_poly-right##37 net@1821#14pmos@90_poly-right##38 9.871
R4032 net@1821#14pmos@90_poly-right##38 net@1821#14pmos@90_poly-right##39 9.871
R4033 net@1821#14pmos@90_poly-right##39 net@1821#14pmos@90_poly-right##40 9.871
R4034 net@1821#14pmos@90_poly-right##40 net@1821#14pmos@90_poly-right##41 9.871
R4035 net@1821#14pmos@90_poly-right##41 net@1821#14pmos@90_poly-right##42 9.871
R4036 net@1821#14pmos@90_poly-right##42 net@1821#14pmos@90_poly-right##43 9.871
R4037 net@1821#14pmos@90_poly-right##43 net@1821#14pmos@90_poly-right##44 9.871
R4038 net@1821#14pmos@90_poly-right##44 net@1821#14pmos@90_poly-right##45 9.871
R4039 net@1821#14pmos@90_poly-right##45 net@1821#14pmos@90_poly-right##46 9.871
R4040 net@1821#14pmos@90_poly-right##46 net@1821#14pmos@90_poly-right##47 9.871
R4041 net@1821#14pmos@90_poly-right##47 net@1821#14pmos@90_poly-right##48 9.871
R4042 net@1821#14pmos@90_poly-right##48 net@1821#14pmos@90_poly-right##49 9.871
R4043 net@1821#14pmos@90_poly-right##49 net@1821#14pmos@90_poly-right##50 9.871
R4044 net@1821#14pmos@90_poly-right##50 net@1821#14pmos@90_poly-right##51 9.871
R4045 net@1821#14pmos@90_poly-right##51 net@1821#14pmos@90_poly-right##52 9.871
R4046 net@1821#14pmos@90_poly-right##52 net@1821#14pmos@90_poly-right##53 9.871
R4047 net@1821#14pmos@90_poly-right##53 net@1821#14pmos@90_poly-right##54 9.871
R4048 net@1821#14pmos@90_poly-right##54 net@1821#14pmos@90_poly-right##55 9.871
R4049 net@1821#14pmos@90_poly-right##55 net@1821#9nmos@90_poly-left 9.871
R4050 net@1820#2contact@642_metal-1-polysilicon-1 net@1820 4.654
R4051 net@1820#12pmos@93_poly-right net@1820#12pmos@93_poly-right##0 9.931
R4052 net@1820#12pmos@93_poly-right##0 net@1820#12pmos@93_poly-right##1 9.931
R4053 net@1820#12pmos@93_poly-right##1 net@1820#12pmos@93_poly-right##2 9.931
R4054 net@1820#12pmos@93_poly-right##2 net@1820#12pmos@93_poly-right##3 9.931
R4055 net@1820#12pmos@93_poly-right##3 net@1820#12pmos@93_poly-right##4 9.931
R4056 net@1820#12pmos@93_poly-right##4 net@1820#12pmos@93_poly-right##5 9.931
R4057 net@1820#12pmos@93_poly-right##5 net@1820#12pmos@93_poly-right##6 9.931
R4058 net@1820#12pmos@93_poly-right##6 net@1820#12pmos@93_poly-right##7 9.931
R4059 net@1820#12pmos@93_poly-right##7 net@1820#12pmos@93_poly-right##8 9.931
R4060 net@1820#12pmos@93_poly-right##8 net@1820#12pmos@93_poly-right##9 9.931
R4061 net@1820#12pmos@93_poly-right##9 net@1820#12pmos@93_poly-right##10 9.931
R4062 net@1820#12pmos@93_poly-right##10 net@1820#12pmos@93_poly-right##11 9.931
R4063 net@1820#12pmos@93_poly-right##11 net@1820#12pmos@93_poly-right##12 9.931
R4064 net@1820#12pmos@93_poly-right##12 net@1820#12pmos@93_poly-right##13 9.931
R4065 net@1820#12pmos@93_poly-right##13 net@1820#12pmos@93_poly-right##14 9.931
R4066 net@1820#12pmos@93_poly-right##14 net@1820#12pmos@93_poly-right##15 9.931
R4067 net@1820#12pmos@93_poly-right##15 net@1820#12pmos@93_poly-right##16 9.931
R4068 net@1820#12pmos@93_poly-right##16 net@1820#12pmos@93_poly-right##17 9.931
R4069 net@1820#12pmos@93_poly-right##17 net@1820#12pmos@93_poly-right##18 9.931
R4070 net@1820#12pmos@93_poly-right##18 net@1820#12pmos@93_poly-right##19 9.931
R4071 net@1820#12pmos@93_poly-right##19 net@1820#12pmos@93_poly-right##20 9.931
R4072 net@1820#12pmos@93_poly-right##20 net@1820#12pmos@93_poly-right##21 9.931
R4073 net@1820#12pmos@93_poly-right##21 net@1820#12pmos@93_poly-right##22 9.931
R4074 net@1820#12pmos@93_poly-right##22 net@1820#12pmos@93_poly-right##23 9.931
R4075 net@1820#12pmos@93_poly-right##23 net@1820#12pmos@93_poly-right##24 9.931
R4076 net@1820#12pmos@93_poly-right##24 net@1820#12pmos@93_poly-right##25 9.931
R4077 net@1820#12pmos@93_poly-right##25 net@1820#12pmos@93_poly-right##26 9.931
R4078 net@1820#12pmos@93_poly-right##26 net@1820#12pmos@93_poly-right##27 9.931
R4079 net@1820#12pmos@93_poly-right##27 net@1820#12pmos@93_poly-right##28 9.931
R4080 net@1820#12pmos@93_poly-right##28 net@1820#12pmos@93_poly-right##29 9.931
R4081 net@1820#12pmos@93_poly-right##29 net@1820#12pmos@93_poly-right##30 9.931
R4082 net@1820#12pmos@93_poly-right##30 net@1820#12pmos@93_poly-right##31 9.931
R4083 net@1820#12pmos@93_poly-right##31 net@1820#12pmos@93_poly-right##32 9.931
R4084 net@1820#12pmos@93_poly-right##32 net@1820#12pmos@93_poly-right##33 9.931
R4085 net@1820#12pmos@93_poly-right##33 net@1820#12pmos@93_poly-right##34 9.931
R4086 net@1820#12pmos@93_poly-right##34 net@1820#12pmos@93_poly-right##35 9.931
R4087 net@1820#12pmos@93_poly-right##35 net@1820#12pmos@93_poly-right##36 9.931
R4088 net@1820#12pmos@93_poly-right##36 net@1820#12pmos@93_poly-right##37 9.931
R4089 net@1820#12pmos@93_poly-right##37 net@1820#12pmos@93_poly-right##38 9.931
R4090 net@1820#12pmos@93_poly-right##38 net@1820#12pmos@93_poly-right##39 9.931
R4091 net@1820#12pmos@93_poly-right##39 net@1820#12pmos@93_poly-right##40 9.931
R4092 net@1820#12pmos@93_poly-right##40 net@1820#12pmos@93_poly-right##41 9.931
R4093 net@1820#12pmos@93_poly-right##41 net@1820#12pmos@93_poly-right##42 9.931
R4094 net@1820#12pmos@93_poly-right##42 net@1820#12pmos@93_poly-right##43 9.931
R4095 net@1820#12pmos@93_poly-right##43 net@1820#12pmos@93_poly-right##44 9.931
R4096 net@1820#12pmos@93_poly-right##44 net@1820#12pmos@93_poly-right##45 9.931
R4097 net@1820#12pmos@93_poly-right##45 net@1820#12pmos@93_poly-right##46 9.931
R4098 net@1820#12pmos@93_poly-right##46 net@1820#12pmos@93_poly-right##47 9.931
R4099 net@1820#12pmos@93_poly-right##47 net@1820#12pmos@93_poly-right##48 9.931
R4100 net@1820#12pmos@93_poly-right##48 net@1820#12pmos@93_poly-right##49 9.931
R4101 net@1820#12pmos@93_poly-right##49 net@1820#12pmos@93_poly-right##50 9.931
R4102 net@1820#12pmos@93_poly-right##50 net@1820#12pmos@93_poly-right##51 9.931
R4103 net@1820#12pmos@93_poly-right##51 net@1820#12pmos@93_poly-right##52 9.931
R4104 net@1820#12pmos@93_poly-right##52 net@1820#5pin@564_polysilicon-1 9.931
R4105 Sum2#4pmos@93_diff-top Sum2 4.823
R4106 XOR1_to_NAND3#14pin@576_polysilicon-1 XOR1_to_NAND3#14pin@576_polysilicon-1##0 9.854
R4107 XOR1_to_NAND3#14pin@576_polysilicon-1##0 XOR1_to_NAND3#14pin@576_polysilicon-1##1 9.854
R4108 XOR1_to_NAND3#14pin@576_polysilicon-1##1 XOR1_to_NAND3#14pin@576_polysilicon-1##2 9.854
R4109 XOR1_to_NAND3#14pin@576_polysilicon-1##2 XOR1_to_NAND3#14pin@576_polysilicon-1##3 9.854
R4110 XOR1_to_NAND3#14pin@576_polysilicon-1##3 XOR1_to_NAND3#14pin@576_polysilicon-1##4 9.854
R4111 XOR1_to_NAND3#14pin@576_polysilicon-1##4 XOR1_to_NAND3#14pin@576_polysilicon-1##5 9.854
R4112 XOR1_to_NAND3#14pin@576_polysilicon-1##5 XOR1_to_NAND3#14pin@576_polysilicon-1##6 9.854
R4113 XOR1_to_NAND3#14pin@576_polysilicon-1##6 XOR1_to_NAND3#14pin@576_polysilicon-1##7 9.854
R4114 XOR1_to_NAND3#14pin@576_polysilicon-1##7 XOR1_to_NAND3#14pin@576_polysilicon-1##8 9.854
R4115 XOR1_to_NAND3#14pin@576_polysilicon-1##8 XOR1_to_NAND3#14pin@576_polysilicon-1##9 9.854
R4116 XOR1_to_NAND3#14pin@576_polysilicon-1##9 XOR1_to_NAND3#14pin@576_polysilicon-1##10 9.854
R4117 XOR1_to_NAND3#14pin@576_polysilicon-1##10 XOR1_to_NAND3#14pin@576_polysilicon-1##11 9.854
R4118 XOR1_to_NAND3#14pin@576_polysilicon-1##11 XOR1_to_NAND3#14pin@576_polysilicon-1##12 9.854
R4119 XOR1_to_NAND3#14pin@576_polysilicon-1##12 XOR1_to_NAND3#14pin@576_polysilicon-1##13 9.854
R4120 XOR1_to_NAND3#14pin@576_polysilicon-1##13 XOR1_to_NAND3#14pin@576_polysilicon-1##14 9.854
R4121 XOR1_to_NAND3#14pin@576_polysilicon-1##14 XOR1_to_NAND3#14pin@576_polysilicon-1##15 9.854
R4122 XOR1_to_NAND3#14pin@576_polysilicon-1##15 XOR1_to_NAND3#14pin@576_polysilicon-1##16 9.854
R4123 XOR1_to_NAND3#14pin@576_polysilicon-1##16 XOR1_to_NAND3#14pin@576_polysilicon-1##17 9.854
R4124 XOR1_to_NAND3#14pin@576_polysilicon-1##17 XOR1_to_NAND3#14pin@576_polysilicon-1##18 9.854
R4125 XOR1_to_NAND3#14pin@576_polysilicon-1##18 XOR1_to_NAND3#14pin@576_polysilicon-1##19 9.854
R4126 XOR1_to_NAND3#14pin@576_polysilicon-1##19 XOR1_to_NAND3#14pin@576_polysilicon-1##20 9.854
R4127 XOR1_to_NAND3#14pin@576_polysilicon-1##20 XOR1_to_NAND3#14pin@576_polysilicon-1##21 9.854
R4128 XOR1_to_NAND3#14pin@576_polysilicon-1##21 XOR1_to_NAND3#14pin@576_polysilicon-1##22 9.854
R4129 XOR1_to_NAND3#14pin@576_polysilicon-1##22 XOR1_to_NAND3#14pin@576_polysilicon-1##23 9.854
R4130 XOR1_to_NAND3#14pin@576_polysilicon-1##23 XOR1_to_NAND3#14pin@576_polysilicon-1##24 9.854
R4131 XOR1_to_NAND3#14pin@576_polysilicon-1##24 XOR1_to_NAND3#14pin@576_polysilicon-1##25 9.854
R4132 XOR1_to_NAND3#14pin@576_polysilicon-1##25 XOR1_to_NAND3#14pin@576_polysilicon-1##26 9.854
R4133 XOR1_to_NAND3#14pin@576_polysilicon-1##26 XOR1_to_NAND3#14pin@576_polysilicon-1##27 9.854
R4134 XOR1_to_NAND3#14pin@576_polysilicon-1##27 XOR1_to_NAND3#14pin@576_polysilicon-1##28 9.854
R4135 XOR1_to_NAND3#14pin@576_polysilicon-1##28 XOR1_to_NAND3#14pin@576_polysilicon-1##29 9.854
R4136 XOR1_to_NAND3#14pin@576_polysilicon-1##29 XOR1_to_NAND3#14pin@576_polysilicon-1##30 9.854
R4137 XOR1_to_NAND3#14pin@576_polysilicon-1##30 XOR1_to_NAND3#14pin@576_polysilicon-1##31 9.854
R4138 XOR1_to_NAND3#14pin@576_polysilicon-1##31 XOR1_to_NAND3#14pin@576_polysilicon-1##32 9.854
R4139 XOR1_to_NAND3#14pin@576_polysilicon-1##32 XOR1_to_NAND3#14pin@576_polysilicon-1##33 9.854
R4140 XOR1_to_NAND3#14pin@576_polysilicon-1##33 XOR1_to_NAND3#14pin@576_polysilicon-1##34 9.854
R4141 XOR1_to_NAND3#14pin@576_polysilicon-1##34 XOR1_to_NAND3#14pin@576_polysilicon-1##35 9.854
R4142 XOR1_to_NAND3#14pin@576_polysilicon-1##35 XOR1_to_NAND3#14pin@576_polysilicon-1##36 9.854
R4143 XOR1_to_NAND3#14pin@576_polysilicon-1##36 XOR1_to_NAND3#14pin@576_polysilicon-1##37 9.854
R4144 XOR1_to_NAND3#14pin@576_polysilicon-1##37 XOR1_to_NAND3#14pin@576_polysilicon-1##38 9.854
R4145 XOR1_to_NAND3#14pin@576_polysilicon-1##38 XOR1_to_NAND3#14pin@576_polysilicon-1##39 9.854
R4146 XOR1_to_NAND3#14pin@576_polysilicon-1##39 XOR1_to_NAND3#14pin@576_polysilicon-1##40 9.854
R4147 XOR1_to_NAND3#14pin@576_polysilicon-1##40 XOR1_to_NAND3#14pin@576_polysilicon-1##41 9.854
R4148 XOR1_to_NAND3#14pin@576_polysilicon-1##41 XOR1_to_NAND3#14pin@576_polysilicon-1##42 9.854
R4149 XOR1_to_NAND3#14pin@576_polysilicon-1##42 XOR1_to_NAND3#14pin@576_polysilicon-1##43 9.854
R4150 XOR1_to_NAND3#14pin@576_polysilicon-1##43 XOR1_to_NAND3#14pin@576_polysilicon-1##44 9.854
R4151 XOR1_to_NAND3#14pin@576_polysilicon-1##44 XOR1_to_NAND3#14pin@576_polysilicon-1##45 9.854
R4152 XOR1_to_NAND3#14pin@576_polysilicon-1##45 XOR1_to_NAND3#14pin@576_polysilicon-1##46 9.854
R4153 XOR1_to_NAND3#14pin@576_polysilicon-1##46 XOR1_to_NAND3#14pin@576_polysilicon-1##47 9.854
R4154 XOR1_to_NAND3#14pin@576_polysilicon-1##47 XOR1_to_NAND3#14pin@576_polysilicon-1##48 9.854
R4155 XOR1_to_NAND3#14pin@576_polysilicon-1##48 XOR1_to_NAND3#14pin@576_polysilicon-1##49 9.854
R4156 XOR1_to_NAND3#14pin@576_polysilicon-1##49 XOR1_to_NAND3#14pin@576_polysilicon-1##50 9.854
R4157 XOR1_to_NAND3#14pin@576_polysilicon-1##50 XOR1_to_NAND3#14pin@576_polysilicon-1##51 9.854
R4158 XOR1_to_NAND3#14pin@576_polysilicon-1##51 XOR1_to_NAND3#14pin@576_polysilicon-1##52 9.854
R4159 XOR1_to_NAND3#14pin@576_polysilicon-1##52 XOR1_to_NAND3#14pin@576_polysilicon-1##53 9.854
R4160 XOR1_to_NAND3#14pin@576_polysilicon-1##53 XOR1_to_NAND3#14pin@576_polysilicon-1##54 9.854
R4161 XOR1_to_NAND3#14pin@576_polysilicon-1##54 XOR1_to_NAND3#27nmos@94_poly-right 9.854
R4162 Cin_to_XOR2___NAND3#29pmos@95_poly-right Cin_to_XOR2___NAND3#29pmos@95_poly-right##0 9.877
R4163 Cin_to_XOR2___NAND3#29pmos@95_poly-right##0 Cin_to_XOR2___NAND3#29pmos@95_poly-right##1 9.877
R4164 Cin_to_XOR2___NAND3#29pmos@95_poly-right##1 Cin_to_XOR2___NAND3#29pmos@95_poly-right##2 9.877
R4165 Cin_to_XOR2___NAND3#29pmos@95_poly-right##2 Cin_to_XOR2___NAND3#29pmos@95_poly-right##3 9.877
R4166 Cin_to_XOR2___NAND3#29pmos@95_poly-right##3 Cin_to_XOR2___NAND3#29pmos@95_poly-right##4 9.877
R4167 Cin_to_XOR2___NAND3#29pmos@95_poly-right##4 Cin_to_XOR2___NAND3#29pmos@95_poly-right##5 9.877
R4168 Cin_to_XOR2___NAND3#29pmos@95_poly-right##5 Cin_to_XOR2___NAND3#29pmos@95_poly-right##6 9.877
R4169 Cin_to_XOR2___NAND3#29pmos@95_poly-right##6 Cin_to_XOR2___NAND3#29pmos@95_poly-right##7 9.877
R4170 Cin_to_XOR2___NAND3#29pmos@95_poly-right##7 Cin_to_XOR2___NAND3#29pmos@95_poly-right##8 9.877
R4171 Cin_to_XOR2___NAND3#29pmos@95_poly-right##8 Cin_to_XOR2___NAND3#29pmos@95_poly-right##9 9.877
R4172 Cin_to_XOR2___NAND3#29pmos@95_poly-right##9 Cin_to_XOR2___NAND3#29pmos@95_poly-right##10 9.877
R4173 Cin_to_XOR2___NAND3#29pmos@95_poly-right##10 Cin_to_XOR2___NAND3#29pmos@95_poly-right##11 9.877
R4174 Cin_to_XOR2___NAND3#29pmos@95_poly-right##11 Cin_to_XOR2___NAND3#29pmos@95_poly-right##12 9.877
R4175 Cin_to_XOR2___NAND3#29pmos@95_poly-right##12 Cin_to_XOR2___NAND3#29pmos@95_poly-right##13 9.877
R4176 Cin_to_XOR2___NAND3#29pmos@95_poly-right##13 Cin_to_XOR2___NAND3#29pmos@95_poly-right##14 9.877
R4177 Cin_to_XOR2___NAND3#29pmos@95_poly-right##14 Cin_to_XOR2___NAND3#29pmos@95_poly-right##15 9.877
R4178 Cin_to_XOR2___NAND3#29pmos@95_poly-right##15 Cin_to_XOR2___NAND3#29pmos@95_poly-right##16 9.877
R4179 Cin_to_XOR2___NAND3#29pmos@95_poly-right##16 Cin_to_XOR2___NAND3#29pmos@95_poly-right##17 9.877
R4180 Cin_to_XOR2___NAND3#29pmos@95_poly-right##17 Cin_to_XOR2___NAND3#29pmos@95_poly-right##18 9.877
R4181 Cin_to_XOR2___NAND3#29pmos@95_poly-right##18 Cin_to_XOR2___NAND3#29pmos@95_poly-right##19 9.877
R4182 Cin_to_XOR2___NAND3#29pmos@95_poly-right##19 Cin_to_XOR2___NAND3#29pmos@95_poly-right##20 9.877
R4183 Cin_to_XOR2___NAND3#29pmos@95_poly-right##20 Cin_to_XOR2___NAND3#29pmos@95_poly-right##21 9.877
R4184 Cin_to_XOR2___NAND3#29pmos@95_poly-right##21 Cin_to_XOR2___NAND3#29pmos@95_poly-right##22 9.877
R4185 Cin_to_XOR2___NAND3#29pmos@95_poly-right##22 Cin_to_XOR2___NAND3#29pmos@95_poly-right##23 9.877
R4186 Cin_to_XOR2___NAND3#29pmos@95_poly-right##23 Cin_to_XOR2___NAND3#29pmos@95_poly-right##24 9.877
R4187 Cin_to_XOR2___NAND3#29pmos@95_poly-right##24 Cin_to_XOR2___NAND3#29pmos@95_poly-right##25 9.877
R4188 Cin_to_XOR2___NAND3#29pmos@95_poly-right##25 Cin_to_XOR2___NAND3#29pmos@95_poly-right##26 9.877
R4189 Cin_to_XOR2___NAND3#29pmos@95_poly-right##26 Cin_to_XOR2___NAND3#29pmos@95_poly-right##27 9.877
R4190 Cin_to_XOR2___NAND3#29pmos@95_poly-right##27 Cin_to_XOR2___NAND3#29pmos@95_poly-right##28 9.877
R4191 Cin_to_XOR2___NAND3#29pmos@95_poly-right##28 Cin_to_XOR2___NAND3#29pmos@95_poly-right##29 9.877
R4192 Cin_to_XOR2___NAND3#29pmos@95_poly-right##29 Cin_to_XOR2___NAND3#29pmos@95_poly-right##30 9.877
R4193 Cin_to_XOR2___NAND3#29pmos@95_poly-right##30 Cin_to_XOR2___NAND3#29pmos@95_poly-right##31 9.877
R4194 Cin_to_XOR2___NAND3#29pmos@95_poly-right##31 Cin_to_XOR2___NAND3#29pmos@95_poly-right##32 9.877
R4195 Cin_to_XOR2___NAND3#29pmos@95_poly-right##32 Cin_to_XOR2___NAND3#29pmos@95_poly-right##33 9.877
R4196 Cin_to_XOR2___NAND3#29pmos@95_poly-right##33 Cin_to_XOR2___NAND3#29pmos@95_poly-right##34 9.877
R4197 Cin_to_XOR2___NAND3#29pmos@95_poly-right##34 Cin_to_XOR2___NAND3#29pmos@95_poly-right##35 9.877
R4198 Cin_to_XOR2___NAND3#29pmos@95_poly-right##35 Cin_to_XOR2___NAND3#29pmos@95_poly-right##36 9.877
R4199 Cin_to_XOR2___NAND3#29pmos@95_poly-right##36 Cin_to_XOR2___NAND3#29pmos@95_poly-right##37 9.877
R4200 Cin_to_XOR2___NAND3#29pmos@95_poly-right##37 Cin_to_XOR2___NAND3#29pmos@95_poly-right##38 9.877
R4201 Cin_to_XOR2___NAND3#29pmos@95_poly-right##38 Cin_to_XOR2___NAND3#29pmos@95_poly-right##39 9.877
R4202 Cin_to_XOR2___NAND3#29pmos@95_poly-right##39 Cin_to_XOR2___NAND3#29pmos@95_poly-right##40 9.877
R4203 Cin_to_XOR2___NAND3#29pmos@95_poly-right##40 Cin_to_XOR2___NAND3#29pmos@95_poly-right##41 9.877
R4204 Cin_to_XOR2___NAND3#29pmos@95_poly-right##41 Cin_to_XOR2___NAND3#29pmos@95_poly-right##42 9.877
R4205 Cin_to_XOR2___NAND3#29pmos@95_poly-right##42 Cin_to_XOR2___NAND3#29pmos@95_poly-right##43 9.877
R4206 Cin_to_XOR2___NAND3#29pmos@95_poly-right##43 Cin_to_XOR2___NAND3#29pmos@95_poly-right##44 9.877
R4207 Cin_to_XOR2___NAND3#29pmos@95_poly-right##44 Cin_to_XOR2___NAND3#29pmos@95_poly-right##45 9.877
R4208 Cin_to_XOR2___NAND3#29pmos@95_poly-right##45 Cin_to_XOR2___NAND3#29pmos@95_poly-right##46 9.877
R4209 Cin_to_XOR2___NAND3#29pmos@95_poly-right##46 Cin_to_XOR2___NAND3#29pmos@95_poly-right##47 9.877
R4210 Cin_to_XOR2___NAND3#29pmos@95_poly-right##47 Cin_to_XOR2___NAND3#29pmos@95_poly-right##48 9.877
R4211 Cin_to_XOR2___NAND3#29pmos@95_poly-right##48 Cin_to_XOR2___NAND3#29pmos@95_poly-right##49 9.877
R4212 Cin_to_XOR2___NAND3#29pmos@95_poly-right##49 Cin_to_XOR2___NAND3#23pin@580_polysilicon-1 9.877
R4213 NAND1_to_NAND5 NAND1_to_NAND5#4nmos@95_diff-bottom 4.823
R4214 A2#10pin@583_polysilicon-1 A2#10pin@583_polysilicon-1##0 9.938
R4215 A2#10pin@583_polysilicon-1##0 A2#10pin@583_polysilicon-1##1 9.938
R4216 A2#10pin@583_polysilicon-1##1 A2#10pin@583_polysilicon-1##2 9.938
R4217 A2#10pin@583_polysilicon-1##2 A2#10pin@583_polysilicon-1##3 9.938
R4218 A2#10pin@583_polysilicon-1##3 A2#10pin@583_polysilicon-1##4 9.938
R4219 A2#10pin@583_polysilicon-1##4 A2#10pin@583_polysilicon-1##5 9.938
R4220 A2#10pin@583_polysilicon-1##5 A2#10pin@583_polysilicon-1##6 9.938
R4221 A2#10pin@583_polysilicon-1##6 A2#10pin@583_polysilicon-1##7 9.938
R4222 A2#10pin@583_polysilicon-1##7 A2#10pin@583_polysilicon-1##8 9.938
R4223 A2#10pin@583_polysilicon-1##8 A2#10pin@583_polysilicon-1##9 9.938
R4224 A2#10pin@583_polysilicon-1##9 A2#10pin@583_polysilicon-1##10 9.938
R4225 A2#10pin@583_polysilicon-1##10 A2#10pin@583_polysilicon-1##11 9.938
R4226 A2#10pin@583_polysilicon-1##11 A2#10pin@583_polysilicon-1##12 9.938
R4227 A2#10pin@583_polysilicon-1##12 A2#10pin@583_polysilicon-1##13 9.938
R4228 A2#10pin@583_polysilicon-1##13 A2#10pin@583_polysilicon-1##14 9.938
R4229 A2#10pin@583_polysilicon-1##14 A2#10pin@583_polysilicon-1##15 9.938
R4230 A2#10pin@583_polysilicon-1##15 A2#10pin@583_polysilicon-1##16 9.938
R4231 A2#10pin@583_polysilicon-1##16 A2#10pin@583_polysilicon-1##17 9.938
R4232 A2#10pin@583_polysilicon-1##17 A2#10pin@583_polysilicon-1##18 9.938
R4233 A2#10pin@583_polysilicon-1##18 A2#10pin@583_polysilicon-1##19 9.938
R4234 A2#10pin@583_polysilicon-1##19 A2#10pin@583_polysilicon-1##20 9.938
R4235 A2#10pin@583_polysilicon-1##20 A2#10pin@583_polysilicon-1##21 9.938
R4236 A2#10pin@583_polysilicon-1##21 A2#10pin@583_polysilicon-1##22 9.938
R4237 A2#10pin@583_polysilicon-1##22 A2#10pin@583_polysilicon-1##23 9.938
R4238 A2#10pin@583_polysilicon-1##23 A2#10pin@583_polysilicon-1##24 9.938
R4239 A2#10pin@583_polysilicon-1##24 A2#10pin@583_polysilicon-1##25 9.938
R4240 A2#10pin@583_polysilicon-1##25 A2#10pin@583_polysilicon-1##26 9.938
R4241 A2#10pin@583_polysilicon-1##26 A2#10pin@583_polysilicon-1##27 9.938
R4242 A2#10pin@583_polysilicon-1##27 A2#10pin@583_polysilicon-1##28 9.938
R4243 A2#10pin@583_polysilicon-1##28 A2#10pin@583_polysilicon-1##29 9.938
R4244 A2#10pin@583_polysilicon-1##29 A2#10pin@583_polysilicon-1##30 9.938
R4245 A2#10pin@583_polysilicon-1##30 A2#10pin@583_polysilicon-1##31 9.938
R4246 A2#10pin@583_polysilicon-1##31 A2#10pin@583_polysilicon-1##32 9.938
R4247 A2#10pin@583_polysilicon-1##32 A2#10pin@583_polysilicon-1##33 9.938
R4248 A2#10pin@583_polysilicon-1##33 A2#10pin@583_polysilicon-1##34 9.938
R4249 A2#10pin@583_polysilicon-1##34 A2#10pin@583_polysilicon-1##35 9.938
R4250 A2#10pin@583_polysilicon-1##35 A2#10pin@583_polysilicon-1##36 9.938
R4251 A2#10pin@583_polysilicon-1##36 A2#10pin@583_polysilicon-1##37 9.938
R4252 A2#10pin@583_polysilicon-1##37 A2#10pin@583_polysilicon-1##38 9.938
R4253 A2#10pin@583_polysilicon-1##38 A2#10pin@583_polysilicon-1##39 9.938
R4254 A2#10pin@583_polysilicon-1##39 A2#10pin@583_polysilicon-1##40 9.938
R4255 A2#10pin@583_polysilicon-1##40 A2#10pin@583_polysilicon-1##41 9.938
R4256 A2#10pin@583_polysilicon-1##41 A2#10pin@583_polysilicon-1##42 9.938
R4257 A2#10pin@583_polysilicon-1##42 A2#10pin@583_polysilicon-1##43 9.938
R4258 A2#10pin@583_polysilicon-1##43 A2#10pin@583_polysilicon-1##44 9.938
R4259 A2#10pin@583_polysilicon-1##44 A2#10pin@583_polysilicon-1##45 9.938
R4260 A2#10pin@583_polysilicon-1##45 A2#10pin@583_polysilicon-1##46 9.938
R4261 A2#10pin@583_polysilicon-1##46 A2#10pin@583_polysilicon-1##47 9.938
R4262 A2#10pin@583_polysilicon-1##47 A2#10pin@583_polysilicon-1##48 9.938
R4263 A2#10pin@583_polysilicon-1##48 A2#10pin@583_polysilicon-1##49 9.938
R4264 A2#10pin@583_polysilicon-1##49 A2#19nmos@96_poly-right 9.938
R4265 B2#20pmos@97_poly-right B2#20pmos@97_poly-right##0 9.869
R4266 B2#20pmos@97_poly-right##0 B2#20pmos@97_poly-right##1 9.869
R4267 B2#20pmos@97_poly-right##1 B2#20pmos@97_poly-right##2 9.869
R4268 B2#20pmos@97_poly-right##2 B2#20pmos@97_poly-right##3 9.869
R4269 B2#20pmos@97_poly-right##3 B2#20pmos@97_poly-right##4 9.869
R4270 B2#20pmos@97_poly-right##4 B2#20pmos@97_poly-right##5 9.869
R4271 B2#20pmos@97_poly-right##5 B2#20pmos@97_poly-right##6 9.869
R4272 B2#20pmos@97_poly-right##6 B2#20pmos@97_poly-right##7 9.869
R4273 B2#20pmos@97_poly-right##7 B2#20pmos@97_poly-right##8 9.869
R4274 B2#20pmos@97_poly-right##8 B2#20pmos@97_poly-right##9 9.869
R4275 B2#20pmos@97_poly-right##9 B2#20pmos@97_poly-right##10 9.869
R4276 B2#20pmos@97_poly-right##10 B2#20pmos@97_poly-right##11 9.869
R4277 B2#20pmos@97_poly-right##11 B2#20pmos@97_poly-right##12 9.869
R4278 B2#20pmos@97_poly-right##12 B2#20pmos@97_poly-right##13 9.869
R4279 B2#20pmos@97_poly-right##13 B2#20pmos@97_poly-right##14 9.869
R4280 B2#20pmos@97_poly-right##14 B2#20pmos@97_poly-right##15 9.869
R4281 B2#20pmos@97_poly-right##15 B2#20pmos@97_poly-right##16 9.869
R4282 B2#20pmos@97_poly-right##16 B2#20pmos@97_poly-right##17 9.869
R4283 B2#20pmos@97_poly-right##17 B2#20pmos@97_poly-right##18 9.869
R4284 B2#20pmos@97_poly-right##18 B2#20pmos@97_poly-right##19 9.869
R4285 B2#20pmos@97_poly-right##19 B2#20pmos@97_poly-right##20 9.869
R4286 B2#20pmos@97_poly-right##20 B2#20pmos@97_poly-right##21 9.869
R4287 B2#20pmos@97_poly-right##21 B2#20pmos@97_poly-right##22 9.869
R4288 B2#20pmos@97_poly-right##22 B2#20pmos@97_poly-right##23 9.869
R4289 B2#20pmos@97_poly-right##23 B2#20pmos@97_poly-right##24 9.869
R4290 B2#20pmos@97_poly-right##24 B2#20pmos@97_poly-right##25 9.869
R4291 B2#20pmos@97_poly-right##25 B2#20pmos@97_poly-right##26 9.869
R4292 B2#20pmos@97_poly-right##26 B2#20pmos@97_poly-right##27 9.869
R4293 B2#20pmos@97_poly-right##27 B2#20pmos@97_poly-right##28 9.869
R4294 B2#20pmos@97_poly-right##28 B2#20pmos@97_poly-right##29 9.869
R4295 B2#20pmos@97_poly-right##29 B2#20pmos@97_poly-right##30 9.869
R4296 B2#20pmos@97_poly-right##30 B2#20pmos@97_poly-right##31 9.869
R4297 B2#20pmos@97_poly-right##31 B2#20pmos@97_poly-right##32 9.869
R4298 B2#20pmos@97_poly-right##32 B2#20pmos@97_poly-right##33 9.869
R4299 B2#20pmos@97_poly-right##33 B2#20pmos@97_poly-right##34 9.869
R4300 B2#20pmos@97_poly-right##34 B2#20pmos@97_poly-right##35 9.869
R4301 B2#20pmos@97_poly-right##35 B2#20pmos@97_poly-right##36 9.869
R4302 B2#20pmos@97_poly-right##36 B2#20pmos@97_poly-right##37 9.869
R4303 B2#20pmos@97_poly-right##37 B2#20pmos@97_poly-right##38 9.869
R4304 B2#20pmos@97_poly-right##38 B2#20pmos@97_poly-right##39 9.869
R4305 B2#20pmos@97_poly-right##39 B2#20pmos@97_poly-right##40 9.869
R4306 B2#20pmos@97_poly-right##40 B2#20pmos@97_poly-right##41 9.869
R4307 B2#20pmos@97_poly-right##41 B2#20pmos@97_poly-right##42 9.869
R4308 B2#20pmos@97_poly-right##42 B2#20pmos@97_poly-right##43 9.869
R4309 B2#20pmos@97_poly-right##43 B2#20pmos@97_poly-right##44 9.869
R4310 B2#20pmos@97_poly-right##44 B2#20pmos@97_poly-right##45 9.869
R4311 B2#20pmos@97_poly-right##45 B2#20pmos@97_poly-right##46 9.869
R4312 B2#20pmos@97_poly-right##46 B2#20pmos@97_poly-right##47 9.869
R4313 B2#20pmos@97_poly-right##47 B2#10pin@587_polysilicon-1 9.869
R4314 NAND2_to_Nand5#9pin@589_polysilicon-1 NAND2_to_Nand5#9pin@589_polysilicon-1##0 9.938
R4315 NAND2_to_Nand5#9pin@589_polysilicon-1##0 NAND2_to_Nand5#9pin@589_polysilicon-1##1 9.938
R4316 NAND2_to_Nand5#9pin@589_polysilicon-1##1 NAND2_to_Nand5#9pin@589_polysilicon-1##2 9.938
R4317 NAND2_to_Nand5#9pin@589_polysilicon-1##2 NAND2_to_Nand5#9pin@589_polysilicon-1##3 9.938
R4318 NAND2_to_Nand5#9pin@589_polysilicon-1##3 NAND2_to_Nand5#9pin@589_polysilicon-1##4 9.938
R4319 NAND2_to_Nand5#9pin@589_polysilicon-1##4 NAND2_to_Nand5#9pin@589_polysilicon-1##5 9.938
R4320 NAND2_to_Nand5#9pin@589_polysilicon-1##5 NAND2_to_Nand5#9pin@589_polysilicon-1##6 9.938
R4321 NAND2_to_Nand5#9pin@589_polysilicon-1##6 NAND2_to_Nand5#9pin@589_polysilicon-1##7 9.938
R4322 NAND2_to_Nand5#9pin@589_polysilicon-1##7 NAND2_to_Nand5#9pin@589_polysilicon-1##8 9.938
R4323 NAND2_to_Nand5#9pin@589_polysilicon-1##8 NAND2_to_Nand5#9pin@589_polysilicon-1##9 9.938
R4324 NAND2_to_Nand5#9pin@589_polysilicon-1##9 NAND2_to_Nand5#9pin@589_polysilicon-1##10 9.938
R4325 NAND2_to_Nand5#9pin@589_polysilicon-1##10 NAND2_to_Nand5#9pin@589_polysilicon-1##11 9.938
R4326 NAND2_to_Nand5#9pin@589_polysilicon-1##11 NAND2_to_Nand5#9pin@589_polysilicon-1##12 9.938
R4327 NAND2_to_Nand5#9pin@589_polysilicon-1##12 NAND2_to_Nand5#9pin@589_polysilicon-1##13 9.938
R4328 NAND2_to_Nand5#9pin@589_polysilicon-1##13 NAND2_to_Nand5#9pin@589_polysilicon-1##14 9.938
R4329 NAND2_to_Nand5#9pin@589_polysilicon-1##14 NAND2_to_Nand5#9pin@589_polysilicon-1##15 9.938
R4330 NAND2_to_Nand5#9pin@589_polysilicon-1##15 NAND2_to_Nand5#9pin@589_polysilicon-1##16 9.938
R4331 NAND2_to_Nand5#9pin@589_polysilicon-1##16 NAND2_to_Nand5#9pin@589_polysilicon-1##17 9.938
R4332 NAND2_to_Nand5#9pin@589_polysilicon-1##17 NAND2_to_Nand5#9pin@589_polysilicon-1##18 9.938
R4333 NAND2_to_Nand5#9pin@589_polysilicon-1##18 NAND2_to_Nand5#9pin@589_polysilicon-1##19 9.938
R4334 NAND2_to_Nand5#9pin@589_polysilicon-1##19 NAND2_to_Nand5#9pin@589_polysilicon-1##20 9.938
R4335 NAND2_to_Nand5#9pin@589_polysilicon-1##20 NAND2_to_Nand5#9pin@589_polysilicon-1##21 9.938
R4336 NAND2_to_Nand5#9pin@589_polysilicon-1##21 NAND2_to_Nand5#9pin@589_polysilicon-1##22 9.938
R4337 NAND2_to_Nand5#9pin@589_polysilicon-1##22 NAND2_to_Nand5#9pin@589_polysilicon-1##23 9.938
R4338 NAND2_to_Nand5#9pin@589_polysilicon-1##23 NAND2_to_Nand5#9pin@589_polysilicon-1##24 9.938
R4339 NAND2_to_Nand5#9pin@589_polysilicon-1##24 NAND2_to_Nand5#9pin@589_polysilicon-1##25 9.938
R4340 NAND2_to_Nand5#9pin@589_polysilicon-1##25 NAND2_to_Nand5#9pin@589_polysilicon-1##26 9.938
R4341 NAND2_to_Nand5#9pin@589_polysilicon-1##26 NAND2_to_Nand5#9pin@589_polysilicon-1##27 9.938
R4342 NAND2_to_Nand5#9pin@589_polysilicon-1##27 NAND2_to_Nand5#9pin@589_polysilicon-1##28 9.938
R4343 NAND2_to_Nand5#9pin@589_polysilicon-1##28 NAND2_to_Nand5#9pin@589_polysilicon-1##29 9.938
R4344 NAND2_to_Nand5#9pin@589_polysilicon-1##29 NAND2_to_Nand5#9pin@589_polysilicon-1##30 9.938
R4345 NAND2_to_Nand5#9pin@589_polysilicon-1##30 NAND2_to_Nand5#9pin@589_polysilicon-1##31 9.938
R4346 NAND2_to_Nand5#9pin@589_polysilicon-1##31 NAND2_to_Nand5#9pin@589_polysilicon-1##32 9.938
R4347 NAND2_to_Nand5#9pin@589_polysilicon-1##32 NAND2_to_Nand5#9pin@589_polysilicon-1##33 9.938
R4348 NAND2_to_Nand5#9pin@589_polysilicon-1##33 NAND2_to_Nand5#9pin@589_polysilicon-1##34 9.938
R4349 NAND2_to_Nand5#9pin@589_polysilicon-1##34 NAND2_to_Nand5#9pin@589_polysilicon-1##35 9.938
R4350 NAND2_to_Nand5#9pin@589_polysilicon-1##35 NAND2_to_Nand5#9pin@589_polysilicon-1##36 9.938
R4351 NAND2_to_Nand5#9pin@589_polysilicon-1##36 NAND2_to_Nand5#9pin@589_polysilicon-1##37 9.938
R4352 NAND2_to_Nand5#9pin@589_polysilicon-1##37 NAND2_to_Nand5#9pin@589_polysilicon-1##38 9.938
R4353 NAND2_to_Nand5#9pin@589_polysilicon-1##38 NAND2_to_Nand5#9pin@589_polysilicon-1##39 9.938
R4354 NAND2_to_Nand5#9pin@589_polysilicon-1##39 NAND2_to_Nand5#9pin@589_polysilicon-1##40 9.938
R4355 NAND2_to_Nand5#9pin@589_polysilicon-1##40 NAND2_to_Nand5#9pin@589_polysilicon-1##41 9.938
R4356 NAND2_to_Nand5#9pin@589_polysilicon-1##41 NAND2_to_Nand5#9pin@589_polysilicon-1##42 9.938
R4357 NAND2_to_Nand5#9pin@589_polysilicon-1##42 NAND2_to_Nand5#9pin@589_polysilicon-1##43 9.938
R4358 NAND2_to_Nand5#9pin@589_polysilicon-1##43 NAND2_to_Nand5#9pin@589_polysilicon-1##44 9.938
R4359 NAND2_to_Nand5#9pin@589_polysilicon-1##44 NAND2_to_Nand5#9pin@589_polysilicon-1##45 9.938
R4360 NAND2_to_Nand5#9pin@589_polysilicon-1##45 NAND2_to_Nand5#9pin@589_polysilicon-1##46 9.938
R4361 NAND2_to_Nand5#9pin@589_polysilicon-1##46 NAND2_to_Nand5#9pin@589_polysilicon-1##47 9.938
R4362 NAND2_to_Nand5#9pin@589_polysilicon-1##47 NAND2_to_Nand5#9pin@589_polysilicon-1##48 9.938
R4363 NAND2_to_Nand5#9pin@589_polysilicon-1##48 NAND2_to_Nand5#9pin@589_polysilicon-1##49 9.938
R4364 NAND2_to_Nand5#9pin@589_polysilicon-1##49 NAND2_to_Nand5#11nmos@98_poly-right 9.938
R4365 NAND1_to_NAND5#14nmos@99_poly-right NAND1_to_NAND5#14nmos@99_poly-right##0 9.898
R4366 NAND1_to_NAND5#14nmos@99_poly-right##0 NAND1_to_NAND5#14nmos@99_poly-right##1 9.898
R4367 NAND1_to_NAND5#14nmos@99_poly-right##1 NAND1_to_NAND5#14nmos@99_poly-right##2 9.898
R4368 NAND1_to_NAND5#14nmos@99_poly-right##2 NAND1_to_NAND5#14nmos@99_poly-right##3 9.898
R4369 NAND1_to_NAND5#14nmos@99_poly-right##3 NAND1_to_NAND5#14nmos@99_poly-right##4 9.898
R4370 NAND1_to_NAND5#14nmos@99_poly-right##4 NAND1_to_NAND5#14nmos@99_poly-right##5 9.898
R4371 NAND1_to_NAND5#14nmos@99_poly-right##5 NAND1_to_NAND5#14nmos@99_poly-right##6 9.898
R4372 NAND1_to_NAND5#14nmos@99_poly-right##6 NAND1_to_NAND5#14nmos@99_poly-right##7 9.898
R4373 NAND1_to_NAND5#14nmos@99_poly-right##7 NAND1_to_NAND5#14nmos@99_poly-right##8 9.898
R4374 NAND1_to_NAND5#14nmos@99_poly-right##8 NAND1_to_NAND5#14nmos@99_poly-right##9 9.898
R4375 NAND1_to_NAND5#14nmos@99_poly-right##9 NAND1_to_NAND5#14nmos@99_poly-right##10 9.898
R4376 NAND1_to_NAND5#14nmos@99_poly-right##10 NAND1_to_NAND5#14nmos@99_poly-right##11 9.898
R4377 NAND1_to_NAND5#14nmos@99_poly-right##11 NAND1_to_NAND5#14nmos@99_poly-right##12 9.898
R4378 NAND1_to_NAND5#14nmos@99_poly-right##12 NAND1_to_NAND5#14nmos@99_poly-right##13 9.898
R4379 NAND1_to_NAND5#14nmos@99_poly-right##13 NAND1_to_NAND5#14nmos@99_poly-right##14 9.898
R4380 NAND1_to_NAND5#14nmos@99_poly-right##14 NAND1_to_NAND5#14nmos@99_poly-right##15 9.898
R4381 NAND1_to_NAND5#14nmos@99_poly-right##15 NAND1_to_NAND5#14nmos@99_poly-right##16 9.898
R4382 NAND1_to_NAND5#14nmos@99_poly-right##16 NAND1_to_NAND5#14nmos@99_poly-right##17 9.898
R4383 NAND1_to_NAND5#14nmos@99_poly-right##17 NAND1_to_NAND5#14nmos@99_poly-right##18 9.898
R4384 NAND1_to_NAND5#14nmos@99_poly-right##18 NAND1_to_NAND5#14nmos@99_poly-right##19 9.898
R4385 NAND1_to_NAND5#14nmos@99_poly-right##19 NAND1_to_NAND5#14nmos@99_poly-right##20 9.898
R4386 NAND1_to_NAND5#14nmos@99_poly-right##20 NAND1_to_NAND5#14nmos@99_poly-right##21 9.898
R4387 NAND1_to_NAND5#14nmos@99_poly-right##21 NAND1_to_NAND5#14nmos@99_poly-right##22 9.898
R4388 NAND1_to_NAND5#14nmos@99_poly-right##22 NAND1_to_NAND5#14nmos@99_poly-right##23 9.898
R4389 NAND1_to_NAND5#14nmos@99_poly-right##23 NAND1_to_NAND5#14nmos@99_poly-right##24 9.898
R4390 NAND1_to_NAND5#14nmos@99_poly-right##24 NAND1_to_NAND5#14nmos@99_poly-right##25 9.898
R4391 NAND1_to_NAND5#14nmos@99_poly-right##25 NAND1_to_NAND5#14nmos@99_poly-right##26 9.898
R4392 NAND1_to_NAND5#14nmos@99_poly-right##26 NAND1_to_NAND5#14nmos@99_poly-right##27 9.898
R4393 NAND1_to_NAND5#14nmos@99_poly-right##27 NAND1_to_NAND5#14nmos@99_poly-right##28 9.898
R4394 NAND1_to_NAND5#14nmos@99_poly-right##28 NAND1_to_NAND5#14nmos@99_poly-right##29 9.898
R4395 NAND1_to_NAND5#14nmos@99_poly-right##29 NAND1_to_NAND5#14nmos@99_poly-right##30 9.898
R4396 NAND1_to_NAND5#14nmos@99_poly-right##30 NAND1_to_NAND5#14nmos@99_poly-right##31 9.898
R4397 NAND1_to_NAND5#14nmos@99_poly-right##31 NAND1_to_NAND5#14nmos@99_poly-right##32 9.898
R4398 NAND1_to_NAND5#14nmos@99_poly-right##32 NAND1_to_NAND5#14nmos@99_poly-right##33 9.898
R4399 NAND1_to_NAND5#14nmos@99_poly-right##33 NAND1_to_NAND5#14nmos@99_poly-right##34 9.898
R4400 NAND1_to_NAND5#14nmos@99_poly-right##34 NAND1_to_NAND5#14nmos@99_poly-right##35 9.898
R4401 NAND1_to_NAND5#14nmos@99_poly-right##35 NAND1_to_NAND5#14nmos@99_poly-right##36 9.898
R4402 NAND1_to_NAND5#14nmos@99_poly-right##36 NAND1_to_NAND5#14nmos@99_poly-right##37 9.898
R4403 NAND1_to_NAND5#14nmos@99_poly-right##37 NAND1_to_NAND5#14nmos@99_poly-right##38 9.898
R4404 NAND1_to_NAND5#14nmos@99_poly-right##38 NAND1_to_NAND5#14nmos@99_poly-right##39 9.898
R4405 NAND1_to_NAND5#14nmos@99_poly-right##39 NAND1_to_NAND5#14nmos@99_poly-right##40 9.898
R4406 NAND1_to_NAND5#14nmos@99_poly-right##40 NAND1_to_NAND5#14nmos@99_poly-right##41 9.898
R4407 NAND1_to_NAND5#14nmos@99_poly-right##41 NAND1_to_NAND5#14nmos@99_poly-right##42 9.898
R4408 NAND1_to_NAND5#14nmos@99_poly-right##42 NAND1_to_NAND5#14nmos@99_poly-right##43 9.898
R4409 NAND1_to_NAND5#14nmos@99_poly-right##43 NAND1_to_NAND5#14nmos@99_poly-right##44 9.898
R4410 NAND1_to_NAND5#14nmos@99_poly-right##44 NAND1_to_NAND5#14nmos@99_poly-right##45 9.898
R4411 NAND1_to_NAND5#14nmos@99_poly-right##45 NAND1_to_NAND5#14nmos@99_poly-right##46 9.898
R4412 NAND1_to_NAND5#14nmos@99_poly-right##46 NAND1_to_NAND5#14nmos@99_poly-right##47 9.898
R4413 NAND1_to_NAND5#14nmos@99_poly-right##47 NAND1_to_NAND5#14nmos@99_poly-right##48 9.898
R4414 NAND1_to_NAND5#14nmos@99_poly-right##48 NAND1_to_NAND5#14nmos@99_poly-right##49 9.898
R4415 NAND1_to_NAND5#14nmos@99_poly-right##49 NAND1_to_NAND5#14nmos@99_poly-right##50 9.898
R4416 NAND1_to_NAND5#14nmos@99_poly-right##50 NAND1_to_NAND5#14nmos@99_poly-right##51 9.898
R4417 NAND1_to_NAND5#14nmos@99_poly-right##51 NAND1_to_NAND5#14nmos@99_poly-right##52 9.898
R4418 NAND1_to_NAND5#14nmos@99_poly-right##52 NAND1_to_NAND5#14nmos@99_poly-right##53 9.898
R4419 NAND1_to_NAND5#14nmos@99_poly-right##53 NAND1_to_NAND5#14nmos@99_poly-right##54 9.898
R4420 NAND1_to_NAND5#14nmos@99_poly-right##54 NAND1_to_NAND5#14nmos@99_poly-right##55 9.898
R4421 NAND1_to_NAND5#14nmos@99_poly-right##55 NAND1_to_NAND5#11pmos@99_poly-right 9.898
R4422 NAND2_to_Nand5 NAND2_to_Nand5#4nmos@97_diff-bottom 4.42
R4423 A2 A2##0 9.854
C347 A2##0 0 10.57fF
R4424 A2##0 A2#1pin@586_metal-2 9.854
R4425 B2 B2##0 9.756
C348 B2##0 0 10.466fF
R4426 B2##0 B2#1pin@588_metal-2 9.756
R4427 net@2106 net@2106##0 9.92
R4428 net@2106##0 net@2106##1 9.92
R4429 net@2106##1 net@2106##2 9.92
R4430 net@2106##2 net@2106##3 9.92
R4431 net@2106##3 net@2106##4 9.92
R4432 net@2106##4 net@2106##5 9.92
R4433 net@2106##5 net@2106##6 9.92
R4434 net@2106##6 net@2106##7 9.92
R4435 net@2106##7 net@2106##8 9.92
R4436 net@2106##8 net@2106##9 9.92
R4437 net@2106##9 net@2106##10 9.92
R4438 net@2106##10 net@2106##11 9.92
R4439 net@2106##11 net@2106##12 9.92
R4440 net@2106##12 net@2106##13 9.92
R4441 net@2106##13 net@2106##14 9.92
R4442 net@2106##14 net@2106##15 9.92
R4443 net@2106##15 net@2106##16 9.92
R4444 net@2106##16 net@2106##17 9.92
R4445 net@2106##17 net@2106##18 9.92
R4446 net@2106##18 net@2106#1pin@641_polysilicon-1 9.92
R4447 net@2108 net@2108##0 9.92
R4448 net@2108##0 net@2108##1 9.92
R4449 net@2108##1 net@2108##2 9.92
R4450 net@2108##2 net@2108##3 9.92
R4451 net@2108##3 net@2108##4 9.92
R4452 net@2108##4 net@2108##5 9.92
R4453 net@2108##5 net@2108##6 9.92
R4454 net@2108##6 net@2108##7 9.92
R4455 net@2108##7 net@2108##8 9.92
R4456 net@2108##8 net@2108##9 9.92
R4457 net@2108##9 net@2108##10 9.92
R4458 net@2108##10 net@2108##11 9.92
R4459 net@2108##11 net@2108##12 9.92
R4460 net@2108##12 net@2108##13 9.92
R4461 net@2108##13 net@2108##14 9.92
R4462 net@2108##14 net@2108##15 9.92
R4463 net@2108##15 net@2108##16 9.92
R4464 net@2108##16 net@2108##17 9.92
R4465 net@2108##17 net@2108##18 9.92
R4466 net@2108##18 net@2108#1pin@666_polysilicon-1 9.92
R4467 XOR1_to_NAND4#3pin@667_polysilicon-1 XOR1_to_NAND4#3pin@667_polysilicon-1##0 6.2
R4468 XOR1_to_NAND4#3pin@667_polysilicon-1##0 XOR1_to_NAND4#4pmos@112_poly-right 6.2
R4469 XOR1_to_NAND4#3pin@667_polysilicon-1 XOR1_to_NAND4#3pin@667_polysilicon-1##0 8.138
R4470 XOR1_to_NAND4#3pin@667_polysilicon-1##0 XOR1_to_NAND4#3pin@667_polysilicon-1##1 8.138
R4471 XOR1_to_NAND4#3pin@667_polysilicon-1##1 XOR1_to_NAND4#3pin@667_polysilicon-1##2 8.138
R4472 XOR1_to_NAND4#3pin@667_polysilicon-1##2 XOR1_to_NAND4#1contact@766_metal-1-metal-2 8.138
R4473 Cin_to_XOR2___NAND4#14nmos@111_poly-right Cin_to_XOR2___NAND4#14nmos@111_poly-right##0 5.425
R4474 Cin_to_XOR2___NAND4#14nmos@111_poly-right##0 Cin_to_XOR2___NAND4#15pin@657_polysilicon-1 5.425
R4475 Cin_to_XOR2___NAND4 Cin_to_XOR2___NAND4##0 8.99
R4476 Cin_to_XOR2___NAND4##0 Cin_to_XOR2___NAND4##1 8.99
R4477 Cin_to_XOR2___NAND4##1 Cin_to_XOR2___NAND4##2 8.99
R4478 Cin_to_XOR2___NAND4##2 Cin_to_XOR2___NAND4##3 8.99
R4479 Cin_to_XOR2___NAND4##3 Cin_to_XOR2___NAND4#15pin@657_polysilicon-1 8.99
R4480 A3#3pin@642_polysilicon-1 A3#3pin@642_polysilicon-1##0 6.2
R4481 A3#3pin@642_polysilicon-1##0 A3#4pmos@105_poly-right 6.2
R4482 XOR1_to_NAND4#9pmos@107_poly-left XOR1_to_NAND4#9pmos@107_poly-left##0 8.138
R4483 XOR1_to_NAND4#9pmos@107_poly-left##0 XOR1_to_NAND4#9pmos@107_poly-left##1 8.138
R4484 XOR1_to_NAND4#9pmos@107_poly-left##1 XOR1_to_NAND4#9pmos@107_poly-left##2 8.138
R4485 XOR1_to_NAND4#9pmos@107_poly-left##2 XOR1_to_NAND4#10pin@654_polysilicon-1 8.138
R4486 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##0 9.843
R4487 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##0 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##1 9.843
R4488 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##1 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##2 9.843
R4489 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##2 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##3 9.843
R4490 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##3 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##4 9.843
R4491 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##4 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##5 9.843
R4492 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##5 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##6 9.843
R4493 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##6 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##7 9.843
R4494 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##7 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##8 9.843
R4495 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##8 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##9 9.843
R4496 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##9 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##10 9.843
R4497 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##10 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##11 9.843
R4498 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##11 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##12 9.843
R4499 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##12 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##13 9.843
R4500 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##13 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##14 9.843
R4501 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##14 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##15 9.843
R4502 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##15 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##16 9.843
R4503 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##16 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##17 9.843
R4504 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##17 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##18 9.843
R4505 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##18 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1 9.843
R4506 net@2117#4nmos@113_poly-right net@2117#4nmos@113_poly-right##0 9.3
R4507 net@2117#4nmos@113_poly-right##0 net@2117#4nmos@113_poly-right##1 9.3
R4508 net@2117#4nmos@113_poly-right##1 net@2117#5pin@659_polysilicon-1 9.3
R4509 net@2117#2contact@752_metal-1-polysilicon-1 net@2117#2contact@752_metal-1-polysilicon-1##0 8.99
R4510 net@2117#2contact@752_metal-1-polysilicon-1##0 net@2117#2contact@752_metal-1-polysilicon-1##1 8.99
R4511 net@2117#2contact@752_metal-1-polysilicon-1##1 net@2117#2contact@752_metal-1-polysilicon-1##2 8.99
R4512 net@2117#2contact@752_metal-1-polysilicon-1##2 net@2117#2contact@752_metal-1-polysilicon-1##3 8.99
R4513 net@2117#2contact@752_metal-1-polysilicon-1##3 net@2117#5pin@659_polysilicon-1 8.99
R4514 A3#3pin@642_polysilicon-1 A3#3pin@642_polysilicon-1##0 8.138
R4515 A3#3pin@642_polysilicon-1##0 A3#3pin@642_polysilicon-1##1 8.138
R4516 A3#3pin@642_polysilicon-1##1 A3#3pin@642_polysilicon-1##2 8.138
R4517 A3#3pin@642_polysilicon-1##2 A3#1pin@681_metal-2 8.138
R4518 XOR1_to_NAND4#1contact@766_metal-1-metal-2 XOR1_to_NAND4#1contact@766_metal-1-metal-2##0 6.717
R4519 XOR1_to_NAND4#1contact@766_metal-1-metal-2##0 XOR1_to_NAND4#1contact@766_metal-1-metal-2##1 6.717
R4520 XOR1_to_NAND4#1contact@766_metal-1-metal-2##1 XOR1_to_NAND4#12pin@655_polysilicon-1 6.717
R4521 XOR1_to_NAND4#10pin@654_polysilicon-1 XOR1_to_NAND4#10pin@654_polysilicon-1##0 7.75
R4522 XOR1_to_NAND4#10pin@654_polysilicon-1##0 XOR1_to_NAND4#10pin@654_polysilicon-1##1 7.75
R4523 XOR1_to_NAND4#10pin@654_polysilicon-1##1 XOR1_to_NAND4#12pin@655_polysilicon-1 7.75
R4524 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1##0 9.743
R4525 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1##0 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1##1 9.743
R4526 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1##1 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1##2 9.743
R4527 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1##2 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1##3 9.743
R4528 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1##3 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1##4 9.743
R4529 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1##4 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1##5 9.743
R4530 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1##5 Cin_to_XOR2___NAND4 9.743
R4531 net@2108#7pmos@108_poly-left net@2108#7pmos@108_poly-left##0 7.75
R4532 net@2108#7pmos@108_poly-left##0 net@2108 7.75
R4533 Cin_to_XOR2___NAND4#18nmos@109_poly-left Cin_to_XOR2___NAND4#18nmos@109_poly-left##0 6.2
R4534 Cin_to_XOR2___NAND4#18nmos@109_poly-left##0 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1 6.2
R4535 net@2118#9nmos@110_poly-left net@2118#9nmos@110_poly-left##0 8.37
R4536 net@2118#9nmos@110_poly-left##0 net@2118#9nmos@110_poly-left##1 8.37
R4537 net@2118#9nmos@110_poly-left##1 net@2118#9nmos@110_poly-left##2 8.37
R4538 net@2118#9nmos@110_poly-left##2 net@2118#9nmos@110_poly-left##3 8.37
R4539 net@2118#9nmos@110_poly-left##3 net@2118#2contact@727_metal-1-metal-2 8.37
R4540 XOR1_to_NAND4 XOR1_to_NAND4##0 6.717
R4541 XOR1_to_NAND4##0 XOR1_to_NAND4##1 6.717
R4542 XOR1_to_NAND4##1 XOR1_to_NAND4#14pin@671_polysilicon-1 6.717
R4543 XOR1_to_NAND4#16pmos@114_poly-right XOR1_to_NAND4#16pmos@114_poly-right##0 6.2
R4544 XOR1_to_NAND4#16pmos@114_poly-right##0 XOR1_to_NAND4#14pin@671_polysilicon-1 6.2
R4545 Cin_to_XOR2___NAND4#23pin@675_polysilicon-1 Cin_to_XOR2___NAND4#23pin@675_polysilicon-1##0 9.688
R4546 Cin_to_XOR2___NAND4#23pin@675_polysilicon-1##0 Cin_to_XOR2___NAND4#23pin@675_polysilicon-1##1 9.688
R4547 Cin_to_XOR2___NAND4#23pin@675_polysilicon-1##1 Cin_to_XOR2___NAND4#23pin@675_polysilicon-1##2 9.688
R4548 Cin_to_XOR2___NAND4#23pin@675_polysilicon-1##2 Cin_to_XOR2___NAND4#20contact@765_metal-1-metal-2 9.688
R4549 Cin_to_XOR2___NAND4#20contact@765_metal-1-metal-2 Cin_to_XOR2___NAND4 4.953
R4550 A3#0contact@774_metal-1-metal-2 A3#0contact@774_metal-1-metal-2##0 6.717
R4551 A3#0contact@774_metal-1-metal-2##0 A3#0contact@774_metal-1-metal-2##1 6.717
R4552 A3#0contact@774_metal-1-metal-2##1 A3#10pin@678_polysilicon-1 6.717
R4553 A3#11pmos@116_poly-right A3#11pmos@116_poly-right##0 9.558
R4554 A3#11pmos@116_poly-right##0 A3#11pmos@116_poly-right##1 9.558
R4555 A3#11pmos@116_poly-right##1 A3#11pmos@116_poly-right##2 9.558
R4556 A3#11pmos@116_poly-right##2 A3#11pmos@116_poly-right##3 9.558
R4557 A3#11pmos@116_poly-right##3 A3#11pmos@116_poly-right##4 9.558
R4558 A3#11pmos@116_poly-right##4 A3#10pin@678_polysilicon-1 9.558
R4559 B3#10pin@682_polysilicon-1 B3#10pin@682_polysilicon-1##0 8.138
R4560 B3#10pin@682_polysilicon-1##0 B3#10pin@682_polysilicon-1##1 8.138
R4561 B3#10pin@682_polysilicon-1##1 B3#10pin@682_polysilicon-1##2 8.138
R4562 B3#10pin@682_polysilicon-1##2 B3#0contact@775_metal-1-metal-2 8.138
R4563 B3#11nmos@104_poly-right B3#11nmos@104_poly-right##0 5.425
R4564 B3#11nmos@104_poly-right##0 B3#12pin@632_polysilicon-1 5.425
R4565 NAND2_to_Nand6 NAND2_to_Nand6##0 6.717
R4566 NAND2_to_Nand6##0 NAND2_to_Nand6##1 6.717
R4567 NAND2_to_Nand6##1 NAND2_to_Nand6#9pin@684_polysilicon-1 6.717
R4568 NAND2_to_Nand6#10pmos@118_poly-right NAND2_to_Nand6#10pmos@118_poly-right##0 9.558
R4569 NAND2_to_Nand6#10pmos@118_poly-right##0 NAND2_to_Nand6#10pmos@118_poly-right##1 9.558
R4570 NAND2_to_Nand6#10pmos@118_poly-right##1 NAND2_to_Nand6#10pmos@118_poly-right##2 9.558
R4571 NAND2_to_Nand6#10pmos@118_poly-right##2 NAND2_to_Nand6#10pmos@118_poly-right##3 9.558
R4572 NAND2_to_Nand6#10pmos@118_poly-right##3 NAND2_to_Nand6#10pmos@118_poly-right##4 9.558
R4573 NAND2_to_Nand6#10pmos@118_poly-right##4 NAND2_to_Nand6#9pin@684_polysilicon-1 9.558
R4574 B3#1pin@683_metal-2 B3#1pin@683_metal-2##0 8.99
R4575 B3#1pin@683_metal-2##0 B3#1pin@683_metal-2##1 8.99
R4576 B3#1pin@683_metal-2##1 B3#1pin@683_metal-2##2 8.99
R4577 B3#1pin@683_metal-2##2 B3#1pin@683_metal-2##3 8.99
R4578 B3#1pin@683_metal-2##3 B3#12pin@632_polysilicon-1 8.99
R4579 NAND1_to_NAND6#11pmos@119_poly-right NAND1_to_NAND6#11pmos@119_poly-right##0 5.425
R4580 NAND1_to_NAND6#11pmos@119_poly-right##0 NAND1_to_NAND6#12pin@688_polysilicon-1 5.425
R4581 NAND1_to_NAND6#12pin@688_polysilicon-1 NAND1_to_NAND6#12pin@688_polysilicon-1##0 9.3
R4582 NAND1_to_NAND6#12pin@688_polysilicon-1##0 NAND1_to_NAND6#12pin@688_polysilicon-1##1 9.3
R4583 NAND1_to_NAND6#12pin@688_polysilicon-1##1 NAND1_to_NAND6 9.3
R4584 Cin_to_XOR2___NAND4#25nmos@115_poly-right Cin_to_XOR2___NAND4#25nmos@115_poly-right##0 8.636
R4585 Cin_to_XOR2___NAND4#25nmos@115_poly-right##0 Cin_to_XOR2___NAND4#25nmos@115_poly-right##1 8.636
R4586 Cin_to_XOR2___NAND4#25nmos@115_poly-right##1 Cin_to_XOR2___NAND4#25nmos@115_poly-right##2 8.636
R4587 Cin_to_XOR2___NAND4#25nmos@115_poly-right##2 Cin_to_XOR2___NAND4#25nmos@115_poly-right##3 8.636
R4588 Cin_to_XOR2___NAND4#25nmos@115_poly-right##3 Cin_to_XOR2___NAND4#25nmos@115_poly-right##4 8.636
R4589 Cin_to_XOR2___NAND4#25nmos@115_poly-right##4 Cin_to_XOR2___NAND4#25nmos@115_poly-right##5 8.636
R4590 Cin_to_XOR2___NAND4#25nmos@115_poly-right##5 Cin_to_XOR2___NAND4#23pin@675_polysilicon-1 8.636
R4591 B3#13nmos@117_poly-right B3#13nmos@117_poly-right##0 8.956
R4592 B3#13nmos@117_poly-right##0 B3#13nmos@117_poly-right##1 8.956
R4593 B3#13nmos@117_poly-right##1 B3#13nmos@117_poly-right##2 8.956
R4594 B3#13nmos@117_poly-right##2 B3#13nmos@117_poly-right##3 8.956
R4595 B3#13nmos@117_poly-right##3 B3#13nmos@117_poly-right##4 8.956
R4596 B3#13nmos@117_poly-right##4 B3#13nmos@117_poly-right##5 8.956
R4597 B3#13nmos@117_poly-right##5 B3#13nmos@117_poly-right##6 8.956
R4598 B3#13nmos@117_poly-right##6 B3#13nmos@117_poly-right##7 8.956
R4599 B3#13nmos@117_poly-right##7 B3#10pin@682_polysilicon-1 8.956
R4600 A3#12pmos@100_poly-left A3#12pmos@100_poly-left##0 8.138
R4601 A3#12pmos@100_poly-left##0 A3#12pmos@100_poly-left##1 8.138
R4602 A3#12pmos@100_poly-left##1 A3#12pmos@100_poly-left##2 8.138
R4603 A3#12pmos@100_poly-left##2 A3#13pin@629_polysilicon-1 8.138
R4604 B3#14pin@622_polysilicon-1 B3#14pin@622_polysilicon-1##0 9.843
R4605 B3#14pin@622_polysilicon-1##0 B3#14pin@622_polysilicon-1##1 9.843
R4606 B3#14pin@622_polysilicon-1##1 B3#14pin@622_polysilicon-1##2 9.843
R4607 B3#14pin@622_polysilicon-1##2 B3#14pin@622_polysilicon-1##3 9.843
R4608 B3#14pin@622_polysilicon-1##3 B3#14pin@622_polysilicon-1##4 9.843
R4609 B3#14pin@622_polysilicon-1##4 B3#14pin@622_polysilicon-1##5 9.843
R4610 B3#14pin@622_polysilicon-1##5 B3#14pin@622_polysilicon-1##6 9.843
R4611 B3#14pin@622_polysilicon-1##6 B3#14pin@622_polysilicon-1##7 9.843
R4612 B3#14pin@622_polysilicon-1##7 B3#14pin@622_polysilicon-1##8 9.843
R4613 B3#14pin@622_polysilicon-1##8 B3#14pin@622_polysilicon-1##9 9.843
R4614 B3#14pin@622_polysilicon-1##9 B3#14pin@622_polysilicon-1##10 9.843
R4615 B3#14pin@622_polysilicon-1##10 B3#14pin@622_polysilicon-1##11 9.843
R4616 B3#14pin@622_polysilicon-1##11 B3#14pin@622_polysilicon-1##12 9.843
R4617 B3#14pin@622_polysilicon-1##12 B3#14pin@622_polysilicon-1##13 9.843
R4618 B3#14pin@622_polysilicon-1##13 B3#14pin@622_polysilicon-1##14 9.843
R4619 B3#14pin@622_polysilicon-1##14 B3#14pin@622_polysilicon-1##15 9.843
R4620 B3#14pin@622_polysilicon-1##15 B3#14pin@622_polysilicon-1##16 9.843
R4621 B3#14pin@622_polysilicon-1##16 B3#14pin@622_polysilicon-1##17 9.843
R4622 B3#14pin@622_polysilicon-1##17 B3#14pin@622_polysilicon-1##18 9.843
R4623 B3#14pin@622_polysilicon-1##18 B3#15pin@639_polysilicon-1 9.843
R4624 net@2204#4nmos@106_poly-right net@2204#4nmos@106_poly-right##0 7.233
R4625 net@2204#4nmos@106_poly-right##0 net@2204#4nmos@106_poly-right##1 7.233
R4626 net@2204#4nmos@106_poly-right##1 net@2204#5pin@634_polysilicon-1 7.233
R4627 net@2204#2contact@713_metal-1-polysilicon-1 net@2204#2contact@713_metal-1-polysilicon-1##0 8.99
R4628 net@2204#2contact@713_metal-1-polysilicon-1##0 net@2204#2contact@713_metal-1-polysilicon-1##1 8.99
R4629 net@2204#2contact@713_metal-1-polysilicon-1##1 net@2204#2contact@713_metal-1-polysilicon-1##2 8.99
R4630 net@2204#2contact@713_metal-1-polysilicon-1##2 net@2204#2contact@713_metal-1-polysilicon-1##3 8.99
R4631 net@2204#2contact@713_metal-1-polysilicon-1##3 net@2204#5pin@634_polysilicon-1 8.99
R4632 A3#1pin@681_metal-2 A3#1pin@681_metal-2##0 6.717
R4633 A3#1pin@681_metal-2##0 A3#1pin@681_metal-2##1 6.717
R4634 A3#1pin@681_metal-2##1 A3#15pin@630_polysilicon-1 6.717
R4635 A3#13pin@629_polysilicon-1 A3#13pin@629_polysilicon-1##0 7.75
R4636 A3#13pin@629_polysilicon-1##0 A3#13pin@629_polysilicon-1##1 7.75
R4637 A3#13pin@629_polysilicon-1##1 A3#15pin@630_polysilicon-1 7.75
R4638 B3#15pin@639_polysilicon-1 B3#15pin@639_polysilicon-1##0 9.743
R4639 B3#15pin@639_polysilicon-1##0 B3#15pin@639_polysilicon-1##1 9.743
R4640 B3#15pin@639_polysilicon-1##1 B3#15pin@639_polysilicon-1##2 9.743
R4641 B3#15pin@639_polysilicon-1##2 B3#15pin@639_polysilicon-1##3 9.743
R4642 B3#15pin@639_polysilicon-1##3 B3#15pin@639_polysilicon-1##4 9.743
R4643 B3#15pin@639_polysilicon-1##4 B3#15pin@639_polysilicon-1##5 9.743
R4644 B3#15pin@639_polysilicon-1##5 B3#1pin@683_metal-2 9.743
R4645 net@2106#7pmos@101_poly-left net@2106#7pmos@101_poly-left##0 7.75
R4646 net@2106#7pmos@101_poly-left##0 net@2106 7.75
R4647 B3#16nmos@102_poly-left B3#16nmos@102_poly-left##0 6.2
R4648 B3#16nmos@102_poly-left##0 B3#14pin@622_polysilicon-1 6.2
R4649 net@2211#9nmos@103_poly-left net@2211#9nmos@103_poly-left##0 8.37
R4650 net@2211#9nmos@103_poly-left##0 net@2211#9nmos@103_poly-left##1 8.37
R4651 net@2211#9nmos@103_poly-left##1 net@2211#9nmos@103_poly-left##2 8.37
R4652 net@2211#9nmos@103_poly-left##2 net@2211#9nmos@103_poly-left##3 8.37
R4653 net@2211#9nmos@103_poly-left##3 net@2211#2contact@689_metal-1-metal-2 8.37
R4654 A3#3pin@642_polysilicon-1 A3#3pin@642_polysilicon-1##0 9.881
R4655 A3#3pin@642_polysilicon-1##0 A3#3pin@642_polysilicon-1##1 9.881
R4656 A3#3pin@642_polysilicon-1##1 A3#3pin@642_polysilicon-1##2 9.881
R4657 A3#3pin@642_polysilicon-1##2 A3#3pin@642_polysilicon-1##3 9.881
R4658 A3#3pin@642_polysilicon-1##3 A3#3pin@642_polysilicon-1##4 9.881
R4659 A3#3pin@642_polysilicon-1##4 A3#3pin@642_polysilicon-1##5 9.881
R4660 A3#3pin@642_polysilicon-1##5 A3#3pin@642_polysilicon-1##6 9.881
R4661 A3#3pin@642_polysilicon-1##6 A3#3pin@642_polysilicon-1##7 9.881
R4662 A3#3pin@642_polysilicon-1##7 A3#3pin@642_polysilicon-1##8 9.881
R4663 A3#3pin@642_polysilicon-1##8 A3#3pin@642_polysilicon-1##9 9.881
R4664 A3#3pin@642_polysilicon-1##9 A3#3pin@642_polysilicon-1##10 9.881
R4665 A3#3pin@642_polysilicon-1##10 A3#3pin@642_polysilicon-1##11 9.881
R4666 A3#3pin@642_polysilicon-1##11 A3#3pin@642_polysilicon-1##12 9.881
R4667 A3#3pin@642_polysilicon-1##12 A3#3pin@642_polysilicon-1##13 9.881
R4668 A3#3pin@642_polysilicon-1##13 A3#3pin@642_polysilicon-1##14 9.881
R4669 A3#3pin@642_polysilicon-1##14 A3#3pin@642_polysilicon-1##15 9.881
R4670 A3#3pin@642_polysilicon-1##15 A3#3pin@642_polysilicon-1##16 9.881
R4671 A3#3pin@642_polysilicon-1##16 A3#3pin@642_polysilicon-1##17 9.881
R4672 A3#3pin@642_polysilicon-1##17 A3#3pin@642_polysilicon-1##18 9.881
R4673 A3#3pin@642_polysilicon-1##18 A3#3pin@642_polysilicon-1##19 9.881
R4674 A3#3pin@642_polysilicon-1##19 A3#3pin@642_polysilicon-1##20 9.881
R4675 A3#3pin@642_polysilicon-1##20 A3#3pin@642_polysilicon-1##21 9.881
R4676 A3#3pin@642_polysilicon-1##21 A3#3pin@642_polysilicon-1##22 9.881
R4677 A3#3pin@642_polysilicon-1##22 A3#3pin@642_polysilicon-1##23 9.881
R4678 A3#3pin@642_polysilicon-1##23 A3#3pin@642_polysilicon-1##24 9.881
R4679 A3#3pin@642_polysilicon-1##24 A3#3pin@642_polysilicon-1##25 9.881
R4680 A3#3pin@642_polysilicon-1##25 A3#3pin@642_polysilicon-1##26 9.881
R4681 A3#3pin@642_polysilicon-1##26 A3#3pin@642_polysilicon-1##27 9.881
R4682 A3#3pin@642_polysilicon-1##27 A3#3pin@642_polysilicon-1##28 9.881
R4683 A3#3pin@642_polysilicon-1##28 A3#3pin@642_polysilicon-1##29 9.881
R4684 A3#3pin@642_polysilicon-1##29 A3#3pin@642_polysilicon-1##30 9.881
R4685 A3#3pin@642_polysilicon-1##30 A3#3pin@642_polysilicon-1##31 9.881
R4686 A3#3pin@642_polysilicon-1##31 A3#3pin@642_polysilicon-1##32 9.881
R4687 A3#3pin@642_polysilicon-1##32 A3#3pin@642_polysilicon-1##33 9.881
R4688 A3#3pin@642_polysilicon-1##33 A3#3pin@642_polysilicon-1##34 9.881
R4689 A3#3pin@642_polysilicon-1##34 A3#3pin@642_polysilicon-1##35 9.881
R4690 A3#3pin@642_polysilicon-1##35 A3#3pin@642_polysilicon-1##36 9.881
R4691 A3#3pin@642_polysilicon-1##36 A3#3pin@642_polysilicon-1##37 9.881
R4692 A3#3pin@642_polysilicon-1##37 A3#3pin@642_polysilicon-1##38 9.881
R4693 A3#3pin@642_polysilicon-1##38 A3#3pin@642_polysilicon-1##39 9.881
R4694 A3#3pin@642_polysilicon-1##39 A3#3pin@642_polysilicon-1##40 9.881
R4695 A3#3pin@642_polysilicon-1##40 A3#3pin@642_polysilicon-1##41 9.881
R4696 A3#3pin@642_polysilicon-1##41 A3#3pin@642_polysilicon-1##42 9.881
R4697 A3#3pin@642_polysilicon-1##42 A3#3pin@642_polysilicon-1##43 9.881
R4698 A3#3pin@642_polysilicon-1##43 A3#3pin@642_polysilicon-1##44 9.881
R4699 A3#3pin@642_polysilicon-1##44 A3#3pin@642_polysilicon-1##45 9.881
R4700 A3#3pin@642_polysilicon-1##45 A3#3pin@642_polysilicon-1##46 9.881
R4701 A3#3pin@642_polysilicon-1##46 A3#3pin@642_polysilicon-1##47 9.881
R4702 A3#3pin@642_polysilicon-1##47 A3#3pin@642_polysilicon-1##48 9.881
R4703 A3#3pin@642_polysilicon-1##48 A3#3pin@642_polysilicon-1##49 9.881
R4704 A3#3pin@642_polysilicon-1##49 A3#3pin@642_polysilicon-1##50 9.881
R4705 A3#3pin@642_polysilicon-1##50 A3#3pin@642_polysilicon-1##51 9.881
R4706 A3#3pin@642_polysilicon-1##51 A3#3pin@642_polysilicon-1##52 9.881
R4707 A3#3pin@642_polysilicon-1##52 A3#3pin@642_polysilicon-1##53 9.881
R4708 A3#3pin@642_polysilicon-1##53 A3#3pin@642_polysilicon-1##54 9.881
R4709 A3#3pin@642_polysilicon-1##54 A3#16nmos@105_poly-right 9.881
R4710 net@2106#5pmos@105_diff-top net@2106#2pin@631_metal-1 4.81
R4711 net@2106#1pin@641_polysilicon-1 net@2106#1pin@641_polysilicon-1##0 9.85
R4712 net@2106#1pin@641_polysilicon-1##0 net@2106#1pin@641_polysilicon-1##1 9.85
R4713 net@2106#1pin@641_polysilicon-1##1 net@2106#1pin@641_polysilicon-1##2 9.85
R4714 net@2106#1pin@641_polysilicon-1##2 net@2106#1pin@641_polysilicon-1##3 9.85
R4715 net@2106#1pin@641_polysilicon-1##3 net@2106#1pin@641_polysilicon-1##4 9.85
R4716 net@2106#1pin@641_polysilicon-1##4 net@2106#1pin@641_polysilicon-1##5 9.85
R4717 net@2106#1pin@641_polysilicon-1##5 net@2106#1pin@641_polysilicon-1##6 9.85
R4718 net@2106#1pin@641_polysilicon-1##6 net@2106#1pin@641_polysilicon-1##7 9.85
R4719 net@2106#1pin@641_polysilicon-1##7 net@2106#1pin@641_polysilicon-1##8 9.85
R4720 net@2106#1pin@641_polysilicon-1##8 net@2106#1pin@641_polysilicon-1##9 9.85
R4721 net@2106#1pin@641_polysilicon-1##9 net@2106#1pin@641_polysilicon-1##10 9.85
R4722 net@2106#1pin@641_polysilicon-1##10 net@2106#1pin@641_polysilicon-1##11 9.85
R4723 net@2106#1pin@641_polysilicon-1##11 net@2106#1pin@641_polysilicon-1##12 9.85
R4724 net@2106#1pin@641_polysilicon-1##12 net@2106#1pin@641_polysilicon-1##13 9.85
R4725 net@2106#1pin@641_polysilicon-1##13 net@2106#1pin@641_polysilicon-1##14 9.85
R4726 net@2106#1pin@641_polysilicon-1##14 net@2106#1pin@641_polysilicon-1##15 9.85
R4727 net@2106#1pin@641_polysilicon-1##15 net@2106#1pin@641_polysilicon-1##16 9.85
R4728 net@2106#1pin@641_polysilicon-1##16 net@2106#1pin@641_polysilicon-1##17 9.85
R4729 net@2106#1pin@641_polysilicon-1##17 net@2106#1pin@641_polysilicon-1##18 9.85
R4730 net@2106#1pin@641_polysilicon-1##18 net@2106#1pin@641_polysilicon-1##19 9.85
R4731 net@2106#1pin@641_polysilicon-1##19 net@2106#1pin@641_polysilicon-1##20 9.85
R4732 net@2106#1pin@641_polysilicon-1##20 net@2106#1pin@641_polysilicon-1##21 9.85
R4733 net@2106#1pin@641_polysilicon-1##21 net@2106#1pin@641_polysilicon-1##22 9.85
R4734 net@2106#1pin@641_polysilicon-1##22 net@2106#1pin@641_polysilicon-1##23 9.85
R4735 net@2106#1pin@641_polysilicon-1##23 net@2106#1pin@641_polysilicon-1##24 9.85
R4736 net@2106#1pin@641_polysilicon-1##24 net@2106#1pin@641_polysilicon-1##25 9.85
R4737 net@2106#1pin@641_polysilicon-1##25 net@2106#1pin@641_polysilicon-1##26 9.85
R4738 net@2106#1pin@641_polysilicon-1##26 net@2106#1pin@641_polysilicon-1##27 9.85
R4739 net@2106#1pin@641_polysilicon-1##27 net@2106#1pin@641_polysilicon-1##28 9.85
R4740 net@2106#1pin@641_polysilicon-1##28 net@2106#1pin@641_polysilicon-1##29 9.85
R4741 net@2106#1pin@641_polysilicon-1##29 net@2106#1pin@641_polysilicon-1##30 9.85
R4742 net@2106#1pin@641_polysilicon-1##30 net@2106#1pin@641_polysilicon-1##31 9.85
R4743 net@2106#1pin@641_polysilicon-1##31 net@2106#1pin@641_polysilicon-1##32 9.85
R4744 net@2106#1pin@641_polysilicon-1##32 net@2106#1pin@641_polysilicon-1##33 9.85
R4745 net@2106#1pin@641_polysilicon-1##33 net@2106#1pin@641_polysilicon-1##34 9.85
R4746 net@2106#1pin@641_polysilicon-1##34 net@2106#1pin@641_polysilicon-1##35 9.85
R4747 net@2106#1pin@641_polysilicon-1##35 net@2106#1pin@641_polysilicon-1##36 9.85
R4748 net@2106#1pin@641_polysilicon-1##36 net@2106#1pin@641_polysilicon-1##37 9.85
R4749 net@2106#1pin@641_polysilicon-1##37 net@2106#1pin@641_polysilicon-1##38 9.85
R4750 net@2106#1pin@641_polysilicon-1##38 net@2106#1pin@641_polysilicon-1##39 9.85
R4751 net@2106#1pin@641_polysilicon-1##39 net@2106#1pin@641_polysilicon-1##40 9.85
R4752 net@2106#1pin@641_polysilicon-1##40 net@2106#1pin@641_polysilicon-1##41 9.85
R4753 net@2106#1pin@641_polysilicon-1##41 net@2106#1pin@641_polysilicon-1##42 9.85
R4754 net@2106#1pin@641_polysilicon-1##42 net@2106#1pin@641_polysilicon-1##43 9.85
R4755 net@2106#1pin@641_polysilicon-1##43 net@2106#1pin@641_polysilicon-1##44 9.85
R4756 net@2106#1pin@641_polysilicon-1##44 net@2106#1pin@641_polysilicon-1##45 9.85
R4757 net@2106#1pin@641_polysilicon-1##45 net@2106#1pin@641_polysilicon-1##46 9.85
R4758 net@2106#1pin@641_polysilicon-1##46 net@2106#1pin@641_polysilicon-1##47 9.85
R4759 net@2106#1pin@641_polysilicon-1##47 net@2106#1pin@641_polysilicon-1##48 9.85
R4760 net@2106#1pin@641_polysilicon-1##48 net@2106#1pin@641_polysilicon-1##49 9.85
R4761 net@2106#1pin@641_polysilicon-1##49 net@2106#1pin@641_polysilicon-1##50 9.85
R4762 net@2106#1pin@641_polysilicon-1##50 net@2106#1pin@641_polysilicon-1##51 9.85
R4763 net@2106#1pin@641_polysilicon-1##51 net@2106#1pin@641_polysilicon-1##52 9.85
R4764 net@2106#1pin@641_polysilicon-1##52 net@2106#1pin@641_polysilicon-1##53 9.85
R4765 net@2106#1pin@641_polysilicon-1##53 net@2106#1pin@641_polysilicon-1##54 9.85
R4766 net@2106#1pin@641_polysilicon-1##54 net@2106#1pin@641_polysilicon-1##55 9.85
R4767 net@2106#1pin@641_polysilicon-1##55 net@2106#1pin@641_polysilicon-1##56 9.85
R4768 net@2106#1pin@641_polysilicon-1##56 net@2106#1pin@641_polysilicon-1##57 9.85
R4769 net@2106#1pin@641_polysilicon-1##57 net@2106#1pin@641_polysilicon-1##58 9.85
R4770 net@2106#1pin@641_polysilicon-1##58 net@2106#1pin@641_polysilicon-1##59 9.85
R4771 net@2106#1pin@641_polysilicon-1##59 net@2106#1pin@641_polysilicon-1##60 9.85
R4772 net@2106#1pin@641_polysilicon-1##60 net@2106#2pin@631_metal-1 9.85
R4773 B3#17pmos@104_poly-right B3#17pmos@104_poly-right##0 9.854
R4774 B3#17pmos@104_poly-right##0 B3#17pmos@104_poly-right##1 9.854
R4775 B3#17pmos@104_poly-right##1 B3#17pmos@104_poly-right##2 9.854
R4776 B3#17pmos@104_poly-right##2 B3#17pmos@104_poly-right##3 9.854
R4777 B3#17pmos@104_poly-right##3 B3#17pmos@104_poly-right##4 9.854
R4778 B3#17pmos@104_poly-right##4 B3#17pmos@104_poly-right##5 9.854
R4779 B3#17pmos@104_poly-right##5 B3#17pmos@104_poly-right##6 9.854
R4780 B3#17pmos@104_poly-right##6 B3#17pmos@104_poly-right##7 9.854
R4781 B3#17pmos@104_poly-right##7 B3#17pmos@104_poly-right##8 9.854
R4782 B3#17pmos@104_poly-right##8 B3#17pmos@104_poly-right##9 9.854
R4783 B3#17pmos@104_poly-right##9 B3#17pmos@104_poly-right##10 9.854
R4784 B3#17pmos@104_poly-right##10 B3#17pmos@104_poly-right##11 9.854
R4785 B3#17pmos@104_poly-right##11 B3#17pmos@104_poly-right##12 9.854
R4786 B3#17pmos@104_poly-right##12 B3#17pmos@104_poly-right##13 9.854
R4787 B3#17pmos@104_poly-right##13 B3#17pmos@104_poly-right##14 9.854
R4788 B3#17pmos@104_poly-right##14 B3#17pmos@104_poly-right##15 9.854
R4789 B3#17pmos@104_poly-right##15 B3#17pmos@104_poly-right##16 9.854
R4790 B3#17pmos@104_poly-right##16 B3#17pmos@104_poly-right##17 9.854
R4791 B3#17pmos@104_poly-right##17 B3#17pmos@104_poly-right##18 9.854
R4792 B3#17pmos@104_poly-right##18 B3#17pmos@104_poly-right##19 9.854
R4793 B3#17pmos@104_poly-right##19 B3#17pmos@104_poly-right##20 9.854
R4794 B3#17pmos@104_poly-right##20 B3#17pmos@104_poly-right##21 9.854
R4795 B3#17pmos@104_poly-right##21 B3#17pmos@104_poly-right##22 9.854
R4796 B3#17pmos@104_poly-right##22 B3#17pmos@104_poly-right##23 9.854
R4797 B3#17pmos@104_poly-right##23 B3#17pmos@104_poly-right##24 9.854
R4798 B3#17pmos@104_poly-right##24 B3#17pmos@104_poly-right##25 9.854
R4799 B3#17pmos@104_poly-right##25 B3#17pmos@104_poly-right##26 9.854
R4800 B3#17pmos@104_poly-right##26 B3#17pmos@104_poly-right##27 9.854
R4801 B3#17pmos@104_poly-right##27 B3#17pmos@104_poly-right##28 9.854
R4802 B3#17pmos@104_poly-right##28 B3#17pmos@104_poly-right##29 9.854
R4803 B3#17pmos@104_poly-right##29 B3#17pmos@104_poly-right##30 9.854
R4804 B3#17pmos@104_poly-right##30 B3#17pmos@104_poly-right##31 9.854
R4805 B3#17pmos@104_poly-right##31 B3#17pmos@104_poly-right##32 9.854
R4806 B3#17pmos@104_poly-right##32 B3#17pmos@104_poly-right##33 9.854
R4807 B3#17pmos@104_poly-right##33 B3#17pmos@104_poly-right##34 9.854
R4808 B3#17pmos@104_poly-right##34 B3#17pmos@104_poly-right##35 9.854
R4809 B3#17pmos@104_poly-right##35 B3#17pmos@104_poly-right##36 9.854
R4810 B3#17pmos@104_poly-right##36 B3#17pmos@104_poly-right##37 9.854
R4811 B3#17pmos@104_poly-right##37 B3#17pmos@104_poly-right##38 9.854
R4812 B3#17pmos@104_poly-right##38 B3#17pmos@104_poly-right##39 9.854
R4813 B3#17pmos@104_poly-right##39 B3#17pmos@104_poly-right##40 9.854
R4814 B3#17pmos@104_poly-right##40 B3#17pmos@104_poly-right##41 9.854
R4815 B3#17pmos@104_poly-right##41 B3#17pmos@104_poly-right##42 9.854
R4816 B3#17pmos@104_poly-right##42 B3#17pmos@104_poly-right##43 9.854
R4817 B3#17pmos@104_poly-right##43 B3#17pmos@104_poly-right##44 9.854
R4818 B3#17pmos@104_poly-right##44 B3#17pmos@104_poly-right##45 9.854
R4819 B3#17pmos@104_poly-right##45 B3#17pmos@104_poly-right##46 9.854
R4820 B3#17pmos@104_poly-right##46 B3#17pmos@104_poly-right##47 9.854
R4821 B3#17pmos@104_poly-right##47 B3#17pmos@104_poly-right##48 9.854
R4822 B3#17pmos@104_poly-right##48 B3#17pmos@104_poly-right##49 9.854
R4823 B3#17pmos@104_poly-right##49 B3#17pmos@104_poly-right##50 9.854
R4824 B3#17pmos@104_poly-right##50 B3#17pmos@104_poly-right##51 9.854
R4825 B3#17pmos@104_poly-right##51 B3#17pmos@104_poly-right##52 9.854
R4826 B3#17pmos@104_poly-right##52 B3#17pmos@104_poly-right##53 9.854
R4827 B3#17pmos@104_poly-right##53 B3#17pmos@104_poly-right##54 9.854
R4828 B3#17pmos@104_poly-right##54 B3#12pin@632_polysilicon-1 9.854
R4829 net@2211 net@2211#2contact@689_metal-1-metal-2 4.797
R4830 A3#17nmos@100_poly-right A3#17nmos@100_poly-right##0 9.871
R4831 A3#17nmos@100_poly-right##0 A3#17nmos@100_poly-right##1 9.871
R4832 A3#17nmos@100_poly-right##1 A3#17nmos@100_poly-right##2 9.871
R4833 A3#17nmos@100_poly-right##2 A3#17nmos@100_poly-right##3 9.871
R4834 A3#17nmos@100_poly-right##3 A3#17nmos@100_poly-right##4 9.871
R4835 A3#17nmos@100_poly-right##4 A3#17nmos@100_poly-right##5 9.871
R4836 A3#17nmos@100_poly-right##5 A3#17nmos@100_poly-right##6 9.871
R4837 A3#17nmos@100_poly-right##6 A3#17nmos@100_poly-right##7 9.871
R4838 A3#17nmos@100_poly-right##7 A3#17nmos@100_poly-right##8 9.871
R4839 A3#17nmos@100_poly-right##8 A3#17nmos@100_poly-right##9 9.871
R4840 A3#17nmos@100_poly-right##9 A3#17nmos@100_poly-right##10 9.871
R4841 A3#17nmos@100_poly-right##10 A3#17nmos@100_poly-right##11 9.871
R4842 A3#17nmos@100_poly-right##11 A3#17nmos@100_poly-right##12 9.871
R4843 A3#17nmos@100_poly-right##12 A3#17nmos@100_poly-right##13 9.871
R4844 A3#17nmos@100_poly-right##13 A3#17nmos@100_poly-right##14 9.871
R4845 A3#17nmos@100_poly-right##14 A3#17nmos@100_poly-right##15 9.871
R4846 A3#17nmos@100_poly-right##15 A3#17nmos@100_poly-right##16 9.871
R4847 A3#17nmos@100_poly-right##16 A3#17nmos@100_poly-right##17 9.871
R4848 A3#17nmos@100_poly-right##17 A3#17nmos@100_poly-right##18 9.871
R4849 A3#17nmos@100_poly-right##18 A3#17nmos@100_poly-right##19 9.871
R4850 A3#17nmos@100_poly-right##19 A3#17nmos@100_poly-right##20 9.871
R4851 A3#17nmos@100_poly-right##20 A3#17nmos@100_poly-right##21 9.871
R4852 A3#17nmos@100_poly-right##21 A3#17nmos@100_poly-right##22 9.871
R4853 A3#17nmos@100_poly-right##22 A3#17nmos@100_poly-right##23 9.871
R4854 A3#17nmos@100_poly-right##23 A3#17nmos@100_poly-right##24 9.871
R4855 A3#17nmos@100_poly-right##24 A3#17nmos@100_poly-right##25 9.871
R4856 A3#17nmos@100_poly-right##25 A3#17nmos@100_poly-right##26 9.871
R4857 A3#17nmos@100_poly-right##26 A3#17nmos@100_poly-right##27 9.871
R4858 A3#17nmos@100_poly-right##27 A3#17nmos@100_poly-right##28 9.871
R4859 A3#17nmos@100_poly-right##28 A3#17nmos@100_poly-right##29 9.871
R4860 A3#17nmos@100_poly-right##29 A3#17nmos@100_poly-right##30 9.871
R4861 A3#17nmos@100_poly-right##30 A3#17nmos@100_poly-right##31 9.871
R4862 A3#17nmos@100_poly-right##31 A3#17nmos@100_poly-right##32 9.871
R4863 A3#17nmos@100_poly-right##32 A3#17nmos@100_poly-right##33 9.871
R4864 A3#17nmos@100_poly-right##33 A3#17nmos@100_poly-right##34 9.871
R4865 A3#17nmos@100_poly-right##34 A3#17nmos@100_poly-right##35 9.871
R4866 A3#17nmos@100_poly-right##35 A3#17nmos@100_poly-right##36 9.871
R4867 A3#17nmos@100_poly-right##36 A3#17nmos@100_poly-right##37 9.871
R4868 A3#17nmos@100_poly-right##37 A3#17nmos@100_poly-right##38 9.871
R4869 A3#17nmos@100_poly-right##38 A3#17nmos@100_poly-right##39 9.871
R4870 A3#17nmos@100_poly-right##39 A3#17nmos@100_poly-right##40 9.871
R4871 A3#17nmos@100_poly-right##40 A3#17nmos@100_poly-right##41 9.871
R4872 A3#17nmos@100_poly-right##41 A3#17nmos@100_poly-right##42 9.871
R4873 A3#17nmos@100_poly-right##42 A3#17nmos@100_poly-right##43 9.871
R4874 A3#17nmos@100_poly-right##43 A3#17nmos@100_poly-right##44 9.871
R4875 A3#17nmos@100_poly-right##44 A3#17nmos@100_poly-right##45 9.871
R4876 A3#17nmos@100_poly-right##45 A3#17nmos@100_poly-right##46 9.871
R4877 A3#17nmos@100_poly-right##46 A3#17nmos@100_poly-right##47 9.871
R4878 A3#17nmos@100_poly-right##47 A3#17nmos@100_poly-right##48 9.871
R4879 A3#17nmos@100_poly-right##48 A3#17nmos@100_poly-right##49 9.871
R4880 A3#17nmos@100_poly-right##49 A3#17nmos@100_poly-right##50 9.871
R4881 A3#17nmos@100_poly-right##50 A3#17nmos@100_poly-right##51 9.871
R4882 A3#17nmos@100_poly-right##51 A3#17nmos@100_poly-right##52 9.871
R4883 A3#17nmos@100_poly-right##52 A3#17nmos@100_poly-right##53 9.871
R4884 A3#17nmos@100_poly-right##53 A3#17nmos@100_poly-right##54 9.871
R4885 A3#17nmos@100_poly-right##54 A3#17nmos@100_poly-right##55 9.871
R4886 A3#17nmos@100_poly-right##55 A3#12pmos@100_poly-left 9.871
R4887 net@2106#7pmos@101_poly-left net@2106#7pmos@101_poly-left##0 9.871
R4888 net@2106#7pmos@101_poly-left##0 net@2106#7pmos@101_poly-left##1 9.871
R4889 net@2106#7pmos@101_poly-left##1 net@2106#7pmos@101_poly-left##2 9.871
R4890 net@2106#7pmos@101_poly-left##2 net@2106#7pmos@101_poly-left##3 9.871
R4891 net@2106#7pmos@101_poly-left##3 net@2106#7pmos@101_poly-left##4 9.871
R4892 net@2106#7pmos@101_poly-left##4 net@2106#7pmos@101_poly-left##5 9.871
R4893 net@2106#7pmos@101_poly-left##5 net@2106#7pmos@101_poly-left##6 9.871
R4894 net@2106#7pmos@101_poly-left##6 net@2106#7pmos@101_poly-left##7 9.871
R4895 net@2106#7pmos@101_poly-left##7 net@2106#7pmos@101_poly-left##8 9.871
R4896 net@2106#7pmos@101_poly-left##8 net@2106#7pmos@101_poly-left##9 9.871
R4897 net@2106#7pmos@101_poly-left##9 net@2106#7pmos@101_poly-left##10 9.871
R4898 net@2106#7pmos@101_poly-left##10 net@2106#7pmos@101_poly-left##11 9.871
R4899 net@2106#7pmos@101_poly-left##11 net@2106#7pmos@101_poly-left##12 9.871
R4900 net@2106#7pmos@101_poly-left##12 net@2106#7pmos@101_poly-left##13 9.871
R4901 net@2106#7pmos@101_poly-left##13 net@2106#7pmos@101_poly-left##14 9.871
R4902 net@2106#7pmos@101_poly-left##14 net@2106#7pmos@101_poly-left##15 9.871
R4903 net@2106#7pmos@101_poly-left##15 net@2106#7pmos@101_poly-left##16 9.871
R4904 net@2106#7pmos@101_poly-left##16 net@2106#7pmos@101_poly-left##17 9.871
R4905 net@2106#7pmos@101_poly-left##17 net@2106#7pmos@101_poly-left##18 9.871
R4906 net@2106#7pmos@101_poly-left##18 net@2106#7pmos@101_poly-left##19 9.871
R4907 net@2106#7pmos@101_poly-left##19 net@2106#7pmos@101_poly-left##20 9.871
R4908 net@2106#7pmos@101_poly-left##20 net@2106#7pmos@101_poly-left##21 9.871
R4909 net@2106#7pmos@101_poly-left##21 net@2106#7pmos@101_poly-left##22 9.871
R4910 net@2106#7pmos@101_poly-left##22 net@2106#7pmos@101_poly-left##23 9.871
R4911 net@2106#7pmos@101_poly-left##23 net@2106#7pmos@101_poly-left##24 9.871
R4912 net@2106#7pmos@101_poly-left##24 net@2106#7pmos@101_poly-left##25 9.871
R4913 net@2106#7pmos@101_poly-left##25 net@2106#7pmos@101_poly-left##26 9.871
R4914 net@2106#7pmos@101_poly-left##26 net@2106#7pmos@101_poly-left##27 9.871
R4915 net@2106#7pmos@101_poly-left##27 net@2106#7pmos@101_poly-left##28 9.871
R4916 net@2106#7pmos@101_poly-left##28 net@2106#7pmos@101_poly-left##29 9.871
R4917 net@2106#7pmos@101_poly-left##29 net@2106#7pmos@101_poly-left##30 9.871
R4918 net@2106#7pmos@101_poly-left##30 net@2106#7pmos@101_poly-left##31 9.871
R4919 net@2106#7pmos@101_poly-left##31 net@2106#7pmos@101_poly-left##32 9.871
R4920 net@2106#7pmos@101_poly-left##32 net@2106#7pmos@101_poly-left##33 9.871
R4921 net@2106#7pmos@101_poly-left##33 net@2106#7pmos@101_poly-left##34 9.871
R4922 net@2106#7pmos@101_poly-left##34 net@2106#7pmos@101_poly-left##35 9.871
R4923 net@2106#7pmos@101_poly-left##35 net@2106#7pmos@101_poly-left##36 9.871
R4924 net@2106#7pmos@101_poly-left##36 net@2106#7pmos@101_poly-left##37 9.871
R4925 net@2106#7pmos@101_poly-left##37 net@2106#7pmos@101_poly-left##38 9.871
R4926 net@2106#7pmos@101_poly-left##38 net@2106#7pmos@101_poly-left##39 9.871
R4927 net@2106#7pmos@101_poly-left##39 net@2106#7pmos@101_poly-left##40 9.871
R4928 net@2106#7pmos@101_poly-left##40 net@2106#7pmos@101_poly-left##41 9.871
R4929 net@2106#7pmos@101_poly-left##41 net@2106#7pmos@101_poly-left##42 9.871
R4930 net@2106#7pmos@101_poly-left##42 net@2106#7pmos@101_poly-left##43 9.871
R4931 net@2106#7pmos@101_poly-left##43 net@2106#7pmos@101_poly-left##44 9.871
R4932 net@2106#7pmos@101_poly-left##44 net@2106#7pmos@101_poly-left##45 9.871
R4933 net@2106#7pmos@101_poly-left##45 net@2106#7pmos@101_poly-left##46 9.871
R4934 net@2106#7pmos@101_poly-left##46 net@2106#7pmos@101_poly-left##47 9.871
R4935 net@2106#7pmos@101_poly-left##47 net@2106#7pmos@101_poly-left##48 9.871
R4936 net@2106#7pmos@101_poly-left##48 net@2106#7pmos@101_poly-left##49 9.871
R4937 net@2106#7pmos@101_poly-left##49 net@2106#7pmos@101_poly-left##50 9.871
R4938 net@2106#7pmos@101_poly-left##50 net@2106#7pmos@101_poly-left##51 9.871
R4939 net@2106#7pmos@101_poly-left##51 net@2106#7pmos@101_poly-left##52 9.871
R4940 net@2106#7pmos@101_poly-left##52 net@2106#7pmos@101_poly-left##53 9.871
R4941 net@2106#7pmos@101_poly-left##53 net@2106#7pmos@101_poly-left##54 9.871
R4942 net@2106#7pmos@101_poly-left##54 net@2106#7pmos@101_poly-left##55 9.871
R4943 net@2106#7pmos@101_poly-left##55 net@2106#11nmos@101_poly-right 9.871
R4944 B3#18pmos@102_poly-right B3#18pmos@102_poly-right##0 9.871
R4945 B3#18pmos@102_poly-right##0 B3#18pmos@102_poly-right##1 9.871
R4946 B3#18pmos@102_poly-right##1 B3#18pmos@102_poly-right##2 9.871
R4947 B3#18pmos@102_poly-right##2 B3#18pmos@102_poly-right##3 9.871
R4948 B3#18pmos@102_poly-right##3 B3#18pmos@102_poly-right##4 9.871
R4949 B3#18pmos@102_poly-right##4 B3#18pmos@102_poly-right##5 9.871
R4950 B3#18pmos@102_poly-right##5 B3#18pmos@102_poly-right##6 9.871
R4951 B3#18pmos@102_poly-right##6 B3#18pmos@102_poly-right##7 9.871
R4952 B3#18pmos@102_poly-right##7 B3#18pmos@102_poly-right##8 9.871
R4953 B3#18pmos@102_poly-right##8 B3#18pmos@102_poly-right##9 9.871
R4954 B3#18pmos@102_poly-right##9 B3#18pmos@102_poly-right##10 9.871
R4955 B3#18pmos@102_poly-right##10 B3#18pmos@102_poly-right##11 9.871
R4956 B3#18pmos@102_poly-right##11 B3#18pmos@102_poly-right##12 9.871
R4957 B3#18pmos@102_poly-right##12 B3#18pmos@102_poly-right##13 9.871
R4958 B3#18pmos@102_poly-right##13 B3#18pmos@102_poly-right##14 9.871
R4959 B3#18pmos@102_poly-right##14 B3#18pmos@102_poly-right##15 9.871
R4960 B3#18pmos@102_poly-right##15 B3#18pmos@102_poly-right##16 9.871
R4961 B3#18pmos@102_poly-right##16 B3#18pmos@102_poly-right##17 9.871
R4962 B3#18pmos@102_poly-right##17 B3#18pmos@102_poly-right##18 9.871
R4963 B3#18pmos@102_poly-right##18 B3#18pmos@102_poly-right##19 9.871
R4964 B3#18pmos@102_poly-right##19 B3#18pmos@102_poly-right##20 9.871
R4965 B3#18pmos@102_poly-right##20 B3#18pmos@102_poly-right##21 9.871
R4966 B3#18pmos@102_poly-right##21 B3#18pmos@102_poly-right##22 9.871
R4967 B3#18pmos@102_poly-right##22 B3#18pmos@102_poly-right##23 9.871
R4968 B3#18pmos@102_poly-right##23 B3#18pmos@102_poly-right##24 9.871
R4969 B3#18pmos@102_poly-right##24 B3#18pmos@102_poly-right##25 9.871
R4970 B3#18pmos@102_poly-right##25 B3#18pmos@102_poly-right##26 9.871
R4971 B3#18pmos@102_poly-right##26 B3#18pmos@102_poly-right##27 9.871
R4972 B3#18pmos@102_poly-right##27 B3#18pmos@102_poly-right##28 9.871
R4973 B3#18pmos@102_poly-right##28 B3#18pmos@102_poly-right##29 9.871
R4974 B3#18pmos@102_poly-right##29 B3#18pmos@102_poly-right##30 9.871
R4975 B3#18pmos@102_poly-right##30 B3#18pmos@102_poly-right##31 9.871
R4976 B3#18pmos@102_poly-right##31 B3#18pmos@102_poly-right##32 9.871
R4977 B3#18pmos@102_poly-right##32 B3#18pmos@102_poly-right##33 9.871
R4978 B3#18pmos@102_poly-right##33 B3#18pmos@102_poly-right##34 9.871
R4979 B3#18pmos@102_poly-right##34 B3#18pmos@102_poly-right##35 9.871
R4980 B3#18pmos@102_poly-right##35 B3#18pmos@102_poly-right##36 9.871
R4981 B3#18pmos@102_poly-right##36 B3#18pmos@102_poly-right##37 9.871
R4982 B3#18pmos@102_poly-right##37 B3#18pmos@102_poly-right##38 9.871
R4983 B3#18pmos@102_poly-right##38 B3#18pmos@102_poly-right##39 9.871
R4984 B3#18pmos@102_poly-right##39 B3#18pmos@102_poly-right##40 9.871
R4985 B3#18pmos@102_poly-right##40 B3#18pmos@102_poly-right##41 9.871
R4986 B3#18pmos@102_poly-right##41 B3#18pmos@102_poly-right##42 9.871
R4987 B3#18pmos@102_poly-right##42 B3#18pmos@102_poly-right##43 9.871
R4988 B3#18pmos@102_poly-right##43 B3#18pmos@102_poly-right##44 9.871
R4989 B3#18pmos@102_poly-right##44 B3#18pmos@102_poly-right##45 9.871
R4990 B3#18pmos@102_poly-right##45 B3#18pmos@102_poly-right##46 9.871
R4991 B3#18pmos@102_poly-right##46 B3#18pmos@102_poly-right##47 9.871
R4992 B3#18pmos@102_poly-right##47 B3#18pmos@102_poly-right##48 9.871
R4993 B3#18pmos@102_poly-right##48 B3#18pmos@102_poly-right##49 9.871
R4994 B3#18pmos@102_poly-right##49 B3#18pmos@102_poly-right##50 9.871
R4995 B3#18pmos@102_poly-right##50 B3#18pmos@102_poly-right##51 9.871
R4996 B3#18pmos@102_poly-right##51 B3#18pmos@102_poly-right##52 9.871
R4997 B3#18pmos@102_poly-right##52 B3#18pmos@102_poly-right##53 9.871
R4998 B3#18pmos@102_poly-right##53 B3#18pmos@102_poly-right##54 9.871
R4999 B3#18pmos@102_poly-right##54 B3#18pmos@102_poly-right##55 9.871
R5000 B3#18pmos@102_poly-right##55 B3#16nmos@102_poly-left 9.871
R5001 net@2211#14pmos@103_poly-right net@2211#14pmos@103_poly-right##0 9.871
R5002 net@2211#14pmos@103_poly-right##0 net@2211#14pmos@103_poly-right##1 9.871
R5003 net@2211#14pmos@103_poly-right##1 net@2211#14pmos@103_poly-right##2 9.871
R5004 net@2211#14pmos@103_poly-right##2 net@2211#14pmos@103_poly-right##3 9.871
R5005 net@2211#14pmos@103_poly-right##3 net@2211#14pmos@103_poly-right##4 9.871
R5006 net@2211#14pmos@103_poly-right##4 net@2211#14pmos@103_poly-right##5 9.871
R5007 net@2211#14pmos@103_poly-right##5 net@2211#14pmos@103_poly-right##6 9.871
R5008 net@2211#14pmos@103_poly-right##6 net@2211#14pmos@103_poly-right##7 9.871
R5009 net@2211#14pmos@103_poly-right##7 net@2211#14pmos@103_poly-right##8 9.871
R5010 net@2211#14pmos@103_poly-right##8 net@2211#14pmos@103_poly-right##9 9.871
R5011 net@2211#14pmos@103_poly-right##9 net@2211#14pmos@103_poly-right##10 9.871
R5012 net@2211#14pmos@103_poly-right##10 net@2211#14pmos@103_poly-right##11 9.871
R5013 net@2211#14pmos@103_poly-right##11 net@2211#14pmos@103_poly-right##12 9.871
R5014 net@2211#14pmos@103_poly-right##12 net@2211#14pmos@103_poly-right##13 9.871
R5015 net@2211#14pmos@103_poly-right##13 net@2211#14pmos@103_poly-right##14 9.871
R5016 net@2211#14pmos@103_poly-right##14 net@2211#14pmos@103_poly-right##15 9.871
R5017 net@2211#14pmos@103_poly-right##15 net@2211#14pmos@103_poly-right##16 9.871
R5018 net@2211#14pmos@103_poly-right##16 net@2211#14pmos@103_poly-right##17 9.871
R5019 net@2211#14pmos@103_poly-right##17 net@2211#14pmos@103_poly-right##18 9.871
R5020 net@2211#14pmos@103_poly-right##18 net@2211#14pmos@103_poly-right##19 9.871
R5021 net@2211#14pmos@103_poly-right##19 net@2211#14pmos@103_poly-right##20 9.871
R5022 net@2211#14pmos@103_poly-right##20 net@2211#14pmos@103_poly-right##21 9.871
R5023 net@2211#14pmos@103_poly-right##21 net@2211#14pmos@103_poly-right##22 9.871
R5024 net@2211#14pmos@103_poly-right##22 net@2211#14pmos@103_poly-right##23 9.871
R5025 net@2211#14pmos@103_poly-right##23 net@2211#14pmos@103_poly-right##24 9.871
R5026 net@2211#14pmos@103_poly-right##24 net@2211#14pmos@103_poly-right##25 9.871
R5027 net@2211#14pmos@103_poly-right##25 net@2211#14pmos@103_poly-right##26 9.871
R5028 net@2211#14pmos@103_poly-right##26 net@2211#14pmos@103_poly-right##27 9.871
R5029 net@2211#14pmos@103_poly-right##27 net@2211#14pmos@103_poly-right##28 9.871
R5030 net@2211#14pmos@103_poly-right##28 net@2211#14pmos@103_poly-right##29 9.871
R5031 net@2211#14pmos@103_poly-right##29 net@2211#14pmos@103_poly-right##30 9.871
R5032 net@2211#14pmos@103_poly-right##30 net@2211#14pmos@103_poly-right##31 9.871
R5033 net@2211#14pmos@103_poly-right##31 net@2211#14pmos@103_poly-right##32 9.871
R5034 net@2211#14pmos@103_poly-right##32 net@2211#14pmos@103_poly-right##33 9.871
R5035 net@2211#14pmos@103_poly-right##33 net@2211#14pmos@103_poly-right##34 9.871
R5036 net@2211#14pmos@103_poly-right##34 net@2211#14pmos@103_poly-right##35 9.871
R5037 net@2211#14pmos@103_poly-right##35 net@2211#14pmos@103_poly-right##36 9.871
R5038 net@2211#14pmos@103_poly-right##36 net@2211#14pmos@103_poly-right##37 9.871
R5039 net@2211#14pmos@103_poly-right##37 net@2211#14pmos@103_poly-right##38 9.871
R5040 net@2211#14pmos@103_poly-right##38 net@2211#14pmos@103_poly-right##39 9.871
R5041 net@2211#14pmos@103_poly-right##39 net@2211#14pmos@103_poly-right##40 9.871
R5042 net@2211#14pmos@103_poly-right##40 net@2211#14pmos@103_poly-right##41 9.871
R5043 net@2211#14pmos@103_poly-right##41 net@2211#14pmos@103_poly-right##42 9.871
R5044 net@2211#14pmos@103_poly-right##42 net@2211#14pmos@103_poly-right##43 9.871
R5045 net@2211#14pmos@103_poly-right##43 net@2211#14pmos@103_poly-right##44 9.871
R5046 net@2211#14pmos@103_poly-right##44 net@2211#14pmos@103_poly-right##45 9.871
R5047 net@2211#14pmos@103_poly-right##45 net@2211#14pmos@103_poly-right##46 9.871
R5048 net@2211#14pmos@103_poly-right##46 net@2211#14pmos@103_poly-right##47 9.871
R5049 net@2211#14pmos@103_poly-right##47 net@2211#14pmos@103_poly-right##48 9.871
R5050 net@2211#14pmos@103_poly-right##48 net@2211#14pmos@103_poly-right##49 9.871
R5051 net@2211#14pmos@103_poly-right##49 net@2211#14pmos@103_poly-right##50 9.871
R5052 net@2211#14pmos@103_poly-right##50 net@2211#14pmos@103_poly-right##51 9.871
R5053 net@2211#14pmos@103_poly-right##51 net@2211#14pmos@103_poly-right##52 9.871
R5054 net@2211#14pmos@103_poly-right##52 net@2211#14pmos@103_poly-right##53 9.871
R5055 net@2211#14pmos@103_poly-right##53 net@2211#14pmos@103_poly-right##54 9.871
R5056 net@2211#14pmos@103_poly-right##54 net@2211#14pmos@103_poly-right##55 9.871
R5057 net@2211#14pmos@103_poly-right##55 net@2211#9nmos@103_poly-left 9.871
R5058 net@2204#2contact@713_metal-1-polysilicon-1 net@2204 4.706
R5059 net@2204#12pmos@106_poly-right net@2204#12pmos@106_poly-right##0 9.864
R5060 net@2204#12pmos@106_poly-right##0 net@2204#12pmos@106_poly-right##1 9.864
R5061 net@2204#12pmos@106_poly-right##1 net@2204#12pmos@106_poly-right##2 9.864
R5062 net@2204#12pmos@106_poly-right##2 net@2204#12pmos@106_poly-right##3 9.864
R5063 net@2204#12pmos@106_poly-right##3 net@2204#12pmos@106_poly-right##4 9.864
R5064 net@2204#12pmos@106_poly-right##4 net@2204#12pmos@106_poly-right##5 9.864
R5065 net@2204#12pmos@106_poly-right##5 net@2204#12pmos@106_poly-right##6 9.864
R5066 net@2204#12pmos@106_poly-right##6 net@2204#12pmos@106_poly-right##7 9.864
R5067 net@2204#12pmos@106_poly-right##7 net@2204#12pmos@106_poly-right##8 9.864
R5068 net@2204#12pmos@106_poly-right##8 net@2204#12pmos@106_poly-right##9 9.864
R5069 net@2204#12pmos@106_poly-right##9 net@2204#12pmos@106_poly-right##10 9.864
R5070 net@2204#12pmos@106_poly-right##10 net@2204#12pmos@106_poly-right##11 9.864
R5071 net@2204#12pmos@106_poly-right##11 net@2204#12pmos@106_poly-right##12 9.864
R5072 net@2204#12pmos@106_poly-right##12 net@2204#12pmos@106_poly-right##13 9.864
R5073 net@2204#12pmos@106_poly-right##13 net@2204#12pmos@106_poly-right##14 9.864
R5074 net@2204#12pmos@106_poly-right##14 net@2204#12pmos@106_poly-right##15 9.864
R5075 net@2204#12pmos@106_poly-right##15 net@2204#12pmos@106_poly-right##16 9.864
R5076 net@2204#12pmos@106_poly-right##16 net@2204#12pmos@106_poly-right##17 9.864
R5077 net@2204#12pmos@106_poly-right##17 net@2204#12pmos@106_poly-right##18 9.864
R5078 net@2204#12pmos@106_poly-right##18 net@2204#12pmos@106_poly-right##19 9.864
R5079 net@2204#12pmos@106_poly-right##19 net@2204#12pmos@106_poly-right##20 9.864
R5080 net@2204#12pmos@106_poly-right##20 net@2204#12pmos@106_poly-right##21 9.864
R5081 net@2204#12pmos@106_poly-right##21 net@2204#12pmos@106_poly-right##22 9.864
R5082 net@2204#12pmos@106_poly-right##22 net@2204#12pmos@106_poly-right##23 9.864
R5083 net@2204#12pmos@106_poly-right##23 net@2204#12pmos@106_poly-right##24 9.864
R5084 net@2204#12pmos@106_poly-right##24 net@2204#12pmos@106_poly-right##25 9.864
R5085 net@2204#12pmos@106_poly-right##25 net@2204#12pmos@106_poly-right##26 9.864
R5086 net@2204#12pmos@106_poly-right##26 net@2204#12pmos@106_poly-right##27 9.864
R5087 net@2204#12pmos@106_poly-right##27 net@2204#12pmos@106_poly-right##28 9.864
R5088 net@2204#12pmos@106_poly-right##28 net@2204#12pmos@106_poly-right##29 9.864
R5089 net@2204#12pmos@106_poly-right##29 net@2204#12pmos@106_poly-right##30 9.864
R5090 net@2204#12pmos@106_poly-right##30 net@2204#12pmos@106_poly-right##31 9.864
R5091 net@2204#12pmos@106_poly-right##31 net@2204#12pmos@106_poly-right##32 9.864
R5092 net@2204#12pmos@106_poly-right##32 net@2204#12pmos@106_poly-right##33 9.864
R5093 net@2204#12pmos@106_poly-right##33 net@2204#12pmos@106_poly-right##34 9.864
R5094 net@2204#12pmos@106_poly-right##34 net@2204#12pmos@106_poly-right##35 9.864
R5095 net@2204#12pmos@106_poly-right##35 net@2204#12pmos@106_poly-right##36 9.864
R5096 net@2204#12pmos@106_poly-right##36 net@2204#12pmos@106_poly-right##37 9.864
R5097 net@2204#12pmos@106_poly-right##37 net@2204#12pmos@106_poly-right##38 9.864
R5098 net@2204#12pmos@106_poly-right##38 net@2204#12pmos@106_poly-right##39 9.864
R5099 net@2204#12pmos@106_poly-right##39 net@2204#12pmos@106_poly-right##40 9.864
R5100 net@2204#12pmos@106_poly-right##40 net@2204#12pmos@106_poly-right##41 9.864
R5101 net@2204#12pmos@106_poly-right##41 net@2204#12pmos@106_poly-right##42 9.864
R5102 net@2204#12pmos@106_poly-right##42 net@2204#12pmos@106_poly-right##43 9.864
R5103 net@2204#12pmos@106_poly-right##43 net@2204#12pmos@106_poly-right##44 9.864
R5104 net@2204#12pmos@106_poly-right##44 net@2204#12pmos@106_poly-right##45 9.864
R5105 net@2204#12pmos@106_poly-right##45 net@2204#12pmos@106_poly-right##46 9.864
R5106 net@2204#12pmos@106_poly-right##46 net@2204#12pmos@106_poly-right##47 9.864
R5107 net@2204#12pmos@106_poly-right##47 net@2204#12pmos@106_poly-right##48 9.864
R5108 net@2204#12pmos@106_poly-right##48 net@2204#12pmos@106_poly-right##49 9.864
R5109 net@2204#12pmos@106_poly-right##49 net@2204#12pmos@106_poly-right##50 9.864
R5110 net@2204#12pmos@106_poly-right##50 net@2204#12pmos@106_poly-right##51 9.864
R5111 net@2204#12pmos@106_poly-right##51 net@2204#12pmos@106_poly-right##52 9.864
R5112 net@2204#12pmos@106_poly-right##52 net@2204#12pmos@106_poly-right##53 9.864
R5113 net@2204#12pmos@106_poly-right##53 net@2204#5pin@634_polysilicon-1 9.864
R5114 XOR1_to_NAND4#22pmos@106_diff-top XOR1_to_NAND4#1contact@766_metal-1-metal-2 4.862
R5115 XOR1_to_NAND4#3pin@667_polysilicon-1 XOR1_to_NAND4#3pin@667_polysilicon-1##0 9.881
R5116 XOR1_to_NAND4#3pin@667_polysilicon-1##0 XOR1_to_NAND4#3pin@667_polysilicon-1##1 9.881
R5117 XOR1_to_NAND4#3pin@667_polysilicon-1##1 XOR1_to_NAND4#3pin@667_polysilicon-1##2 9.881
R5118 XOR1_to_NAND4#3pin@667_polysilicon-1##2 XOR1_to_NAND4#3pin@667_polysilicon-1##3 9.881
R5119 XOR1_to_NAND4#3pin@667_polysilicon-1##3 XOR1_to_NAND4#3pin@667_polysilicon-1##4 9.881
R5120 XOR1_to_NAND4#3pin@667_polysilicon-1##4 XOR1_to_NAND4#3pin@667_polysilicon-1##5 9.881
R5121 XOR1_to_NAND4#3pin@667_polysilicon-1##5 XOR1_to_NAND4#3pin@667_polysilicon-1##6 9.881
R5122 XOR1_to_NAND4#3pin@667_polysilicon-1##6 XOR1_to_NAND4#3pin@667_polysilicon-1##7 9.881
R5123 XOR1_to_NAND4#3pin@667_polysilicon-1##7 XOR1_to_NAND4#3pin@667_polysilicon-1##8 9.881
R5124 XOR1_to_NAND4#3pin@667_polysilicon-1##8 XOR1_to_NAND4#3pin@667_polysilicon-1##9 9.881
R5125 XOR1_to_NAND4#3pin@667_polysilicon-1##9 XOR1_to_NAND4#3pin@667_polysilicon-1##10 9.881
R5126 XOR1_to_NAND4#3pin@667_polysilicon-1##10 XOR1_to_NAND4#3pin@667_polysilicon-1##11 9.881
R5127 XOR1_to_NAND4#3pin@667_polysilicon-1##11 XOR1_to_NAND4#3pin@667_polysilicon-1##12 9.881
R5128 XOR1_to_NAND4#3pin@667_polysilicon-1##12 XOR1_to_NAND4#3pin@667_polysilicon-1##13 9.881
R5129 XOR1_to_NAND4#3pin@667_polysilicon-1##13 XOR1_to_NAND4#3pin@667_polysilicon-1##14 9.881
R5130 XOR1_to_NAND4#3pin@667_polysilicon-1##14 XOR1_to_NAND4#3pin@667_polysilicon-1##15 9.881
R5131 XOR1_to_NAND4#3pin@667_polysilicon-1##15 XOR1_to_NAND4#3pin@667_polysilicon-1##16 9.881
R5132 XOR1_to_NAND4#3pin@667_polysilicon-1##16 XOR1_to_NAND4#3pin@667_polysilicon-1##17 9.881
R5133 XOR1_to_NAND4#3pin@667_polysilicon-1##17 XOR1_to_NAND4#3pin@667_polysilicon-1##18 9.881
R5134 XOR1_to_NAND4#3pin@667_polysilicon-1##18 XOR1_to_NAND4#3pin@667_polysilicon-1##19 9.881
R5135 XOR1_to_NAND4#3pin@667_polysilicon-1##19 XOR1_to_NAND4#3pin@667_polysilicon-1##20 9.881
R5136 XOR1_to_NAND4#3pin@667_polysilicon-1##20 XOR1_to_NAND4#3pin@667_polysilicon-1##21 9.881
R5137 XOR1_to_NAND4#3pin@667_polysilicon-1##21 XOR1_to_NAND4#3pin@667_polysilicon-1##22 9.881
R5138 XOR1_to_NAND4#3pin@667_polysilicon-1##22 XOR1_to_NAND4#3pin@667_polysilicon-1##23 9.881
R5139 XOR1_to_NAND4#3pin@667_polysilicon-1##23 XOR1_to_NAND4#3pin@667_polysilicon-1##24 9.881
R5140 XOR1_to_NAND4#3pin@667_polysilicon-1##24 XOR1_to_NAND4#3pin@667_polysilicon-1##25 9.881
R5141 XOR1_to_NAND4#3pin@667_polysilicon-1##25 XOR1_to_NAND4#3pin@667_polysilicon-1##26 9.881
R5142 XOR1_to_NAND4#3pin@667_polysilicon-1##26 XOR1_to_NAND4#3pin@667_polysilicon-1##27 9.881
R5143 XOR1_to_NAND4#3pin@667_polysilicon-1##27 XOR1_to_NAND4#3pin@667_polysilicon-1##28 9.881
R5144 XOR1_to_NAND4#3pin@667_polysilicon-1##28 XOR1_to_NAND4#3pin@667_polysilicon-1##29 9.881
R5145 XOR1_to_NAND4#3pin@667_polysilicon-1##29 XOR1_to_NAND4#3pin@667_polysilicon-1##30 9.881
R5146 XOR1_to_NAND4#3pin@667_polysilicon-1##30 XOR1_to_NAND4#3pin@667_polysilicon-1##31 9.881
R5147 XOR1_to_NAND4#3pin@667_polysilicon-1##31 XOR1_to_NAND4#3pin@667_polysilicon-1##32 9.881
R5148 XOR1_to_NAND4#3pin@667_polysilicon-1##32 XOR1_to_NAND4#3pin@667_polysilicon-1##33 9.881
R5149 XOR1_to_NAND4#3pin@667_polysilicon-1##33 XOR1_to_NAND4#3pin@667_polysilicon-1##34 9.881
R5150 XOR1_to_NAND4#3pin@667_polysilicon-1##34 XOR1_to_NAND4#3pin@667_polysilicon-1##35 9.881
R5151 XOR1_to_NAND4#3pin@667_polysilicon-1##35 XOR1_to_NAND4#3pin@667_polysilicon-1##36 9.881
R5152 XOR1_to_NAND4#3pin@667_polysilicon-1##36 XOR1_to_NAND4#3pin@667_polysilicon-1##37 9.881
R5153 XOR1_to_NAND4#3pin@667_polysilicon-1##37 XOR1_to_NAND4#3pin@667_polysilicon-1##38 9.881
R5154 XOR1_to_NAND4#3pin@667_polysilicon-1##38 XOR1_to_NAND4#3pin@667_polysilicon-1##39 9.881
R5155 XOR1_to_NAND4#3pin@667_polysilicon-1##39 XOR1_to_NAND4#3pin@667_polysilicon-1##40 9.881
R5156 XOR1_to_NAND4#3pin@667_polysilicon-1##40 XOR1_to_NAND4#3pin@667_polysilicon-1##41 9.881
R5157 XOR1_to_NAND4#3pin@667_polysilicon-1##41 XOR1_to_NAND4#3pin@667_polysilicon-1##42 9.881
R5158 XOR1_to_NAND4#3pin@667_polysilicon-1##42 XOR1_to_NAND4#3pin@667_polysilicon-1##43 9.881
R5159 XOR1_to_NAND4#3pin@667_polysilicon-1##43 XOR1_to_NAND4#3pin@667_polysilicon-1##44 9.881
R5160 XOR1_to_NAND4#3pin@667_polysilicon-1##44 XOR1_to_NAND4#3pin@667_polysilicon-1##45 9.881
R5161 XOR1_to_NAND4#3pin@667_polysilicon-1##45 XOR1_to_NAND4#3pin@667_polysilicon-1##46 9.881
R5162 XOR1_to_NAND4#3pin@667_polysilicon-1##46 XOR1_to_NAND4#3pin@667_polysilicon-1##47 9.881
R5163 XOR1_to_NAND4#3pin@667_polysilicon-1##47 XOR1_to_NAND4#3pin@667_polysilicon-1##48 9.881
R5164 XOR1_to_NAND4#3pin@667_polysilicon-1##48 XOR1_to_NAND4#3pin@667_polysilicon-1##49 9.881
R5165 XOR1_to_NAND4#3pin@667_polysilicon-1##49 XOR1_to_NAND4#3pin@667_polysilicon-1##50 9.881
R5166 XOR1_to_NAND4#3pin@667_polysilicon-1##50 XOR1_to_NAND4#3pin@667_polysilicon-1##51 9.881
R5167 XOR1_to_NAND4#3pin@667_polysilicon-1##51 XOR1_to_NAND4#3pin@667_polysilicon-1##52 9.881
R5168 XOR1_to_NAND4#3pin@667_polysilicon-1##52 XOR1_to_NAND4#3pin@667_polysilicon-1##53 9.881
R5169 XOR1_to_NAND4#3pin@667_polysilicon-1##53 XOR1_to_NAND4#3pin@667_polysilicon-1##54 9.881
R5170 XOR1_to_NAND4#3pin@667_polysilicon-1##54 XOR1_to_NAND4#24nmos@112_poly-right 9.881
R5171 net@2108#5pmos@112_diff-top net@2108#2pin@656_metal-1 4.81
R5172 net@2108#1pin@666_polysilicon-1 net@2108#1pin@666_polysilicon-1##0 9.85
R5173 net@2108#1pin@666_polysilicon-1##0 net@2108#1pin@666_polysilicon-1##1 9.85
R5174 net@2108#1pin@666_polysilicon-1##1 net@2108#1pin@666_polysilicon-1##2 9.85
R5175 net@2108#1pin@666_polysilicon-1##2 net@2108#1pin@666_polysilicon-1##3 9.85
R5176 net@2108#1pin@666_polysilicon-1##3 net@2108#1pin@666_polysilicon-1##4 9.85
R5177 net@2108#1pin@666_polysilicon-1##4 net@2108#1pin@666_polysilicon-1##5 9.85
R5178 net@2108#1pin@666_polysilicon-1##5 net@2108#1pin@666_polysilicon-1##6 9.85
R5179 net@2108#1pin@666_polysilicon-1##6 net@2108#1pin@666_polysilicon-1##7 9.85
R5180 net@2108#1pin@666_polysilicon-1##7 net@2108#1pin@666_polysilicon-1##8 9.85
R5181 net@2108#1pin@666_polysilicon-1##8 net@2108#1pin@666_polysilicon-1##9 9.85
R5182 net@2108#1pin@666_polysilicon-1##9 net@2108#1pin@666_polysilicon-1##10 9.85
R5183 net@2108#1pin@666_polysilicon-1##10 net@2108#1pin@666_polysilicon-1##11 9.85
R5184 net@2108#1pin@666_polysilicon-1##11 net@2108#1pin@666_polysilicon-1##12 9.85
R5185 net@2108#1pin@666_polysilicon-1##12 net@2108#1pin@666_polysilicon-1##13 9.85
R5186 net@2108#1pin@666_polysilicon-1##13 net@2108#1pin@666_polysilicon-1##14 9.85
R5187 net@2108#1pin@666_polysilicon-1##14 net@2108#1pin@666_polysilicon-1##15 9.85
R5188 net@2108#1pin@666_polysilicon-1##15 net@2108#1pin@666_polysilicon-1##16 9.85
R5189 net@2108#1pin@666_polysilicon-1##16 net@2108#1pin@666_polysilicon-1##17 9.85
R5190 net@2108#1pin@666_polysilicon-1##17 net@2108#1pin@666_polysilicon-1##18 9.85
R5191 net@2108#1pin@666_polysilicon-1##18 net@2108#1pin@666_polysilicon-1##19 9.85
R5192 net@2108#1pin@666_polysilicon-1##19 net@2108#1pin@666_polysilicon-1##20 9.85
R5193 net@2108#1pin@666_polysilicon-1##20 net@2108#1pin@666_polysilicon-1##21 9.85
R5194 net@2108#1pin@666_polysilicon-1##21 net@2108#1pin@666_polysilicon-1##22 9.85
R5195 net@2108#1pin@666_polysilicon-1##22 net@2108#1pin@666_polysilicon-1##23 9.85
R5196 net@2108#1pin@666_polysilicon-1##23 net@2108#1pin@666_polysilicon-1##24 9.85
R5197 net@2108#1pin@666_polysilicon-1##24 net@2108#1pin@666_polysilicon-1##25 9.85
R5198 net@2108#1pin@666_polysilicon-1##25 net@2108#1pin@666_polysilicon-1##26 9.85
R5199 net@2108#1pin@666_polysilicon-1##26 net@2108#1pin@666_polysilicon-1##27 9.85
R5200 net@2108#1pin@666_polysilicon-1##27 net@2108#1pin@666_polysilicon-1##28 9.85
R5201 net@2108#1pin@666_polysilicon-1##28 net@2108#1pin@666_polysilicon-1##29 9.85
R5202 net@2108#1pin@666_polysilicon-1##29 net@2108#1pin@666_polysilicon-1##30 9.85
R5203 net@2108#1pin@666_polysilicon-1##30 net@2108#1pin@666_polysilicon-1##31 9.85
R5204 net@2108#1pin@666_polysilicon-1##31 net@2108#1pin@666_polysilicon-1##32 9.85
R5205 net@2108#1pin@666_polysilicon-1##32 net@2108#1pin@666_polysilicon-1##33 9.85
R5206 net@2108#1pin@666_polysilicon-1##33 net@2108#1pin@666_polysilicon-1##34 9.85
R5207 net@2108#1pin@666_polysilicon-1##34 net@2108#1pin@666_polysilicon-1##35 9.85
R5208 net@2108#1pin@666_polysilicon-1##35 net@2108#1pin@666_polysilicon-1##36 9.85
R5209 net@2108#1pin@666_polysilicon-1##36 net@2108#1pin@666_polysilicon-1##37 9.85
R5210 net@2108#1pin@666_polysilicon-1##37 net@2108#1pin@666_polysilicon-1##38 9.85
R5211 net@2108#1pin@666_polysilicon-1##38 net@2108#1pin@666_polysilicon-1##39 9.85
R5212 net@2108#1pin@666_polysilicon-1##39 net@2108#1pin@666_polysilicon-1##40 9.85
R5213 net@2108#1pin@666_polysilicon-1##40 net@2108#1pin@666_polysilicon-1##41 9.85
R5214 net@2108#1pin@666_polysilicon-1##41 net@2108#1pin@666_polysilicon-1##42 9.85
R5215 net@2108#1pin@666_polysilicon-1##42 net@2108#1pin@666_polysilicon-1##43 9.85
R5216 net@2108#1pin@666_polysilicon-1##43 net@2108#1pin@666_polysilicon-1##44 9.85
R5217 net@2108#1pin@666_polysilicon-1##44 net@2108#1pin@666_polysilicon-1##45 9.85
R5218 net@2108#1pin@666_polysilicon-1##45 net@2108#1pin@666_polysilicon-1##46 9.85
R5219 net@2108#1pin@666_polysilicon-1##46 net@2108#1pin@666_polysilicon-1##47 9.85
R5220 net@2108#1pin@666_polysilicon-1##47 net@2108#1pin@666_polysilicon-1##48 9.85
R5221 net@2108#1pin@666_polysilicon-1##48 net@2108#1pin@666_polysilicon-1##49 9.85
R5222 net@2108#1pin@666_polysilicon-1##49 net@2108#1pin@666_polysilicon-1##50 9.85
R5223 net@2108#1pin@666_polysilicon-1##50 net@2108#1pin@666_polysilicon-1##51 9.85
R5224 net@2108#1pin@666_polysilicon-1##51 net@2108#1pin@666_polysilicon-1##52 9.85
R5225 net@2108#1pin@666_polysilicon-1##52 net@2108#1pin@666_polysilicon-1##53 9.85
R5226 net@2108#1pin@666_polysilicon-1##53 net@2108#1pin@666_polysilicon-1##54 9.85
R5227 net@2108#1pin@666_polysilicon-1##54 net@2108#1pin@666_polysilicon-1##55 9.85
R5228 net@2108#1pin@666_polysilicon-1##55 net@2108#1pin@666_polysilicon-1##56 9.85
R5229 net@2108#1pin@666_polysilicon-1##56 net@2108#1pin@666_polysilicon-1##57 9.85
R5230 net@2108#1pin@666_polysilicon-1##57 net@2108#1pin@666_polysilicon-1##58 9.85
R5231 net@2108#1pin@666_polysilicon-1##58 net@2108#1pin@666_polysilicon-1##59 9.85
R5232 net@2108#1pin@666_polysilicon-1##59 net@2108#1pin@666_polysilicon-1##60 9.85
R5233 net@2108#1pin@666_polysilicon-1##60 net@2108#2pin@656_metal-1 9.85
R5234 Cin_to_XOR2___NAND4#26pmos@111_poly-right Cin_to_XOR2___NAND4#26pmos@111_poly-right##0 9.854
R5235 Cin_to_XOR2___NAND4#26pmos@111_poly-right##0 Cin_to_XOR2___NAND4#26pmos@111_poly-right##1 9.854
R5236 Cin_to_XOR2___NAND4#26pmos@111_poly-right##1 Cin_to_XOR2___NAND4#26pmos@111_poly-right##2 9.854
R5237 Cin_to_XOR2___NAND4#26pmos@111_poly-right##2 Cin_to_XOR2___NAND4#26pmos@111_poly-right##3 9.854
R5238 Cin_to_XOR2___NAND4#26pmos@111_poly-right##3 Cin_to_XOR2___NAND4#26pmos@111_poly-right##4 9.854
R5239 Cin_to_XOR2___NAND4#26pmos@111_poly-right##4 Cin_to_XOR2___NAND4#26pmos@111_poly-right##5 9.854
R5240 Cin_to_XOR2___NAND4#26pmos@111_poly-right##5 Cin_to_XOR2___NAND4#26pmos@111_poly-right##6 9.854
R5241 Cin_to_XOR2___NAND4#26pmos@111_poly-right##6 Cin_to_XOR2___NAND4#26pmos@111_poly-right##7 9.854
R5242 Cin_to_XOR2___NAND4#26pmos@111_poly-right##7 Cin_to_XOR2___NAND4#26pmos@111_poly-right##8 9.854
R5243 Cin_to_XOR2___NAND4#26pmos@111_poly-right##8 Cin_to_XOR2___NAND4#26pmos@111_poly-right##9 9.854
R5244 Cin_to_XOR2___NAND4#26pmos@111_poly-right##9 Cin_to_XOR2___NAND4#26pmos@111_poly-right##10 9.854
R5245 Cin_to_XOR2___NAND4#26pmos@111_poly-right##10 Cin_to_XOR2___NAND4#26pmos@111_poly-right##11 9.854
R5246 Cin_to_XOR2___NAND4#26pmos@111_poly-right##11 Cin_to_XOR2___NAND4#26pmos@111_poly-right##12 9.854
R5247 Cin_to_XOR2___NAND4#26pmos@111_poly-right##12 Cin_to_XOR2___NAND4#26pmos@111_poly-right##13 9.854
R5248 Cin_to_XOR2___NAND4#26pmos@111_poly-right##13 Cin_to_XOR2___NAND4#26pmos@111_poly-right##14 9.854
R5249 Cin_to_XOR2___NAND4#26pmos@111_poly-right##14 Cin_to_XOR2___NAND4#26pmos@111_poly-right##15 9.854
R5250 Cin_to_XOR2___NAND4#26pmos@111_poly-right##15 Cin_to_XOR2___NAND4#26pmos@111_poly-right##16 9.854
R5251 Cin_to_XOR2___NAND4#26pmos@111_poly-right##16 Cin_to_XOR2___NAND4#26pmos@111_poly-right##17 9.854
R5252 Cin_to_XOR2___NAND4#26pmos@111_poly-right##17 Cin_to_XOR2___NAND4#26pmos@111_poly-right##18 9.854
R5253 Cin_to_XOR2___NAND4#26pmos@111_poly-right##18 Cin_to_XOR2___NAND4#26pmos@111_poly-right##19 9.854
R5254 Cin_to_XOR2___NAND4#26pmos@111_poly-right##19 Cin_to_XOR2___NAND4#26pmos@111_poly-right##20 9.854
R5255 Cin_to_XOR2___NAND4#26pmos@111_poly-right##20 Cin_to_XOR2___NAND4#26pmos@111_poly-right##21 9.854
R5256 Cin_to_XOR2___NAND4#26pmos@111_poly-right##21 Cin_to_XOR2___NAND4#26pmos@111_poly-right##22 9.854
R5257 Cin_to_XOR2___NAND4#26pmos@111_poly-right##22 Cin_to_XOR2___NAND4#26pmos@111_poly-right##23 9.854
R5258 Cin_to_XOR2___NAND4#26pmos@111_poly-right##23 Cin_to_XOR2___NAND4#26pmos@111_poly-right##24 9.854
R5259 Cin_to_XOR2___NAND4#26pmos@111_poly-right##24 Cin_to_XOR2___NAND4#26pmos@111_poly-right##25 9.854
R5260 Cin_to_XOR2___NAND4#26pmos@111_poly-right##25 Cin_to_XOR2___NAND4#26pmos@111_poly-right##26 9.854
R5261 Cin_to_XOR2___NAND4#26pmos@111_poly-right##26 Cin_to_XOR2___NAND4#26pmos@111_poly-right##27 9.854
R5262 Cin_to_XOR2___NAND4#26pmos@111_poly-right##27 Cin_to_XOR2___NAND4#26pmos@111_poly-right##28 9.854
R5263 Cin_to_XOR2___NAND4#26pmos@111_poly-right##28 Cin_to_XOR2___NAND4#26pmos@111_poly-right##29 9.854
R5264 Cin_to_XOR2___NAND4#26pmos@111_poly-right##29 Cin_to_XOR2___NAND4#26pmos@111_poly-right##30 9.854
R5265 Cin_to_XOR2___NAND4#26pmos@111_poly-right##30 Cin_to_XOR2___NAND4#26pmos@111_poly-right##31 9.854
R5266 Cin_to_XOR2___NAND4#26pmos@111_poly-right##31 Cin_to_XOR2___NAND4#26pmos@111_poly-right##32 9.854
R5267 Cin_to_XOR2___NAND4#26pmos@111_poly-right##32 Cin_to_XOR2___NAND4#26pmos@111_poly-right##33 9.854
R5268 Cin_to_XOR2___NAND4#26pmos@111_poly-right##33 Cin_to_XOR2___NAND4#26pmos@111_poly-right##34 9.854
R5269 Cin_to_XOR2___NAND4#26pmos@111_poly-right##34 Cin_to_XOR2___NAND4#26pmos@111_poly-right##35 9.854
R5270 Cin_to_XOR2___NAND4#26pmos@111_poly-right##35 Cin_to_XOR2___NAND4#26pmos@111_poly-right##36 9.854
R5271 Cin_to_XOR2___NAND4#26pmos@111_poly-right##36 Cin_to_XOR2___NAND4#26pmos@111_poly-right##37 9.854
R5272 Cin_to_XOR2___NAND4#26pmos@111_poly-right##37 Cin_to_XOR2___NAND4#26pmos@111_poly-right##38 9.854
R5273 Cin_to_XOR2___NAND4#26pmos@111_poly-right##38 Cin_to_XOR2___NAND4#26pmos@111_poly-right##39 9.854
R5274 Cin_to_XOR2___NAND4#26pmos@111_poly-right##39 Cin_to_XOR2___NAND4#26pmos@111_poly-right##40 9.854
R5275 Cin_to_XOR2___NAND4#26pmos@111_poly-right##40 Cin_to_XOR2___NAND4#26pmos@111_poly-right##41 9.854
R5276 Cin_to_XOR2___NAND4#26pmos@111_poly-right##41 Cin_to_XOR2___NAND4#26pmos@111_poly-right##42 9.854
R5277 Cin_to_XOR2___NAND4#26pmos@111_poly-right##42 Cin_to_XOR2___NAND4#26pmos@111_poly-right##43 9.854
R5278 Cin_to_XOR2___NAND4#26pmos@111_poly-right##43 Cin_to_XOR2___NAND4#26pmos@111_poly-right##44 9.854
R5279 Cin_to_XOR2___NAND4#26pmos@111_poly-right##44 Cin_to_XOR2___NAND4#26pmos@111_poly-right##45 9.854
R5280 Cin_to_XOR2___NAND4#26pmos@111_poly-right##45 Cin_to_XOR2___NAND4#26pmos@111_poly-right##46 9.854
R5281 Cin_to_XOR2___NAND4#26pmos@111_poly-right##46 Cin_to_XOR2___NAND4#26pmos@111_poly-right##47 9.854
R5282 Cin_to_XOR2___NAND4#26pmos@111_poly-right##47 Cin_to_XOR2___NAND4#26pmos@111_poly-right##48 9.854
R5283 Cin_to_XOR2___NAND4#26pmos@111_poly-right##48 Cin_to_XOR2___NAND4#26pmos@111_poly-right##49 9.854
R5284 Cin_to_XOR2___NAND4#26pmos@111_poly-right##49 Cin_to_XOR2___NAND4#26pmos@111_poly-right##50 9.854
R5285 Cin_to_XOR2___NAND4#26pmos@111_poly-right##50 Cin_to_XOR2___NAND4#26pmos@111_poly-right##51 9.854
R5286 Cin_to_XOR2___NAND4#26pmos@111_poly-right##51 Cin_to_XOR2___NAND4#26pmos@111_poly-right##52 9.854
R5287 Cin_to_XOR2___NAND4#26pmos@111_poly-right##52 Cin_to_XOR2___NAND4#26pmos@111_poly-right##53 9.854
R5288 Cin_to_XOR2___NAND4#26pmos@111_poly-right##53 Cin_to_XOR2___NAND4#26pmos@111_poly-right##54 9.854
R5289 Cin_to_XOR2___NAND4#26pmos@111_poly-right##54 Cin_to_XOR2___NAND4#15pin@657_polysilicon-1 9.854
R5290 net@2118 net@2118#2contact@727_metal-1-metal-2 4.797
R5291 XOR1_to_NAND4#9pmos@107_poly-left XOR1_to_NAND4#9pmos@107_poly-left##0 9.871
R5292 XOR1_to_NAND4#9pmos@107_poly-left##0 XOR1_to_NAND4#9pmos@107_poly-left##1 9.871
R5293 XOR1_to_NAND4#9pmos@107_poly-left##1 XOR1_to_NAND4#9pmos@107_poly-left##2 9.871
R5294 XOR1_to_NAND4#9pmos@107_poly-left##2 XOR1_to_NAND4#9pmos@107_poly-left##3 9.871
R5295 XOR1_to_NAND4#9pmos@107_poly-left##3 XOR1_to_NAND4#9pmos@107_poly-left##4 9.871
R5296 XOR1_to_NAND4#9pmos@107_poly-left##4 XOR1_to_NAND4#9pmos@107_poly-left##5 9.871
R5297 XOR1_to_NAND4#9pmos@107_poly-left##5 XOR1_to_NAND4#9pmos@107_poly-left##6 9.871
R5298 XOR1_to_NAND4#9pmos@107_poly-left##6 XOR1_to_NAND4#9pmos@107_poly-left##7 9.871
R5299 XOR1_to_NAND4#9pmos@107_poly-left##7 XOR1_to_NAND4#9pmos@107_poly-left##8 9.871
R5300 XOR1_to_NAND4#9pmos@107_poly-left##8 XOR1_to_NAND4#9pmos@107_poly-left##9 9.871
R5301 XOR1_to_NAND4#9pmos@107_poly-left##9 XOR1_to_NAND4#9pmos@107_poly-left##10 9.871
R5302 XOR1_to_NAND4#9pmos@107_poly-left##10 XOR1_to_NAND4#9pmos@107_poly-left##11 9.871
R5303 XOR1_to_NAND4#9pmos@107_poly-left##11 XOR1_to_NAND4#9pmos@107_poly-left##12 9.871
R5304 XOR1_to_NAND4#9pmos@107_poly-left##12 XOR1_to_NAND4#9pmos@107_poly-left##13 9.871
R5305 XOR1_to_NAND4#9pmos@107_poly-left##13 XOR1_to_NAND4#9pmos@107_poly-left##14 9.871
R5306 XOR1_to_NAND4#9pmos@107_poly-left##14 XOR1_to_NAND4#9pmos@107_poly-left##15 9.871
R5307 XOR1_to_NAND4#9pmos@107_poly-left##15 XOR1_to_NAND4#9pmos@107_poly-left##16 9.871
R5308 XOR1_to_NAND4#9pmos@107_poly-left##16 XOR1_to_NAND4#9pmos@107_poly-left##17 9.871
R5309 XOR1_to_NAND4#9pmos@107_poly-left##17 XOR1_to_NAND4#9pmos@107_poly-left##18 9.871
R5310 XOR1_to_NAND4#9pmos@107_poly-left##18 XOR1_to_NAND4#9pmos@107_poly-left##19 9.871
R5311 XOR1_to_NAND4#9pmos@107_poly-left##19 XOR1_to_NAND4#9pmos@107_poly-left##20 9.871
R5312 XOR1_to_NAND4#9pmos@107_poly-left##20 XOR1_to_NAND4#9pmos@107_poly-left##21 9.871
R5313 XOR1_to_NAND4#9pmos@107_poly-left##21 XOR1_to_NAND4#9pmos@107_poly-left##22 9.871
R5314 XOR1_to_NAND4#9pmos@107_poly-left##22 XOR1_to_NAND4#9pmos@107_poly-left##23 9.871
R5315 XOR1_to_NAND4#9pmos@107_poly-left##23 XOR1_to_NAND4#9pmos@107_poly-left##24 9.871
R5316 XOR1_to_NAND4#9pmos@107_poly-left##24 XOR1_to_NAND4#9pmos@107_poly-left##25 9.871
R5317 XOR1_to_NAND4#9pmos@107_poly-left##25 XOR1_to_NAND4#9pmos@107_poly-left##26 9.871
R5318 XOR1_to_NAND4#9pmos@107_poly-left##26 XOR1_to_NAND4#9pmos@107_poly-left##27 9.871
R5319 XOR1_to_NAND4#9pmos@107_poly-left##27 XOR1_to_NAND4#9pmos@107_poly-left##28 9.871
R5320 XOR1_to_NAND4#9pmos@107_poly-left##28 XOR1_to_NAND4#9pmos@107_poly-left##29 9.871
R5321 XOR1_to_NAND4#9pmos@107_poly-left##29 XOR1_to_NAND4#9pmos@107_poly-left##30 9.871
R5322 XOR1_to_NAND4#9pmos@107_poly-left##30 XOR1_to_NAND4#9pmos@107_poly-left##31 9.871
R5323 XOR1_to_NAND4#9pmos@107_poly-left##31 XOR1_to_NAND4#9pmos@107_poly-left##32 9.871
R5324 XOR1_to_NAND4#9pmos@107_poly-left##32 XOR1_to_NAND4#9pmos@107_poly-left##33 9.871
R5325 XOR1_to_NAND4#9pmos@107_poly-left##33 XOR1_to_NAND4#9pmos@107_poly-left##34 9.871
R5326 XOR1_to_NAND4#9pmos@107_poly-left##34 XOR1_to_NAND4#9pmos@107_poly-left##35 9.871
R5327 XOR1_to_NAND4#9pmos@107_poly-left##35 XOR1_to_NAND4#9pmos@107_poly-left##36 9.871
R5328 XOR1_to_NAND4#9pmos@107_poly-left##36 XOR1_to_NAND4#9pmos@107_poly-left##37 9.871
R5329 XOR1_to_NAND4#9pmos@107_poly-left##37 XOR1_to_NAND4#9pmos@107_poly-left##38 9.871
R5330 XOR1_to_NAND4#9pmos@107_poly-left##38 XOR1_to_NAND4#9pmos@107_poly-left##39 9.871
R5331 XOR1_to_NAND4#9pmos@107_poly-left##39 XOR1_to_NAND4#9pmos@107_poly-left##40 9.871
R5332 XOR1_to_NAND4#9pmos@107_poly-left##40 XOR1_to_NAND4#9pmos@107_poly-left##41 9.871
R5333 XOR1_to_NAND4#9pmos@107_poly-left##41 XOR1_to_NAND4#9pmos@107_poly-left##42 9.871
R5334 XOR1_to_NAND4#9pmos@107_poly-left##42 XOR1_to_NAND4#9pmos@107_poly-left##43 9.871
R5335 XOR1_to_NAND4#9pmos@107_poly-left##43 XOR1_to_NAND4#9pmos@107_poly-left##44 9.871
R5336 XOR1_to_NAND4#9pmos@107_poly-left##44 XOR1_to_NAND4#9pmos@107_poly-left##45 9.871
R5337 XOR1_to_NAND4#9pmos@107_poly-left##45 XOR1_to_NAND4#9pmos@107_poly-left##46 9.871
R5338 XOR1_to_NAND4#9pmos@107_poly-left##46 XOR1_to_NAND4#9pmos@107_poly-left##47 9.871
R5339 XOR1_to_NAND4#9pmos@107_poly-left##47 XOR1_to_NAND4#9pmos@107_poly-left##48 9.871
R5340 XOR1_to_NAND4#9pmos@107_poly-left##48 XOR1_to_NAND4#9pmos@107_poly-left##49 9.871
R5341 XOR1_to_NAND4#9pmos@107_poly-left##49 XOR1_to_NAND4#9pmos@107_poly-left##50 9.871
R5342 XOR1_to_NAND4#9pmos@107_poly-left##50 XOR1_to_NAND4#9pmos@107_poly-left##51 9.871
R5343 XOR1_to_NAND4#9pmos@107_poly-left##51 XOR1_to_NAND4#9pmos@107_poly-left##52 9.871
R5344 XOR1_to_NAND4#9pmos@107_poly-left##52 XOR1_to_NAND4#9pmos@107_poly-left##53 9.871
R5345 XOR1_to_NAND4#9pmos@107_poly-left##53 XOR1_to_NAND4#9pmos@107_poly-left##54 9.871
R5346 XOR1_to_NAND4#9pmos@107_poly-left##54 XOR1_to_NAND4#9pmos@107_poly-left##55 9.871
R5347 XOR1_to_NAND4#9pmos@107_poly-left##55 XOR1_to_NAND4#26nmos@107_poly-right 9.871
R5348 net@2108#7pmos@108_poly-left net@2108#7pmos@108_poly-left##0 9.871
R5349 net@2108#7pmos@108_poly-left##0 net@2108#7pmos@108_poly-left##1 9.871
R5350 net@2108#7pmos@108_poly-left##1 net@2108#7pmos@108_poly-left##2 9.871
R5351 net@2108#7pmos@108_poly-left##2 net@2108#7pmos@108_poly-left##3 9.871
R5352 net@2108#7pmos@108_poly-left##3 net@2108#7pmos@108_poly-left##4 9.871
R5353 net@2108#7pmos@108_poly-left##4 net@2108#7pmos@108_poly-left##5 9.871
R5354 net@2108#7pmos@108_poly-left##5 net@2108#7pmos@108_poly-left##6 9.871
R5355 net@2108#7pmos@108_poly-left##6 net@2108#7pmos@108_poly-left##7 9.871
R5356 net@2108#7pmos@108_poly-left##7 net@2108#7pmos@108_poly-left##8 9.871
R5357 net@2108#7pmos@108_poly-left##8 net@2108#7pmos@108_poly-left##9 9.871
R5358 net@2108#7pmos@108_poly-left##9 net@2108#7pmos@108_poly-left##10 9.871
R5359 net@2108#7pmos@108_poly-left##10 net@2108#7pmos@108_poly-left##11 9.871
R5360 net@2108#7pmos@108_poly-left##11 net@2108#7pmos@108_poly-left##12 9.871
R5361 net@2108#7pmos@108_poly-left##12 net@2108#7pmos@108_poly-left##13 9.871
R5362 net@2108#7pmos@108_poly-left##13 net@2108#7pmos@108_poly-left##14 9.871
R5363 net@2108#7pmos@108_poly-left##14 net@2108#7pmos@108_poly-left##15 9.871
R5364 net@2108#7pmos@108_poly-left##15 net@2108#7pmos@108_poly-left##16 9.871
R5365 net@2108#7pmos@108_poly-left##16 net@2108#7pmos@108_poly-left##17 9.871
R5366 net@2108#7pmos@108_poly-left##17 net@2108#7pmos@108_poly-left##18 9.871
R5367 net@2108#7pmos@108_poly-left##18 net@2108#7pmos@108_poly-left##19 9.871
R5368 net@2108#7pmos@108_poly-left##19 net@2108#7pmos@108_poly-left##20 9.871
R5369 net@2108#7pmos@108_poly-left##20 net@2108#7pmos@108_poly-left##21 9.871
R5370 net@2108#7pmos@108_poly-left##21 net@2108#7pmos@108_poly-left##22 9.871
R5371 net@2108#7pmos@108_poly-left##22 net@2108#7pmos@108_poly-left##23 9.871
R5372 net@2108#7pmos@108_poly-left##23 net@2108#7pmos@108_poly-left##24 9.871
R5373 net@2108#7pmos@108_poly-left##24 net@2108#7pmos@108_poly-left##25 9.871
R5374 net@2108#7pmos@108_poly-left##25 net@2108#7pmos@108_poly-left##26 9.871
R5375 net@2108#7pmos@108_poly-left##26 net@2108#7pmos@108_poly-left##27 9.871
R5376 net@2108#7pmos@108_poly-left##27 net@2108#7pmos@108_poly-left##28 9.871
R5377 net@2108#7pmos@108_poly-left##28 net@2108#7pmos@108_poly-left##29 9.871
R5378 net@2108#7pmos@108_poly-left##29 net@2108#7pmos@108_poly-left##30 9.871
R5379 net@2108#7pmos@108_poly-left##30 net@2108#7pmos@108_poly-left##31 9.871
R5380 net@2108#7pmos@108_poly-left##31 net@2108#7pmos@108_poly-left##32 9.871
R5381 net@2108#7pmos@108_poly-left##32 net@2108#7pmos@108_poly-left##33 9.871
R5382 net@2108#7pmos@108_poly-left##33 net@2108#7pmos@108_poly-left##34 9.871
R5383 net@2108#7pmos@108_poly-left##34 net@2108#7pmos@108_poly-left##35 9.871
R5384 net@2108#7pmos@108_poly-left##35 net@2108#7pmos@108_poly-left##36 9.871
R5385 net@2108#7pmos@108_poly-left##36 net@2108#7pmos@108_poly-left##37 9.871
R5386 net@2108#7pmos@108_poly-left##37 net@2108#7pmos@108_poly-left##38 9.871
R5387 net@2108#7pmos@108_poly-left##38 net@2108#7pmos@108_poly-left##39 9.871
R5388 net@2108#7pmos@108_poly-left##39 net@2108#7pmos@108_poly-left##40 9.871
R5389 net@2108#7pmos@108_poly-left##40 net@2108#7pmos@108_poly-left##41 9.871
R5390 net@2108#7pmos@108_poly-left##41 net@2108#7pmos@108_poly-left##42 9.871
R5391 net@2108#7pmos@108_poly-left##42 net@2108#7pmos@108_poly-left##43 9.871
R5392 net@2108#7pmos@108_poly-left##43 net@2108#7pmos@108_poly-left##44 9.871
R5393 net@2108#7pmos@108_poly-left##44 net@2108#7pmos@108_poly-left##45 9.871
R5394 net@2108#7pmos@108_poly-left##45 net@2108#7pmos@108_poly-left##46 9.871
R5395 net@2108#7pmos@108_poly-left##46 net@2108#7pmos@108_poly-left##47 9.871
R5396 net@2108#7pmos@108_poly-left##47 net@2108#7pmos@108_poly-left##48 9.871
R5397 net@2108#7pmos@108_poly-left##48 net@2108#7pmos@108_poly-left##49 9.871
R5398 net@2108#7pmos@108_poly-left##49 net@2108#7pmos@108_poly-left##50 9.871
R5399 net@2108#7pmos@108_poly-left##50 net@2108#7pmos@108_poly-left##51 9.871
R5400 net@2108#7pmos@108_poly-left##51 net@2108#7pmos@108_poly-left##52 9.871
R5401 net@2108#7pmos@108_poly-left##52 net@2108#7pmos@108_poly-left##53 9.871
R5402 net@2108#7pmos@108_poly-left##53 net@2108#7pmos@108_poly-left##54 9.871
R5403 net@2108#7pmos@108_poly-left##54 net@2108#7pmos@108_poly-left##55 9.871
R5404 net@2108#7pmos@108_poly-left##55 net@2108#11nmos@108_poly-right 9.871
R5405 Cin_to_XOR2___NAND4#27pmos@109_poly-right Cin_to_XOR2___NAND4#27pmos@109_poly-right##0 9.871
R5406 Cin_to_XOR2___NAND4#27pmos@109_poly-right##0 Cin_to_XOR2___NAND4#27pmos@109_poly-right##1 9.871
R5407 Cin_to_XOR2___NAND4#27pmos@109_poly-right##1 Cin_to_XOR2___NAND4#27pmos@109_poly-right##2 9.871
R5408 Cin_to_XOR2___NAND4#27pmos@109_poly-right##2 Cin_to_XOR2___NAND4#27pmos@109_poly-right##3 9.871
R5409 Cin_to_XOR2___NAND4#27pmos@109_poly-right##3 Cin_to_XOR2___NAND4#27pmos@109_poly-right##4 9.871
R5410 Cin_to_XOR2___NAND4#27pmos@109_poly-right##4 Cin_to_XOR2___NAND4#27pmos@109_poly-right##5 9.871
R5411 Cin_to_XOR2___NAND4#27pmos@109_poly-right##5 Cin_to_XOR2___NAND4#27pmos@109_poly-right##6 9.871
R5412 Cin_to_XOR2___NAND4#27pmos@109_poly-right##6 Cin_to_XOR2___NAND4#27pmos@109_poly-right##7 9.871
R5413 Cin_to_XOR2___NAND4#27pmos@109_poly-right##7 Cin_to_XOR2___NAND4#27pmos@109_poly-right##8 9.871
R5414 Cin_to_XOR2___NAND4#27pmos@109_poly-right##8 Cin_to_XOR2___NAND4#27pmos@109_poly-right##9 9.871
R5415 Cin_to_XOR2___NAND4#27pmos@109_poly-right##9 Cin_to_XOR2___NAND4#27pmos@109_poly-right##10 9.871
R5416 Cin_to_XOR2___NAND4#27pmos@109_poly-right##10 Cin_to_XOR2___NAND4#27pmos@109_poly-right##11 9.871
R5417 Cin_to_XOR2___NAND4#27pmos@109_poly-right##11 Cin_to_XOR2___NAND4#27pmos@109_poly-right##12 9.871
R5418 Cin_to_XOR2___NAND4#27pmos@109_poly-right##12 Cin_to_XOR2___NAND4#27pmos@109_poly-right##13 9.871
R5419 Cin_to_XOR2___NAND4#27pmos@109_poly-right##13 Cin_to_XOR2___NAND4#27pmos@109_poly-right##14 9.871
R5420 Cin_to_XOR2___NAND4#27pmos@109_poly-right##14 Cin_to_XOR2___NAND4#27pmos@109_poly-right##15 9.871
R5421 Cin_to_XOR2___NAND4#27pmos@109_poly-right##15 Cin_to_XOR2___NAND4#27pmos@109_poly-right##16 9.871
R5422 Cin_to_XOR2___NAND4#27pmos@109_poly-right##16 Cin_to_XOR2___NAND4#27pmos@109_poly-right##17 9.871
R5423 Cin_to_XOR2___NAND4#27pmos@109_poly-right##17 Cin_to_XOR2___NAND4#27pmos@109_poly-right##18 9.871
R5424 Cin_to_XOR2___NAND4#27pmos@109_poly-right##18 Cin_to_XOR2___NAND4#27pmos@109_poly-right##19 9.871
R5425 Cin_to_XOR2___NAND4#27pmos@109_poly-right##19 Cin_to_XOR2___NAND4#27pmos@109_poly-right##20 9.871
R5426 Cin_to_XOR2___NAND4#27pmos@109_poly-right##20 Cin_to_XOR2___NAND4#27pmos@109_poly-right##21 9.871
R5427 Cin_to_XOR2___NAND4#27pmos@109_poly-right##21 Cin_to_XOR2___NAND4#27pmos@109_poly-right##22 9.871
R5428 Cin_to_XOR2___NAND4#27pmos@109_poly-right##22 Cin_to_XOR2___NAND4#27pmos@109_poly-right##23 9.871
R5429 Cin_to_XOR2___NAND4#27pmos@109_poly-right##23 Cin_to_XOR2___NAND4#27pmos@109_poly-right##24 9.871
R5430 Cin_to_XOR2___NAND4#27pmos@109_poly-right##24 Cin_to_XOR2___NAND4#27pmos@109_poly-right##25 9.871
R5431 Cin_to_XOR2___NAND4#27pmos@109_poly-right##25 Cin_to_XOR2___NAND4#27pmos@109_poly-right##26 9.871
R5432 Cin_to_XOR2___NAND4#27pmos@109_poly-right##26 Cin_to_XOR2___NAND4#27pmos@109_poly-right##27 9.871
R5433 Cin_to_XOR2___NAND4#27pmos@109_poly-right##27 Cin_to_XOR2___NAND4#27pmos@109_poly-right##28 9.871
R5434 Cin_to_XOR2___NAND4#27pmos@109_poly-right##28 Cin_to_XOR2___NAND4#27pmos@109_poly-right##29 9.871
R5435 Cin_to_XOR2___NAND4#27pmos@109_poly-right##29 Cin_to_XOR2___NAND4#27pmos@109_poly-right##30 9.871
R5436 Cin_to_XOR2___NAND4#27pmos@109_poly-right##30 Cin_to_XOR2___NAND4#27pmos@109_poly-right##31 9.871
R5437 Cin_to_XOR2___NAND4#27pmos@109_poly-right##31 Cin_to_XOR2___NAND4#27pmos@109_poly-right##32 9.871
R5438 Cin_to_XOR2___NAND4#27pmos@109_poly-right##32 Cin_to_XOR2___NAND4#27pmos@109_poly-right##33 9.871
R5439 Cin_to_XOR2___NAND4#27pmos@109_poly-right##33 Cin_to_XOR2___NAND4#27pmos@109_poly-right##34 9.871
R5440 Cin_to_XOR2___NAND4#27pmos@109_poly-right##34 Cin_to_XOR2___NAND4#27pmos@109_poly-right##35 9.871
R5441 Cin_to_XOR2___NAND4#27pmos@109_poly-right##35 Cin_to_XOR2___NAND4#27pmos@109_poly-right##36 9.871
R5442 Cin_to_XOR2___NAND4#27pmos@109_poly-right##36 Cin_to_XOR2___NAND4#27pmos@109_poly-right##37 9.871
R5443 Cin_to_XOR2___NAND4#27pmos@109_poly-right##37 Cin_to_XOR2___NAND4#27pmos@109_poly-right##38 9.871
R5444 Cin_to_XOR2___NAND4#27pmos@109_poly-right##38 Cin_to_XOR2___NAND4#27pmos@109_poly-right##39 9.871
R5445 Cin_to_XOR2___NAND4#27pmos@109_poly-right##39 Cin_to_XOR2___NAND4#27pmos@109_poly-right##40 9.871
R5446 Cin_to_XOR2___NAND4#27pmos@109_poly-right##40 Cin_to_XOR2___NAND4#27pmos@109_poly-right##41 9.871
R5447 Cin_to_XOR2___NAND4#27pmos@109_poly-right##41 Cin_to_XOR2___NAND4#27pmos@109_poly-right##42 9.871
R5448 Cin_to_XOR2___NAND4#27pmos@109_poly-right##42 Cin_to_XOR2___NAND4#27pmos@109_poly-right##43 9.871
R5449 Cin_to_XOR2___NAND4#27pmos@109_poly-right##43 Cin_to_XOR2___NAND4#27pmos@109_poly-right##44 9.871
R5450 Cin_to_XOR2___NAND4#27pmos@109_poly-right##44 Cin_to_XOR2___NAND4#27pmos@109_poly-right##45 9.871
R5451 Cin_to_XOR2___NAND4#27pmos@109_poly-right##45 Cin_to_XOR2___NAND4#27pmos@109_poly-right##46 9.871
R5452 Cin_to_XOR2___NAND4#27pmos@109_poly-right##46 Cin_to_XOR2___NAND4#27pmos@109_poly-right##47 9.871
R5453 Cin_to_XOR2___NAND4#27pmos@109_poly-right##47 Cin_to_XOR2___NAND4#27pmos@109_poly-right##48 9.871
R5454 Cin_to_XOR2___NAND4#27pmos@109_poly-right##48 Cin_to_XOR2___NAND4#27pmos@109_poly-right##49 9.871
R5455 Cin_to_XOR2___NAND4#27pmos@109_poly-right##49 Cin_to_XOR2___NAND4#27pmos@109_poly-right##50 9.871
R5456 Cin_to_XOR2___NAND4#27pmos@109_poly-right##50 Cin_to_XOR2___NAND4#27pmos@109_poly-right##51 9.871
R5457 Cin_to_XOR2___NAND4#27pmos@109_poly-right##51 Cin_to_XOR2___NAND4#27pmos@109_poly-right##52 9.871
R5458 Cin_to_XOR2___NAND4#27pmos@109_poly-right##52 Cin_to_XOR2___NAND4#27pmos@109_poly-right##53 9.871
R5459 Cin_to_XOR2___NAND4#27pmos@109_poly-right##53 Cin_to_XOR2___NAND4#27pmos@109_poly-right##54 9.871
R5460 Cin_to_XOR2___NAND4#27pmos@109_poly-right##54 Cin_to_XOR2___NAND4#27pmos@109_poly-right##55 9.871
R5461 Cin_to_XOR2___NAND4#27pmos@109_poly-right##55 Cin_to_XOR2___NAND4#18nmos@109_poly-left 9.871
R5462 net@2118#14pmos@110_poly-right net@2118#14pmos@110_poly-right##0 9.871
R5463 net@2118#14pmos@110_poly-right##0 net@2118#14pmos@110_poly-right##1 9.871
R5464 net@2118#14pmos@110_poly-right##1 net@2118#14pmos@110_poly-right##2 9.871
R5465 net@2118#14pmos@110_poly-right##2 net@2118#14pmos@110_poly-right##3 9.871
R5466 net@2118#14pmos@110_poly-right##3 net@2118#14pmos@110_poly-right##4 9.871
R5467 net@2118#14pmos@110_poly-right##4 net@2118#14pmos@110_poly-right##5 9.871
R5468 net@2118#14pmos@110_poly-right##5 net@2118#14pmos@110_poly-right##6 9.871
R5469 net@2118#14pmos@110_poly-right##6 net@2118#14pmos@110_poly-right##7 9.871
R5470 net@2118#14pmos@110_poly-right##7 net@2118#14pmos@110_poly-right##8 9.871
R5471 net@2118#14pmos@110_poly-right##8 net@2118#14pmos@110_poly-right##9 9.871
R5472 net@2118#14pmos@110_poly-right##9 net@2118#14pmos@110_poly-right##10 9.871
R5473 net@2118#14pmos@110_poly-right##10 net@2118#14pmos@110_poly-right##11 9.871
R5474 net@2118#14pmos@110_poly-right##11 net@2118#14pmos@110_poly-right##12 9.871
R5475 net@2118#14pmos@110_poly-right##12 net@2118#14pmos@110_poly-right##13 9.871
R5476 net@2118#14pmos@110_poly-right##13 net@2118#14pmos@110_poly-right##14 9.871
R5477 net@2118#14pmos@110_poly-right##14 net@2118#14pmos@110_poly-right##15 9.871
R5478 net@2118#14pmos@110_poly-right##15 net@2118#14pmos@110_poly-right##16 9.871
R5479 net@2118#14pmos@110_poly-right##16 net@2118#14pmos@110_poly-right##17 9.871
R5480 net@2118#14pmos@110_poly-right##17 net@2118#14pmos@110_poly-right##18 9.871
R5481 net@2118#14pmos@110_poly-right##18 net@2118#14pmos@110_poly-right##19 9.871
R5482 net@2118#14pmos@110_poly-right##19 net@2118#14pmos@110_poly-right##20 9.871
R5483 net@2118#14pmos@110_poly-right##20 net@2118#14pmos@110_poly-right##21 9.871
R5484 net@2118#14pmos@110_poly-right##21 net@2118#14pmos@110_poly-right##22 9.871
R5485 net@2118#14pmos@110_poly-right##22 net@2118#14pmos@110_poly-right##23 9.871
R5486 net@2118#14pmos@110_poly-right##23 net@2118#14pmos@110_poly-right##24 9.871
R5487 net@2118#14pmos@110_poly-right##24 net@2118#14pmos@110_poly-right##25 9.871
R5488 net@2118#14pmos@110_poly-right##25 net@2118#14pmos@110_poly-right##26 9.871
R5489 net@2118#14pmos@110_poly-right##26 net@2118#14pmos@110_poly-right##27 9.871
R5490 net@2118#14pmos@110_poly-right##27 net@2118#14pmos@110_poly-right##28 9.871
R5491 net@2118#14pmos@110_poly-right##28 net@2118#14pmos@110_poly-right##29 9.871
R5492 net@2118#14pmos@110_poly-right##29 net@2118#14pmos@110_poly-right##30 9.871
R5493 net@2118#14pmos@110_poly-right##30 net@2118#14pmos@110_poly-right##31 9.871
R5494 net@2118#14pmos@110_poly-right##31 net@2118#14pmos@110_poly-right##32 9.871
R5495 net@2118#14pmos@110_poly-right##32 net@2118#14pmos@110_poly-right##33 9.871
R5496 net@2118#14pmos@110_poly-right##33 net@2118#14pmos@110_poly-right##34 9.871
R5497 net@2118#14pmos@110_poly-right##34 net@2118#14pmos@110_poly-right##35 9.871
R5498 net@2118#14pmos@110_poly-right##35 net@2118#14pmos@110_poly-right##36 9.871
R5499 net@2118#14pmos@110_poly-right##36 net@2118#14pmos@110_poly-right##37 9.871
R5500 net@2118#14pmos@110_poly-right##37 net@2118#14pmos@110_poly-right##38 9.871
R5501 net@2118#14pmos@110_poly-right##38 net@2118#14pmos@110_poly-right##39 9.871
R5502 net@2118#14pmos@110_poly-right##39 net@2118#14pmos@110_poly-right##40 9.871
R5503 net@2118#14pmos@110_poly-right##40 net@2118#14pmos@110_poly-right##41 9.871
R5504 net@2118#14pmos@110_poly-right##41 net@2118#14pmos@110_poly-right##42 9.871
R5505 net@2118#14pmos@110_poly-right##42 net@2118#14pmos@110_poly-right##43 9.871
R5506 net@2118#14pmos@110_poly-right##43 net@2118#14pmos@110_poly-right##44 9.871
R5507 net@2118#14pmos@110_poly-right##44 net@2118#14pmos@110_poly-right##45 9.871
R5508 net@2118#14pmos@110_poly-right##45 net@2118#14pmos@110_poly-right##46 9.871
R5509 net@2118#14pmos@110_poly-right##46 net@2118#14pmos@110_poly-right##47 9.871
R5510 net@2118#14pmos@110_poly-right##47 net@2118#14pmos@110_poly-right##48 9.871
R5511 net@2118#14pmos@110_poly-right##48 net@2118#14pmos@110_poly-right##49 9.871
R5512 net@2118#14pmos@110_poly-right##49 net@2118#14pmos@110_poly-right##50 9.871
R5513 net@2118#14pmos@110_poly-right##50 net@2118#14pmos@110_poly-right##51 9.871
R5514 net@2118#14pmos@110_poly-right##51 net@2118#14pmos@110_poly-right##52 9.871
R5515 net@2118#14pmos@110_poly-right##52 net@2118#14pmos@110_poly-right##53 9.871
R5516 net@2118#14pmos@110_poly-right##53 net@2118#14pmos@110_poly-right##54 9.871
R5517 net@2118#14pmos@110_poly-right##54 net@2118#14pmos@110_poly-right##55 9.871
R5518 net@2118#14pmos@110_poly-right##55 net@2118#9nmos@110_poly-left 9.871
R5519 net@2117#2contact@752_metal-1-polysilicon-1 net@2117 4.654
R5520 net@2117#12pmos@113_poly-right net@2117#12pmos@113_poly-right##0 9.931
R5521 net@2117#12pmos@113_poly-right##0 net@2117#12pmos@113_poly-right##1 9.931
R5522 net@2117#12pmos@113_poly-right##1 net@2117#12pmos@113_poly-right##2 9.931
R5523 net@2117#12pmos@113_poly-right##2 net@2117#12pmos@113_poly-right##3 9.931
R5524 net@2117#12pmos@113_poly-right##3 net@2117#12pmos@113_poly-right##4 9.931
R5525 net@2117#12pmos@113_poly-right##4 net@2117#12pmos@113_poly-right##5 9.931
R5526 net@2117#12pmos@113_poly-right##5 net@2117#12pmos@113_poly-right##6 9.931
R5527 net@2117#12pmos@113_poly-right##6 net@2117#12pmos@113_poly-right##7 9.931
R5528 net@2117#12pmos@113_poly-right##7 net@2117#12pmos@113_poly-right##8 9.931
R5529 net@2117#12pmos@113_poly-right##8 net@2117#12pmos@113_poly-right##9 9.931
R5530 net@2117#12pmos@113_poly-right##9 net@2117#12pmos@113_poly-right##10 9.931
R5531 net@2117#12pmos@113_poly-right##10 net@2117#12pmos@113_poly-right##11 9.931
R5532 net@2117#12pmos@113_poly-right##11 net@2117#12pmos@113_poly-right##12 9.931
R5533 net@2117#12pmos@113_poly-right##12 net@2117#12pmos@113_poly-right##13 9.931
R5534 net@2117#12pmos@113_poly-right##13 net@2117#12pmos@113_poly-right##14 9.931
R5535 net@2117#12pmos@113_poly-right##14 net@2117#12pmos@113_poly-right##15 9.931
R5536 net@2117#12pmos@113_poly-right##15 net@2117#12pmos@113_poly-right##16 9.931
R5537 net@2117#12pmos@113_poly-right##16 net@2117#12pmos@113_poly-right##17 9.931
R5538 net@2117#12pmos@113_poly-right##17 net@2117#12pmos@113_poly-right##18 9.931
R5539 net@2117#12pmos@113_poly-right##18 net@2117#12pmos@113_poly-right##19 9.931
R5540 net@2117#12pmos@113_poly-right##19 net@2117#12pmos@113_poly-right##20 9.931
R5541 net@2117#12pmos@113_poly-right##20 net@2117#12pmos@113_poly-right##21 9.931
R5542 net@2117#12pmos@113_poly-right##21 net@2117#12pmos@113_poly-right##22 9.931
R5543 net@2117#12pmos@113_poly-right##22 net@2117#12pmos@113_poly-right##23 9.931
R5544 net@2117#12pmos@113_poly-right##23 net@2117#12pmos@113_poly-right##24 9.931
R5545 net@2117#12pmos@113_poly-right##24 net@2117#12pmos@113_poly-right##25 9.931
R5546 net@2117#12pmos@113_poly-right##25 net@2117#12pmos@113_poly-right##26 9.931
R5547 net@2117#12pmos@113_poly-right##26 net@2117#12pmos@113_poly-right##27 9.931
R5548 net@2117#12pmos@113_poly-right##27 net@2117#12pmos@113_poly-right##28 9.931
R5549 net@2117#12pmos@113_poly-right##28 net@2117#12pmos@113_poly-right##29 9.931
R5550 net@2117#12pmos@113_poly-right##29 net@2117#12pmos@113_poly-right##30 9.931
R5551 net@2117#12pmos@113_poly-right##30 net@2117#12pmos@113_poly-right##31 9.931
R5552 net@2117#12pmos@113_poly-right##31 net@2117#12pmos@113_poly-right##32 9.931
R5553 net@2117#12pmos@113_poly-right##32 net@2117#12pmos@113_poly-right##33 9.931
R5554 net@2117#12pmos@113_poly-right##33 net@2117#12pmos@113_poly-right##34 9.931
R5555 net@2117#12pmos@113_poly-right##34 net@2117#12pmos@113_poly-right##35 9.931
R5556 net@2117#12pmos@113_poly-right##35 net@2117#12pmos@113_poly-right##36 9.931
R5557 net@2117#12pmos@113_poly-right##36 net@2117#12pmos@113_poly-right##37 9.931
R5558 net@2117#12pmos@113_poly-right##37 net@2117#12pmos@113_poly-right##38 9.931
R5559 net@2117#12pmos@113_poly-right##38 net@2117#12pmos@113_poly-right##39 9.931
R5560 net@2117#12pmos@113_poly-right##39 net@2117#12pmos@113_poly-right##40 9.931
R5561 net@2117#12pmos@113_poly-right##40 net@2117#12pmos@113_poly-right##41 9.931
R5562 net@2117#12pmos@113_poly-right##41 net@2117#12pmos@113_poly-right##42 9.931
R5563 net@2117#12pmos@113_poly-right##42 net@2117#12pmos@113_poly-right##43 9.931
R5564 net@2117#12pmos@113_poly-right##43 net@2117#12pmos@113_poly-right##44 9.931
R5565 net@2117#12pmos@113_poly-right##44 net@2117#12pmos@113_poly-right##45 9.931
R5566 net@2117#12pmos@113_poly-right##45 net@2117#12pmos@113_poly-right##46 9.931
R5567 net@2117#12pmos@113_poly-right##46 net@2117#12pmos@113_poly-right##47 9.931
R5568 net@2117#12pmos@113_poly-right##47 net@2117#12pmos@113_poly-right##48 9.931
R5569 net@2117#12pmos@113_poly-right##48 net@2117#12pmos@113_poly-right##49 9.931
R5570 net@2117#12pmos@113_poly-right##49 net@2117#12pmos@113_poly-right##50 9.931
R5571 net@2117#12pmos@113_poly-right##50 net@2117#12pmos@113_poly-right##51 9.931
R5572 net@2117#12pmos@113_poly-right##51 net@2117#12pmos@113_poly-right##52 9.931
R5573 net@2117#12pmos@113_poly-right##52 net@2117#5pin@659_polysilicon-1 9.931
R5574 Sum3#4pmos@113_diff-top Sum3 4.823
R5575 XOR1_to_NAND4#14pin@671_polysilicon-1 XOR1_to_NAND4#14pin@671_polysilicon-1##0 9.854
R5576 XOR1_to_NAND4#14pin@671_polysilicon-1##0 XOR1_to_NAND4#14pin@671_polysilicon-1##1 9.854
R5577 XOR1_to_NAND4#14pin@671_polysilicon-1##1 XOR1_to_NAND4#14pin@671_polysilicon-1##2 9.854
R5578 XOR1_to_NAND4#14pin@671_polysilicon-1##2 XOR1_to_NAND4#14pin@671_polysilicon-1##3 9.854
R5579 XOR1_to_NAND4#14pin@671_polysilicon-1##3 XOR1_to_NAND4#14pin@671_polysilicon-1##4 9.854
R5580 XOR1_to_NAND4#14pin@671_polysilicon-1##4 XOR1_to_NAND4#14pin@671_polysilicon-1##5 9.854
R5581 XOR1_to_NAND4#14pin@671_polysilicon-1##5 XOR1_to_NAND4#14pin@671_polysilicon-1##6 9.854
R5582 XOR1_to_NAND4#14pin@671_polysilicon-1##6 XOR1_to_NAND4#14pin@671_polysilicon-1##7 9.854
R5583 XOR1_to_NAND4#14pin@671_polysilicon-1##7 XOR1_to_NAND4#14pin@671_polysilicon-1##8 9.854
R5584 XOR1_to_NAND4#14pin@671_polysilicon-1##8 XOR1_to_NAND4#14pin@671_polysilicon-1##9 9.854
R5585 XOR1_to_NAND4#14pin@671_polysilicon-1##9 XOR1_to_NAND4#14pin@671_polysilicon-1##10 9.854
R5586 XOR1_to_NAND4#14pin@671_polysilicon-1##10 XOR1_to_NAND4#14pin@671_polysilicon-1##11 9.854
R5587 XOR1_to_NAND4#14pin@671_polysilicon-1##11 XOR1_to_NAND4#14pin@671_polysilicon-1##12 9.854
R5588 XOR1_to_NAND4#14pin@671_polysilicon-1##12 XOR1_to_NAND4#14pin@671_polysilicon-1##13 9.854
R5589 XOR1_to_NAND4#14pin@671_polysilicon-1##13 XOR1_to_NAND4#14pin@671_polysilicon-1##14 9.854
R5590 XOR1_to_NAND4#14pin@671_polysilicon-1##14 XOR1_to_NAND4#14pin@671_polysilicon-1##15 9.854
R5591 XOR1_to_NAND4#14pin@671_polysilicon-1##15 XOR1_to_NAND4#14pin@671_polysilicon-1##16 9.854
R5592 XOR1_to_NAND4#14pin@671_polysilicon-1##16 XOR1_to_NAND4#14pin@671_polysilicon-1##17 9.854
R5593 XOR1_to_NAND4#14pin@671_polysilicon-1##17 XOR1_to_NAND4#14pin@671_polysilicon-1##18 9.854
R5594 XOR1_to_NAND4#14pin@671_polysilicon-1##18 XOR1_to_NAND4#14pin@671_polysilicon-1##19 9.854
R5595 XOR1_to_NAND4#14pin@671_polysilicon-1##19 XOR1_to_NAND4#14pin@671_polysilicon-1##20 9.854
R5596 XOR1_to_NAND4#14pin@671_polysilicon-1##20 XOR1_to_NAND4#14pin@671_polysilicon-1##21 9.854
R5597 XOR1_to_NAND4#14pin@671_polysilicon-1##21 XOR1_to_NAND4#14pin@671_polysilicon-1##22 9.854
R5598 XOR1_to_NAND4#14pin@671_polysilicon-1##22 XOR1_to_NAND4#14pin@671_polysilicon-1##23 9.854
R5599 XOR1_to_NAND4#14pin@671_polysilicon-1##23 XOR1_to_NAND4#14pin@671_polysilicon-1##24 9.854
R5600 XOR1_to_NAND4#14pin@671_polysilicon-1##24 XOR1_to_NAND4#14pin@671_polysilicon-1##25 9.854
R5601 XOR1_to_NAND4#14pin@671_polysilicon-1##25 XOR1_to_NAND4#14pin@671_polysilicon-1##26 9.854
R5602 XOR1_to_NAND4#14pin@671_polysilicon-1##26 XOR1_to_NAND4#14pin@671_polysilicon-1##27 9.854
R5603 XOR1_to_NAND4#14pin@671_polysilicon-1##27 XOR1_to_NAND4#14pin@671_polysilicon-1##28 9.854
R5604 XOR1_to_NAND4#14pin@671_polysilicon-1##28 XOR1_to_NAND4#14pin@671_polysilicon-1##29 9.854
R5605 XOR1_to_NAND4#14pin@671_polysilicon-1##29 XOR1_to_NAND4#14pin@671_polysilicon-1##30 9.854
R5606 XOR1_to_NAND4#14pin@671_polysilicon-1##30 XOR1_to_NAND4#14pin@671_polysilicon-1##31 9.854
R5607 XOR1_to_NAND4#14pin@671_polysilicon-1##31 XOR1_to_NAND4#14pin@671_polysilicon-1##32 9.854
R5608 XOR1_to_NAND4#14pin@671_polysilicon-1##32 XOR1_to_NAND4#14pin@671_polysilicon-1##33 9.854
R5609 XOR1_to_NAND4#14pin@671_polysilicon-1##33 XOR1_to_NAND4#14pin@671_polysilicon-1##34 9.854
R5610 XOR1_to_NAND4#14pin@671_polysilicon-1##34 XOR1_to_NAND4#14pin@671_polysilicon-1##35 9.854
R5611 XOR1_to_NAND4#14pin@671_polysilicon-1##35 XOR1_to_NAND4#14pin@671_polysilicon-1##36 9.854
R5612 XOR1_to_NAND4#14pin@671_polysilicon-1##36 XOR1_to_NAND4#14pin@671_polysilicon-1##37 9.854
R5613 XOR1_to_NAND4#14pin@671_polysilicon-1##37 XOR1_to_NAND4#14pin@671_polysilicon-1##38 9.854
R5614 XOR1_to_NAND4#14pin@671_polysilicon-1##38 XOR1_to_NAND4#14pin@671_polysilicon-1##39 9.854
R5615 XOR1_to_NAND4#14pin@671_polysilicon-1##39 XOR1_to_NAND4#14pin@671_polysilicon-1##40 9.854
R5616 XOR1_to_NAND4#14pin@671_polysilicon-1##40 XOR1_to_NAND4#14pin@671_polysilicon-1##41 9.854
R5617 XOR1_to_NAND4#14pin@671_polysilicon-1##41 XOR1_to_NAND4#14pin@671_polysilicon-1##42 9.854
R5618 XOR1_to_NAND4#14pin@671_polysilicon-1##42 XOR1_to_NAND4#14pin@671_polysilicon-1##43 9.854
R5619 XOR1_to_NAND4#14pin@671_polysilicon-1##43 XOR1_to_NAND4#14pin@671_polysilicon-1##44 9.854
R5620 XOR1_to_NAND4#14pin@671_polysilicon-1##44 XOR1_to_NAND4#14pin@671_polysilicon-1##45 9.854
R5621 XOR1_to_NAND4#14pin@671_polysilicon-1##45 XOR1_to_NAND4#14pin@671_polysilicon-1##46 9.854
R5622 XOR1_to_NAND4#14pin@671_polysilicon-1##46 XOR1_to_NAND4#14pin@671_polysilicon-1##47 9.854
R5623 XOR1_to_NAND4#14pin@671_polysilicon-1##47 XOR1_to_NAND4#14pin@671_polysilicon-1##48 9.854
R5624 XOR1_to_NAND4#14pin@671_polysilicon-1##48 XOR1_to_NAND4#14pin@671_polysilicon-1##49 9.854
R5625 XOR1_to_NAND4#14pin@671_polysilicon-1##49 XOR1_to_NAND4#14pin@671_polysilicon-1##50 9.854
R5626 XOR1_to_NAND4#14pin@671_polysilicon-1##50 XOR1_to_NAND4#14pin@671_polysilicon-1##51 9.854
R5627 XOR1_to_NAND4#14pin@671_polysilicon-1##51 XOR1_to_NAND4#14pin@671_polysilicon-1##52 9.854
R5628 XOR1_to_NAND4#14pin@671_polysilicon-1##52 XOR1_to_NAND4#14pin@671_polysilicon-1##53 9.854
R5629 XOR1_to_NAND4#14pin@671_polysilicon-1##53 XOR1_to_NAND4#14pin@671_polysilicon-1##54 9.854
R5630 XOR1_to_NAND4#14pin@671_polysilicon-1##54 XOR1_to_NAND4#27nmos@114_poly-right 9.854
R5631 Cin_to_XOR2___NAND4#29pmos@115_poly-right Cin_to_XOR2___NAND4#29pmos@115_poly-right##0 9.877
R5632 Cin_to_XOR2___NAND4#29pmos@115_poly-right##0 Cin_to_XOR2___NAND4#29pmos@115_poly-right##1 9.877
R5633 Cin_to_XOR2___NAND4#29pmos@115_poly-right##1 Cin_to_XOR2___NAND4#29pmos@115_poly-right##2 9.877
R5634 Cin_to_XOR2___NAND4#29pmos@115_poly-right##2 Cin_to_XOR2___NAND4#29pmos@115_poly-right##3 9.877
R5635 Cin_to_XOR2___NAND4#29pmos@115_poly-right##3 Cin_to_XOR2___NAND4#29pmos@115_poly-right##4 9.877
R5636 Cin_to_XOR2___NAND4#29pmos@115_poly-right##4 Cin_to_XOR2___NAND4#29pmos@115_poly-right##5 9.877
R5637 Cin_to_XOR2___NAND4#29pmos@115_poly-right##5 Cin_to_XOR2___NAND4#29pmos@115_poly-right##6 9.877
R5638 Cin_to_XOR2___NAND4#29pmos@115_poly-right##6 Cin_to_XOR2___NAND4#29pmos@115_poly-right##7 9.877
R5639 Cin_to_XOR2___NAND4#29pmos@115_poly-right##7 Cin_to_XOR2___NAND4#29pmos@115_poly-right##8 9.877
R5640 Cin_to_XOR2___NAND4#29pmos@115_poly-right##8 Cin_to_XOR2___NAND4#29pmos@115_poly-right##9 9.877
R5641 Cin_to_XOR2___NAND4#29pmos@115_poly-right##9 Cin_to_XOR2___NAND4#29pmos@115_poly-right##10 9.877
R5642 Cin_to_XOR2___NAND4#29pmos@115_poly-right##10 Cin_to_XOR2___NAND4#29pmos@115_poly-right##11 9.877
R5643 Cin_to_XOR2___NAND4#29pmos@115_poly-right##11 Cin_to_XOR2___NAND4#29pmos@115_poly-right##12 9.877
R5644 Cin_to_XOR2___NAND4#29pmos@115_poly-right##12 Cin_to_XOR2___NAND4#29pmos@115_poly-right##13 9.877
R5645 Cin_to_XOR2___NAND4#29pmos@115_poly-right##13 Cin_to_XOR2___NAND4#29pmos@115_poly-right##14 9.877
R5646 Cin_to_XOR2___NAND4#29pmos@115_poly-right##14 Cin_to_XOR2___NAND4#29pmos@115_poly-right##15 9.877
R5647 Cin_to_XOR2___NAND4#29pmos@115_poly-right##15 Cin_to_XOR2___NAND4#29pmos@115_poly-right##16 9.877
R5648 Cin_to_XOR2___NAND4#29pmos@115_poly-right##16 Cin_to_XOR2___NAND4#29pmos@115_poly-right##17 9.877
R5649 Cin_to_XOR2___NAND4#29pmos@115_poly-right##17 Cin_to_XOR2___NAND4#29pmos@115_poly-right##18 9.877
R5650 Cin_to_XOR2___NAND4#29pmos@115_poly-right##18 Cin_to_XOR2___NAND4#29pmos@115_poly-right##19 9.877
R5651 Cin_to_XOR2___NAND4#29pmos@115_poly-right##19 Cin_to_XOR2___NAND4#29pmos@115_poly-right##20 9.877
R5652 Cin_to_XOR2___NAND4#29pmos@115_poly-right##20 Cin_to_XOR2___NAND4#29pmos@115_poly-right##21 9.877
R5653 Cin_to_XOR2___NAND4#29pmos@115_poly-right##21 Cin_to_XOR2___NAND4#29pmos@115_poly-right##22 9.877
R5654 Cin_to_XOR2___NAND4#29pmos@115_poly-right##22 Cin_to_XOR2___NAND4#29pmos@115_poly-right##23 9.877
R5655 Cin_to_XOR2___NAND4#29pmos@115_poly-right##23 Cin_to_XOR2___NAND4#29pmos@115_poly-right##24 9.877
R5656 Cin_to_XOR2___NAND4#29pmos@115_poly-right##24 Cin_to_XOR2___NAND4#29pmos@115_poly-right##25 9.877
R5657 Cin_to_XOR2___NAND4#29pmos@115_poly-right##25 Cin_to_XOR2___NAND4#29pmos@115_poly-right##26 9.877
R5658 Cin_to_XOR2___NAND4#29pmos@115_poly-right##26 Cin_to_XOR2___NAND4#29pmos@115_poly-right##27 9.877
R5659 Cin_to_XOR2___NAND4#29pmos@115_poly-right##27 Cin_to_XOR2___NAND4#29pmos@115_poly-right##28 9.877
R5660 Cin_to_XOR2___NAND4#29pmos@115_poly-right##28 Cin_to_XOR2___NAND4#29pmos@115_poly-right##29 9.877
R5661 Cin_to_XOR2___NAND4#29pmos@115_poly-right##29 Cin_to_XOR2___NAND4#29pmos@115_poly-right##30 9.877
R5662 Cin_to_XOR2___NAND4#29pmos@115_poly-right##30 Cin_to_XOR2___NAND4#29pmos@115_poly-right##31 9.877
R5663 Cin_to_XOR2___NAND4#29pmos@115_poly-right##31 Cin_to_XOR2___NAND4#29pmos@115_poly-right##32 9.877
R5664 Cin_to_XOR2___NAND4#29pmos@115_poly-right##32 Cin_to_XOR2___NAND4#29pmos@115_poly-right##33 9.877
R5665 Cin_to_XOR2___NAND4#29pmos@115_poly-right##33 Cin_to_XOR2___NAND4#29pmos@115_poly-right##34 9.877
R5666 Cin_to_XOR2___NAND4#29pmos@115_poly-right##34 Cin_to_XOR2___NAND4#29pmos@115_poly-right##35 9.877
R5667 Cin_to_XOR2___NAND4#29pmos@115_poly-right##35 Cin_to_XOR2___NAND4#29pmos@115_poly-right##36 9.877
R5668 Cin_to_XOR2___NAND4#29pmos@115_poly-right##36 Cin_to_XOR2___NAND4#29pmos@115_poly-right##37 9.877
R5669 Cin_to_XOR2___NAND4#29pmos@115_poly-right##37 Cin_to_XOR2___NAND4#29pmos@115_poly-right##38 9.877
R5670 Cin_to_XOR2___NAND4#29pmos@115_poly-right##38 Cin_to_XOR2___NAND4#29pmos@115_poly-right##39 9.877
R5671 Cin_to_XOR2___NAND4#29pmos@115_poly-right##39 Cin_to_XOR2___NAND4#29pmos@115_poly-right##40 9.877
R5672 Cin_to_XOR2___NAND4#29pmos@115_poly-right##40 Cin_to_XOR2___NAND4#29pmos@115_poly-right##41 9.877
R5673 Cin_to_XOR2___NAND4#29pmos@115_poly-right##41 Cin_to_XOR2___NAND4#29pmos@115_poly-right##42 9.877
R5674 Cin_to_XOR2___NAND4#29pmos@115_poly-right##42 Cin_to_XOR2___NAND4#29pmos@115_poly-right##43 9.877
R5675 Cin_to_XOR2___NAND4#29pmos@115_poly-right##43 Cin_to_XOR2___NAND4#29pmos@115_poly-right##44 9.877
R5676 Cin_to_XOR2___NAND4#29pmos@115_poly-right##44 Cin_to_XOR2___NAND4#29pmos@115_poly-right##45 9.877
R5677 Cin_to_XOR2___NAND4#29pmos@115_poly-right##45 Cin_to_XOR2___NAND4#29pmos@115_poly-right##46 9.877
R5678 Cin_to_XOR2___NAND4#29pmos@115_poly-right##46 Cin_to_XOR2___NAND4#29pmos@115_poly-right##47 9.877
R5679 Cin_to_XOR2___NAND4#29pmos@115_poly-right##47 Cin_to_XOR2___NAND4#29pmos@115_poly-right##48 9.877
R5680 Cin_to_XOR2___NAND4#29pmos@115_poly-right##48 Cin_to_XOR2___NAND4#29pmos@115_poly-right##49 9.877
R5681 Cin_to_XOR2___NAND4#29pmos@115_poly-right##49 Cin_to_XOR2___NAND4#23pin@675_polysilicon-1 9.877
R5682 NAND1_to_NAND6 NAND1_to_NAND6#4nmos@115_diff-bottom 4.823
R5683 A3#10pin@678_polysilicon-1 A3#10pin@678_polysilicon-1##0 9.938
R5684 A3#10pin@678_polysilicon-1##0 A3#10pin@678_polysilicon-1##1 9.938
R5685 A3#10pin@678_polysilicon-1##1 A3#10pin@678_polysilicon-1##2 9.938
R5686 A3#10pin@678_polysilicon-1##2 A3#10pin@678_polysilicon-1##3 9.938
R5687 A3#10pin@678_polysilicon-1##3 A3#10pin@678_polysilicon-1##4 9.938
R5688 A3#10pin@678_polysilicon-1##4 A3#10pin@678_polysilicon-1##5 9.938
R5689 A3#10pin@678_polysilicon-1##5 A3#10pin@678_polysilicon-1##6 9.938
R5690 A3#10pin@678_polysilicon-1##6 A3#10pin@678_polysilicon-1##7 9.938
R5691 A3#10pin@678_polysilicon-1##7 A3#10pin@678_polysilicon-1##8 9.938
R5692 A3#10pin@678_polysilicon-1##8 A3#10pin@678_polysilicon-1##9 9.938
R5693 A3#10pin@678_polysilicon-1##9 A3#10pin@678_polysilicon-1##10 9.938
R5694 A3#10pin@678_polysilicon-1##10 A3#10pin@678_polysilicon-1##11 9.938
R5695 A3#10pin@678_polysilicon-1##11 A3#10pin@678_polysilicon-1##12 9.938
R5696 A3#10pin@678_polysilicon-1##12 A3#10pin@678_polysilicon-1##13 9.938
R5697 A3#10pin@678_polysilicon-1##13 A3#10pin@678_polysilicon-1##14 9.938
R5698 A3#10pin@678_polysilicon-1##14 A3#10pin@678_polysilicon-1##15 9.938
R5699 A3#10pin@678_polysilicon-1##15 A3#10pin@678_polysilicon-1##16 9.938
R5700 A3#10pin@678_polysilicon-1##16 A3#10pin@678_polysilicon-1##17 9.938
R5701 A3#10pin@678_polysilicon-1##17 A3#10pin@678_polysilicon-1##18 9.938
R5702 A3#10pin@678_polysilicon-1##18 A3#10pin@678_polysilicon-1##19 9.938
R5703 A3#10pin@678_polysilicon-1##19 A3#10pin@678_polysilicon-1##20 9.938
R5704 A3#10pin@678_polysilicon-1##20 A3#10pin@678_polysilicon-1##21 9.938
R5705 A3#10pin@678_polysilicon-1##21 A3#10pin@678_polysilicon-1##22 9.938
R5706 A3#10pin@678_polysilicon-1##22 A3#10pin@678_polysilicon-1##23 9.938
R5707 A3#10pin@678_polysilicon-1##23 A3#10pin@678_polysilicon-1##24 9.938
R5708 A3#10pin@678_polysilicon-1##24 A3#10pin@678_polysilicon-1##25 9.938
R5709 A3#10pin@678_polysilicon-1##25 A3#10pin@678_polysilicon-1##26 9.938
R5710 A3#10pin@678_polysilicon-1##26 A3#10pin@678_polysilicon-1##27 9.938
R5711 A3#10pin@678_polysilicon-1##27 A3#10pin@678_polysilicon-1##28 9.938
R5712 A3#10pin@678_polysilicon-1##28 A3#10pin@678_polysilicon-1##29 9.938
R5713 A3#10pin@678_polysilicon-1##29 A3#10pin@678_polysilicon-1##30 9.938
R5714 A3#10pin@678_polysilicon-1##30 A3#10pin@678_polysilicon-1##31 9.938
R5715 A3#10pin@678_polysilicon-1##31 A3#10pin@678_polysilicon-1##32 9.938
R5716 A3#10pin@678_polysilicon-1##32 A3#10pin@678_polysilicon-1##33 9.938
R5717 A3#10pin@678_polysilicon-1##33 A3#10pin@678_polysilicon-1##34 9.938
R5718 A3#10pin@678_polysilicon-1##34 A3#10pin@678_polysilicon-1##35 9.938
R5719 A3#10pin@678_polysilicon-1##35 A3#10pin@678_polysilicon-1##36 9.938
R5720 A3#10pin@678_polysilicon-1##36 A3#10pin@678_polysilicon-1##37 9.938
R5721 A3#10pin@678_polysilicon-1##37 A3#10pin@678_polysilicon-1##38 9.938
R5722 A3#10pin@678_polysilicon-1##38 A3#10pin@678_polysilicon-1##39 9.938
R5723 A3#10pin@678_polysilicon-1##39 A3#10pin@678_polysilicon-1##40 9.938
R5724 A3#10pin@678_polysilicon-1##40 A3#10pin@678_polysilicon-1##41 9.938
R5725 A3#10pin@678_polysilicon-1##41 A3#10pin@678_polysilicon-1##42 9.938
R5726 A3#10pin@678_polysilicon-1##42 A3#10pin@678_polysilicon-1##43 9.938
R5727 A3#10pin@678_polysilicon-1##43 A3#10pin@678_polysilicon-1##44 9.938
R5728 A3#10pin@678_polysilicon-1##44 A3#10pin@678_polysilicon-1##45 9.938
R5729 A3#10pin@678_polysilicon-1##45 A3#10pin@678_polysilicon-1##46 9.938
R5730 A3#10pin@678_polysilicon-1##46 A3#10pin@678_polysilicon-1##47 9.938
R5731 A3#10pin@678_polysilicon-1##47 A3#10pin@678_polysilicon-1##48 9.938
R5732 A3#10pin@678_polysilicon-1##48 A3#10pin@678_polysilicon-1##49 9.938
R5733 A3#10pin@678_polysilicon-1##49 A3#19nmos@116_poly-right 9.938
R5734 B3#20pmos@117_poly-right B3#20pmos@117_poly-right##0 9.869
R5735 B3#20pmos@117_poly-right##0 B3#20pmos@117_poly-right##1 9.869
R5736 B3#20pmos@117_poly-right##1 B3#20pmos@117_poly-right##2 9.869
R5737 B3#20pmos@117_poly-right##2 B3#20pmos@117_poly-right##3 9.869
R5738 B3#20pmos@117_poly-right##3 B3#20pmos@117_poly-right##4 9.869
R5739 B3#20pmos@117_poly-right##4 B3#20pmos@117_poly-right##5 9.869
R5740 B3#20pmos@117_poly-right##5 B3#20pmos@117_poly-right##6 9.869
R5741 B3#20pmos@117_poly-right##6 B3#20pmos@117_poly-right##7 9.869
R5742 B3#20pmos@117_poly-right##7 B3#20pmos@117_poly-right##8 9.869
R5743 B3#20pmos@117_poly-right##8 B3#20pmos@117_poly-right##9 9.869
R5744 B3#20pmos@117_poly-right##9 B3#20pmos@117_poly-right##10 9.869
R5745 B3#20pmos@117_poly-right##10 B3#20pmos@117_poly-right##11 9.869
R5746 B3#20pmos@117_poly-right##11 B3#20pmos@117_poly-right##12 9.869
R5747 B3#20pmos@117_poly-right##12 B3#20pmos@117_poly-right##13 9.869
R5748 B3#20pmos@117_poly-right##13 B3#20pmos@117_poly-right##14 9.869
R5749 B3#20pmos@117_poly-right##14 B3#20pmos@117_poly-right##15 9.869
R5750 B3#20pmos@117_poly-right##15 B3#20pmos@117_poly-right##16 9.869
R5751 B3#20pmos@117_poly-right##16 B3#20pmos@117_poly-right##17 9.869
R5752 B3#20pmos@117_poly-right##17 B3#20pmos@117_poly-right##18 9.869
R5753 B3#20pmos@117_poly-right##18 B3#20pmos@117_poly-right##19 9.869
R5754 B3#20pmos@117_poly-right##19 B3#20pmos@117_poly-right##20 9.869
R5755 B3#20pmos@117_poly-right##20 B3#20pmos@117_poly-right##21 9.869
R5756 B3#20pmos@117_poly-right##21 B3#20pmos@117_poly-right##22 9.869
R5757 B3#20pmos@117_poly-right##22 B3#20pmos@117_poly-right##23 9.869
R5758 B3#20pmos@117_poly-right##23 B3#20pmos@117_poly-right##24 9.869
R5759 B3#20pmos@117_poly-right##24 B3#20pmos@117_poly-right##25 9.869
R5760 B3#20pmos@117_poly-right##25 B3#20pmos@117_poly-right##26 9.869
R5761 B3#20pmos@117_poly-right##26 B3#20pmos@117_poly-right##27 9.869
R5762 B3#20pmos@117_poly-right##27 B3#20pmos@117_poly-right##28 9.869
R5763 B3#20pmos@117_poly-right##28 B3#20pmos@117_poly-right##29 9.869
R5764 B3#20pmos@117_poly-right##29 B3#20pmos@117_poly-right##30 9.869
R5765 B3#20pmos@117_poly-right##30 B3#20pmos@117_poly-right##31 9.869
R5766 B3#20pmos@117_poly-right##31 B3#20pmos@117_poly-right##32 9.869
R5767 B3#20pmos@117_poly-right##32 B3#20pmos@117_poly-right##33 9.869
R5768 B3#20pmos@117_poly-right##33 B3#20pmos@117_poly-right##34 9.869
R5769 B3#20pmos@117_poly-right##34 B3#20pmos@117_poly-right##35 9.869
R5770 B3#20pmos@117_poly-right##35 B3#20pmos@117_poly-right##36 9.869
R5771 B3#20pmos@117_poly-right##36 B3#20pmos@117_poly-right##37 9.869
R5772 B3#20pmos@117_poly-right##37 B3#20pmos@117_poly-right##38 9.869
R5773 B3#20pmos@117_poly-right##38 B3#20pmos@117_poly-right##39 9.869
R5774 B3#20pmos@117_poly-right##39 B3#20pmos@117_poly-right##40 9.869
R5775 B3#20pmos@117_poly-right##40 B3#20pmos@117_poly-right##41 9.869
R5776 B3#20pmos@117_poly-right##41 B3#20pmos@117_poly-right##42 9.869
R5777 B3#20pmos@117_poly-right##42 B3#20pmos@117_poly-right##43 9.869
R5778 B3#20pmos@117_poly-right##43 B3#20pmos@117_poly-right##44 9.869
R5779 B3#20pmos@117_poly-right##44 B3#20pmos@117_poly-right##45 9.869
R5780 B3#20pmos@117_poly-right##45 B3#20pmos@117_poly-right##46 9.869
R5781 B3#20pmos@117_poly-right##46 B3#20pmos@117_poly-right##47 9.869
R5782 B3#20pmos@117_poly-right##47 B3#10pin@682_polysilicon-1 9.869
R5783 NAND2_to_Nand6#9pin@684_polysilicon-1 NAND2_to_Nand6#9pin@684_polysilicon-1##0 9.938
R5784 NAND2_to_Nand6#9pin@684_polysilicon-1##0 NAND2_to_Nand6#9pin@684_polysilicon-1##1 9.938
R5785 NAND2_to_Nand6#9pin@684_polysilicon-1##1 NAND2_to_Nand6#9pin@684_polysilicon-1##2 9.938
R5786 NAND2_to_Nand6#9pin@684_polysilicon-1##2 NAND2_to_Nand6#9pin@684_polysilicon-1##3 9.938
R5787 NAND2_to_Nand6#9pin@684_polysilicon-1##3 NAND2_to_Nand6#9pin@684_polysilicon-1##4 9.938
R5788 NAND2_to_Nand6#9pin@684_polysilicon-1##4 NAND2_to_Nand6#9pin@684_polysilicon-1##5 9.938
R5789 NAND2_to_Nand6#9pin@684_polysilicon-1##5 NAND2_to_Nand6#9pin@684_polysilicon-1##6 9.938
R5790 NAND2_to_Nand6#9pin@684_polysilicon-1##6 NAND2_to_Nand6#9pin@684_polysilicon-1##7 9.938
R5791 NAND2_to_Nand6#9pin@684_polysilicon-1##7 NAND2_to_Nand6#9pin@684_polysilicon-1##8 9.938
R5792 NAND2_to_Nand6#9pin@684_polysilicon-1##8 NAND2_to_Nand6#9pin@684_polysilicon-1##9 9.938
R5793 NAND2_to_Nand6#9pin@684_polysilicon-1##9 NAND2_to_Nand6#9pin@684_polysilicon-1##10 9.938
R5794 NAND2_to_Nand6#9pin@684_polysilicon-1##10 NAND2_to_Nand6#9pin@684_polysilicon-1##11 9.938
R5795 NAND2_to_Nand6#9pin@684_polysilicon-1##11 NAND2_to_Nand6#9pin@684_polysilicon-1##12 9.938
R5796 NAND2_to_Nand6#9pin@684_polysilicon-1##12 NAND2_to_Nand6#9pin@684_polysilicon-1##13 9.938
R5797 NAND2_to_Nand6#9pin@684_polysilicon-1##13 NAND2_to_Nand6#9pin@684_polysilicon-1##14 9.938
R5798 NAND2_to_Nand6#9pin@684_polysilicon-1##14 NAND2_to_Nand6#9pin@684_polysilicon-1##15 9.938
R5799 NAND2_to_Nand6#9pin@684_polysilicon-1##15 NAND2_to_Nand6#9pin@684_polysilicon-1##16 9.938
R5800 NAND2_to_Nand6#9pin@684_polysilicon-1##16 NAND2_to_Nand6#9pin@684_polysilicon-1##17 9.938
R5801 NAND2_to_Nand6#9pin@684_polysilicon-1##17 NAND2_to_Nand6#9pin@684_polysilicon-1##18 9.938
R5802 NAND2_to_Nand6#9pin@684_polysilicon-1##18 NAND2_to_Nand6#9pin@684_polysilicon-1##19 9.938
R5803 NAND2_to_Nand6#9pin@684_polysilicon-1##19 NAND2_to_Nand6#9pin@684_polysilicon-1##20 9.938
R5804 NAND2_to_Nand6#9pin@684_polysilicon-1##20 NAND2_to_Nand6#9pin@684_polysilicon-1##21 9.938
R5805 NAND2_to_Nand6#9pin@684_polysilicon-1##21 NAND2_to_Nand6#9pin@684_polysilicon-1##22 9.938
R5806 NAND2_to_Nand6#9pin@684_polysilicon-1##22 NAND2_to_Nand6#9pin@684_polysilicon-1##23 9.938
R5807 NAND2_to_Nand6#9pin@684_polysilicon-1##23 NAND2_to_Nand6#9pin@684_polysilicon-1##24 9.938
R5808 NAND2_to_Nand6#9pin@684_polysilicon-1##24 NAND2_to_Nand6#9pin@684_polysilicon-1##25 9.938
R5809 NAND2_to_Nand6#9pin@684_polysilicon-1##25 NAND2_to_Nand6#9pin@684_polysilicon-1##26 9.938
R5810 NAND2_to_Nand6#9pin@684_polysilicon-1##26 NAND2_to_Nand6#9pin@684_polysilicon-1##27 9.938
R5811 NAND2_to_Nand6#9pin@684_polysilicon-1##27 NAND2_to_Nand6#9pin@684_polysilicon-1##28 9.938
R5812 NAND2_to_Nand6#9pin@684_polysilicon-1##28 NAND2_to_Nand6#9pin@684_polysilicon-1##29 9.938
R5813 NAND2_to_Nand6#9pin@684_polysilicon-1##29 NAND2_to_Nand6#9pin@684_polysilicon-1##30 9.938
R5814 NAND2_to_Nand6#9pin@684_polysilicon-1##30 NAND2_to_Nand6#9pin@684_polysilicon-1##31 9.938
R5815 NAND2_to_Nand6#9pin@684_polysilicon-1##31 NAND2_to_Nand6#9pin@684_polysilicon-1##32 9.938
R5816 NAND2_to_Nand6#9pin@684_polysilicon-1##32 NAND2_to_Nand6#9pin@684_polysilicon-1##33 9.938
R5817 NAND2_to_Nand6#9pin@684_polysilicon-1##33 NAND2_to_Nand6#9pin@684_polysilicon-1##34 9.938
R5818 NAND2_to_Nand6#9pin@684_polysilicon-1##34 NAND2_to_Nand6#9pin@684_polysilicon-1##35 9.938
R5819 NAND2_to_Nand6#9pin@684_polysilicon-1##35 NAND2_to_Nand6#9pin@684_polysilicon-1##36 9.938
R5820 NAND2_to_Nand6#9pin@684_polysilicon-1##36 NAND2_to_Nand6#9pin@684_polysilicon-1##37 9.938
R5821 NAND2_to_Nand6#9pin@684_polysilicon-1##37 NAND2_to_Nand6#9pin@684_polysilicon-1##38 9.938
R5822 NAND2_to_Nand6#9pin@684_polysilicon-1##38 NAND2_to_Nand6#9pin@684_polysilicon-1##39 9.938
R5823 NAND2_to_Nand6#9pin@684_polysilicon-1##39 NAND2_to_Nand6#9pin@684_polysilicon-1##40 9.938
R5824 NAND2_to_Nand6#9pin@684_polysilicon-1##40 NAND2_to_Nand6#9pin@684_polysilicon-1##41 9.938
R5825 NAND2_to_Nand6#9pin@684_polysilicon-1##41 NAND2_to_Nand6#9pin@684_polysilicon-1##42 9.938
R5826 NAND2_to_Nand6#9pin@684_polysilicon-1##42 NAND2_to_Nand6#9pin@684_polysilicon-1##43 9.938
R5827 NAND2_to_Nand6#9pin@684_polysilicon-1##43 NAND2_to_Nand6#9pin@684_polysilicon-1##44 9.938
R5828 NAND2_to_Nand6#9pin@684_polysilicon-1##44 NAND2_to_Nand6#9pin@684_polysilicon-1##45 9.938
R5829 NAND2_to_Nand6#9pin@684_polysilicon-1##45 NAND2_to_Nand6#9pin@684_polysilicon-1##46 9.938
R5830 NAND2_to_Nand6#9pin@684_polysilicon-1##46 NAND2_to_Nand6#9pin@684_polysilicon-1##47 9.938
R5831 NAND2_to_Nand6#9pin@684_polysilicon-1##47 NAND2_to_Nand6#9pin@684_polysilicon-1##48 9.938
R5832 NAND2_to_Nand6#9pin@684_polysilicon-1##48 NAND2_to_Nand6#9pin@684_polysilicon-1##49 9.938
R5833 NAND2_to_Nand6#9pin@684_polysilicon-1##49 NAND2_to_Nand6#11nmos@118_poly-right 9.938
R5834 NAND1_to_NAND6#14nmos@119_poly-right NAND1_to_NAND6#14nmos@119_poly-right##0 9.898
R5835 NAND1_to_NAND6#14nmos@119_poly-right##0 NAND1_to_NAND6#14nmos@119_poly-right##1 9.898
R5836 NAND1_to_NAND6#14nmos@119_poly-right##1 NAND1_to_NAND6#14nmos@119_poly-right##2 9.898
R5837 NAND1_to_NAND6#14nmos@119_poly-right##2 NAND1_to_NAND6#14nmos@119_poly-right##3 9.898
R5838 NAND1_to_NAND6#14nmos@119_poly-right##3 NAND1_to_NAND6#14nmos@119_poly-right##4 9.898
R5839 NAND1_to_NAND6#14nmos@119_poly-right##4 NAND1_to_NAND6#14nmos@119_poly-right##5 9.898
R5840 NAND1_to_NAND6#14nmos@119_poly-right##5 NAND1_to_NAND6#14nmos@119_poly-right##6 9.898
R5841 NAND1_to_NAND6#14nmos@119_poly-right##6 NAND1_to_NAND6#14nmos@119_poly-right##7 9.898
R5842 NAND1_to_NAND6#14nmos@119_poly-right##7 NAND1_to_NAND6#14nmos@119_poly-right##8 9.898
R5843 NAND1_to_NAND6#14nmos@119_poly-right##8 NAND1_to_NAND6#14nmos@119_poly-right##9 9.898
R5844 NAND1_to_NAND6#14nmos@119_poly-right##9 NAND1_to_NAND6#14nmos@119_poly-right##10 9.898
R5845 NAND1_to_NAND6#14nmos@119_poly-right##10 NAND1_to_NAND6#14nmos@119_poly-right##11 9.898
R5846 NAND1_to_NAND6#14nmos@119_poly-right##11 NAND1_to_NAND6#14nmos@119_poly-right##12 9.898
R5847 NAND1_to_NAND6#14nmos@119_poly-right##12 NAND1_to_NAND6#14nmos@119_poly-right##13 9.898
R5848 NAND1_to_NAND6#14nmos@119_poly-right##13 NAND1_to_NAND6#14nmos@119_poly-right##14 9.898
R5849 NAND1_to_NAND6#14nmos@119_poly-right##14 NAND1_to_NAND6#14nmos@119_poly-right##15 9.898
R5850 NAND1_to_NAND6#14nmos@119_poly-right##15 NAND1_to_NAND6#14nmos@119_poly-right##16 9.898
R5851 NAND1_to_NAND6#14nmos@119_poly-right##16 NAND1_to_NAND6#14nmos@119_poly-right##17 9.898
R5852 NAND1_to_NAND6#14nmos@119_poly-right##17 NAND1_to_NAND6#14nmos@119_poly-right##18 9.898
R5853 NAND1_to_NAND6#14nmos@119_poly-right##18 NAND1_to_NAND6#14nmos@119_poly-right##19 9.898
R5854 NAND1_to_NAND6#14nmos@119_poly-right##19 NAND1_to_NAND6#14nmos@119_poly-right##20 9.898
R5855 NAND1_to_NAND6#14nmos@119_poly-right##20 NAND1_to_NAND6#14nmos@119_poly-right##21 9.898
R5856 NAND1_to_NAND6#14nmos@119_poly-right##21 NAND1_to_NAND6#14nmos@119_poly-right##22 9.898
R5857 NAND1_to_NAND6#14nmos@119_poly-right##22 NAND1_to_NAND6#14nmos@119_poly-right##23 9.898
R5858 NAND1_to_NAND6#14nmos@119_poly-right##23 NAND1_to_NAND6#14nmos@119_poly-right##24 9.898
R5859 NAND1_to_NAND6#14nmos@119_poly-right##24 NAND1_to_NAND6#14nmos@119_poly-right##25 9.898
R5860 NAND1_to_NAND6#14nmos@119_poly-right##25 NAND1_to_NAND6#14nmos@119_poly-right##26 9.898
R5861 NAND1_to_NAND6#14nmos@119_poly-right##26 NAND1_to_NAND6#14nmos@119_poly-right##27 9.898
R5862 NAND1_to_NAND6#14nmos@119_poly-right##27 NAND1_to_NAND6#14nmos@119_poly-right##28 9.898
R5863 NAND1_to_NAND6#14nmos@119_poly-right##28 NAND1_to_NAND6#14nmos@119_poly-right##29 9.898
R5864 NAND1_to_NAND6#14nmos@119_poly-right##29 NAND1_to_NAND6#14nmos@119_poly-right##30 9.898
R5865 NAND1_to_NAND6#14nmos@119_poly-right##30 NAND1_to_NAND6#14nmos@119_poly-right##31 9.898
R5866 NAND1_to_NAND6#14nmos@119_poly-right##31 NAND1_to_NAND6#14nmos@119_poly-right##32 9.898
R5867 NAND1_to_NAND6#14nmos@119_poly-right##32 NAND1_to_NAND6#14nmos@119_poly-right##33 9.898
R5868 NAND1_to_NAND6#14nmos@119_poly-right##33 NAND1_to_NAND6#14nmos@119_poly-right##34 9.898
R5869 NAND1_to_NAND6#14nmos@119_poly-right##34 NAND1_to_NAND6#14nmos@119_poly-right##35 9.898
R5870 NAND1_to_NAND6#14nmos@119_poly-right##35 NAND1_to_NAND6#14nmos@119_poly-right##36 9.898
R5871 NAND1_to_NAND6#14nmos@119_poly-right##36 NAND1_to_NAND6#14nmos@119_poly-right##37 9.898
R5872 NAND1_to_NAND6#14nmos@119_poly-right##37 NAND1_to_NAND6#14nmos@119_poly-right##38 9.898
R5873 NAND1_to_NAND6#14nmos@119_poly-right##38 NAND1_to_NAND6#14nmos@119_poly-right##39 9.898
R5874 NAND1_to_NAND6#14nmos@119_poly-right##39 NAND1_to_NAND6#14nmos@119_poly-right##40 9.898
R5875 NAND1_to_NAND6#14nmos@119_poly-right##40 NAND1_to_NAND6#14nmos@119_poly-right##41 9.898
R5876 NAND1_to_NAND6#14nmos@119_poly-right##41 NAND1_to_NAND6#14nmos@119_poly-right##42 9.898
R5877 NAND1_to_NAND6#14nmos@119_poly-right##42 NAND1_to_NAND6#14nmos@119_poly-right##43 9.898
R5878 NAND1_to_NAND6#14nmos@119_poly-right##43 NAND1_to_NAND6#14nmos@119_poly-right##44 9.898
R5879 NAND1_to_NAND6#14nmos@119_poly-right##44 NAND1_to_NAND6#14nmos@119_poly-right##45 9.898
R5880 NAND1_to_NAND6#14nmos@119_poly-right##45 NAND1_to_NAND6#14nmos@119_poly-right##46 9.898
R5881 NAND1_to_NAND6#14nmos@119_poly-right##46 NAND1_to_NAND6#14nmos@119_poly-right##47 9.898
R5882 NAND1_to_NAND6#14nmos@119_poly-right##47 NAND1_to_NAND6#14nmos@119_poly-right##48 9.898
R5883 NAND1_to_NAND6#14nmos@119_poly-right##48 NAND1_to_NAND6#14nmos@119_poly-right##49 9.898
R5884 NAND1_to_NAND6#14nmos@119_poly-right##49 NAND1_to_NAND6#14nmos@119_poly-right##50 9.898
R5885 NAND1_to_NAND6#14nmos@119_poly-right##50 NAND1_to_NAND6#14nmos@119_poly-right##51 9.898
R5886 NAND1_to_NAND6#14nmos@119_poly-right##51 NAND1_to_NAND6#14nmos@119_poly-right##52 9.898
R5887 NAND1_to_NAND6#14nmos@119_poly-right##52 NAND1_to_NAND6#14nmos@119_poly-right##53 9.898
R5888 NAND1_to_NAND6#14nmos@119_poly-right##53 NAND1_to_NAND6#14nmos@119_poly-right##54 9.898
R5889 NAND1_to_NAND6#14nmos@119_poly-right##54 NAND1_to_NAND6#14nmos@119_poly-right##55 9.898
R5890 NAND1_to_NAND6#14nmos@119_poly-right##55 NAND1_to_NAND6#11pmos@119_poly-right 9.898
R5891 NAND2_to_Nand6 NAND2_to_Nand6#4nmos@117_diff-bottom 4.42
R5892 net@2392 net@2392##0 9.92
R5893 net@2392##0 net@2392##1 9.92
R5894 net@2392##1 net@2392##2 9.92
R5895 net@2392##2 net@2392##3 9.92
R5896 net@2392##3 net@2392##4 9.92
R5897 net@2392##4 net@2392##5 9.92
R5898 net@2392##5 net@2392##6 9.92
R5899 net@2392##6 net@2392##7 9.92
R5900 net@2392##7 net@2392##8 9.92
R5901 net@2392##8 net@2392##9 9.92
R5902 net@2392##9 net@2392##10 9.92
R5903 net@2392##10 net@2392##11 9.92
R5904 net@2392##11 net@2392##12 9.92
R5905 net@2392##12 net@2392##13 9.92
R5906 net@2392##13 net@2392##14 9.92
R5907 net@2392##14 net@2392##15 9.92
R5908 net@2392##15 net@2392##16 9.92
R5909 net@2392##16 net@2392##17 9.92
R5910 net@2392##17 net@2392##18 9.92
R5911 net@2392##18 net@2392#1pin@727_polysilicon-1 9.92
R5912 net@2394 net@2394##0 9.92
R5913 net@2394##0 net@2394##1 9.92
R5914 net@2394##1 net@2394##2 9.92
R5915 net@2394##2 net@2394##3 9.92
R5916 net@2394##3 net@2394##4 9.92
R5917 net@2394##4 net@2394##5 9.92
R5918 net@2394##5 net@2394##6 9.92
R5919 net@2394##6 net@2394##7 9.92
R5920 net@2394##7 net@2394##8 9.92
R5921 net@2394##8 net@2394##9 9.92
R5922 net@2394##9 net@2394##10 9.92
R5923 net@2394##10 net@2394##11 9.92
R5924 net@2394##11 net@2394##12 9.92
R5925 net@2394##12 net@2394##13 9.92
R5926 net@2394##13 net@2394##14 9.92
R5927 net@2394##14 net@2394##15 9.92
R5928 net@2394##15 net@2394##16 9.92
R5929 net@2394##16 net@2394##17 9.92
R5930 net@2394##17 net@2394##18 9.92
R5931 net@2394##18 net@2394#1pin@752_polysilicon-1 9.92
R5932 XOR1_to_NAND5#3pin@753_polysilicon-1 XOR1_to_NAND5#3pin@753_polysilicon-1##0 6.2
R5933 XOR1_to_NAND5#3pin@753_polysilicon-1##0 XOR1_to_NAND5#4pmos@132_poly-right 6.2
R5934 XOR1_to_NAND5#3pin@753_polysilicon-1 XOR1_to_NAND5#3pin@753_polysilicon-1##0 8.138
R5935 XOR1_to_NAND5#3pin@753_polysilicon-1##0 XOR1_to_NAND5#3pin@753_polysilicon-1##1 8.138
R5936 XOR1_to_NAND5#3pin@753_polysilicon-1##1 XOR1_to_NAND5#3pin@753_polysilicon-1##2 8.138
R5937 XOR1_to_NAND5#3pin@753_polysilicon-1##2 XOR1_to_NAND5#1contact@875_metal-1-metal-2 8.138
R5938 Cin_to_XOR2___NAND5#14nmos@131_poly-right Cin_to_XOR2___NAND5#14nmos@131_poly-right##0 5.425
R5939 Cin_to_XOR2___NAND5#14nmos@131_poly-right##0 Cin_to_XOR2___NAND5#15pin@743_polysilicon-1 5.425
R5940 Cin_to_XOR2___NAND5 Cin_to_XOR2___NAND5##0 8.99
R5941 Cin_to_XOR2___NAND5##0 Cin_to_XOR2___NAND5##1 8.99
R5942 Cin_to_XOR2___NAND5##1 Cin_to_XOR2___NAND5##2 8.99
R5943 Cin_to_XOR2___NAND5##2 Cin_to_XOR2___NAND5##3 8.99
R5944 Cin_to_XOR2___NAND5##3 Cin_to_XOR2___NAND5#15pin@743_polysilicon-1 8.99
R5945 A4#3pin@728_polysilicon-1 A4#3pin@728_polysilicon-1##0 6.2
R5946 A4#3pin@728_polysilicon-1##0 A4#4pmos@125_poly-right 6.2
R5947 XOR1_to_NAND5#9pmos@127_poly-left XOR1_to_NAND5#9pmos@127_poly-left##0 8.138
R5948 XOR1_to_NAND5#9pmos@127_poly-left##0 XOR1_to_NAND5#9pmos@127_poly-left##1 8.138
R5949 XOR1_to_NAND5#9pmos@127_poly-left##1 XOR1_to_NAND5#9pmos@127_poly-left##2 8.138
R5950 XOR1_to_NAND5#9pmos@127_poly-left##2 XOR1_to_NAND5#10pin@740_polysilicon-1 8.138
R5951 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##0 9.843
R5952 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##0 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##1 9.843
R5953 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##1 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##2 9.843
R5954 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##2 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##3 9.843
R5955 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##3 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##4 9.843
R5956 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##4 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##5 9.843
R5957 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##5 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##6 9.843
R5958 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##6 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##7 9.843
R5959 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##7 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##8 9.843
R5960 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##8 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##9 9.843
R5961 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##9 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##10 9.843
R5962 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##10 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##11 9.843
R5963 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##11 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##12 9.843
R5964 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##12 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##13 9.843
R5965 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##13 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##14 9.843
R5966 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##14 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##15 9.843
R5967 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##15 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##16 9.843
R5968 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##16 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##17 9.843
R5969 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##17 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##18 9.843
R5970 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##18 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1 9.843
R5971 net@2403#4nmos@133_poly-right net@2403#4nmos@133_poly-right##0 9.3
R5972 net@2403#4nmos@133_poly-right##0 net@2403#4nmos@133_poly-right##1 9.3
R5973 net@2403#4nmos@133_poly-right##1 net@2403#5pin@745_polysilicon-1 9.3
R5974 net@2403#2contact@861_metal-1-polysilicon-1 net@2403#2contact@861_metal-1-polysilicon-1##0 8.99
R5975 net@2403#2contact@861_metal-1-polysilicon-1##0 net@2403#2contact@861_metal-1-polysilicon-1##1 8.99
R5976 net@2403#2contact@861_metal-1-polysilicon-1##1 net@2403#2contact@861_metal-1-polysilicon-1##2 8.99
R5977 net@2403#2contact@861_metal-1-polysilicon-1##2 net@2403#2contact@861_metal-1-polysilicon-1##3 8.99
R5978 net@2403#2contact@861_metal-1-polysilicon-1##3 net@2403#5pin@745_polysilicon-1 8.99
R5979 A4#3pin@728_polysilicon-1 A4#3pin@728_polysilicon-1##0 8.138
R5980 A4#3pin@728_polysilicon-1##0 A4#3pin@728_polysilicon-1##1 8.138
R5981 A4#3pin@728_polysilicon-1##1 A4#3pin@728_polysilicon-1##2 8.138
R5982 A4#3pin@728_polysilicon-1##2 A4#1pin@767_metal-2 8.138
R5983 XOR1_to_NAND5#1contact@875_metal-1-metal-2 XOR1_to_NAND5#1contact@875_metal-1-metal-2##0 6.717
R5984 XOR1_to_NAND5#1contact@875_metal-1-metal-2##0 XOR1_to_NAND5#1contact@875_metal-1-metal-2##1 6.717
R5985 XOR1_to_NAND5#1contact@875_metal-1-metal-2##1 XOR1_to_NAND5#12pin@741_polysilicon-1 6.717
R5986 XOR1_to_NAND5#10pin@740_polysilicon-1 XOR1_to_NAND5#10pin@740_polysilicon-1##0 7.75
R5987 XOR1_to_NAND5#10pin@740_polysilicon-1##0 XOR1_to_NAND5#10pin@740_polysilicon-1##1 7.75
R5988 XOR1_to_NAND5#10pin@740_polysilicon-1##1 XOR1_to_NAND5#12pin@741_polysilicon-1 7.75
R5989 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1##0 9.743
R5990 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1##0 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1##1 9.743
R5991 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1##1 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1##2 9.743
R5992 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1##2 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1##3 9.743
R5993 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1##3 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1##4 9.743
R5994 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1##4 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1##5 9.743
R5995 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1##5 Cin_to_XOR2___NAND5 9.743
R5996 net@2394#7pmos@128_poly-left net@2394#7pmos@128_poly-left##0 7.75
R5997 net@2394#7pmos@128_poly-left##0 net@2394 7.75
R5998 Cin_to_XOR2___NAND5#18nmos@129_poly-left Cin_to_XOR2___NAND5#18nmos@129_poly-left##0 6.2
R5999 Cin_to_XOR2___NAND5#18nmos@129_poly-left##0 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1 6.2
R6000 net@2404#9nmos@130_poly-left net@2404#9nmos@130_poly-left##0 8.37
R6001 net@2404#9nmos@130_poly-left##0 net@2404#9nmos@130_poly-left##1 8.37
R6002 net@2404#9nmos@130_poly-left##1 net@2404#9nmos@130_poly-left##2 8.37
R6003 net@2404#9nmos@130_poly-left##2 net@2404#9nmos@130_poly-left##3 8.37
R6004 net@2404#9nmos@130_poly-left##3 net@2404#2contact@836_metal-1-metal-2 8.37
R6005 XOR1_to_NAND5 XOR1_to_NAND5##0 6.717
R6006 XOR1_to_NAND5##0 XOR1_to_NAND5##1 6.717
R6007 XOR1_to_NAND5##1 XOR1_to_NAND5#14pin@757_polysilicon-1 6.717
R6008 XOR1_to_NAND5#16pmos@134_poly-right XOR1_to_NAND5#16pmos@134_poly-right##0 6.2
R6009 XOR1_to_NAND5#16pmos@134_poly-right##0 XOR1_to_NAND5#14pin@757_polysilicon-1 6.2
R6010 Cin_to_XOR2___NAND5#23pin@761_polysilicon-1 Cin_to_XOR2___NAND5#23pin@761_polysilicon-1##0 9.688
R6011 Cin_to_XOR2___NAND5#23pin@761_polysilicon-1##0 Cin_to_XOR2___NAND5#23pin@761_polysilicon-1##1 9.688
R6012 Cin_to_XOR2___NAND5#23pin@761_polysilicon-1##1 Cin_to_XOR2___NAND5#23pin@761_polysilicon-1##2 9.688
R6013 Cin_to_XOR2___NAND5#23pin@761_polysilicon-1##2 Cin_to_XOR2___NAND5#20contact@874_metal-1-metal-2 9.688
R6014 Cin_to_XOR2___NAND5#20contact@874_metal-1-metal-2 Cin_to_XOR2___NAND5 4.953
R6015 A4#0contact@883_metal-1-metal-2 A4#0contact@883_metal-1-metal-2##0 6.717
R6016 A4#0contact@883_metal-1-metal-2##0 A4#0contact@883_metal-1-metal-2##1 6.717
R6017 A4#0contact@883_metal-1-metal-2##1 A4#10pin@764_polysilicon-1 6.717
R6018 A4#11pmos@136_poly-right A4#11pmos@136_poly-right##0 9.558
R6019 A4#11pmos@136_poly-right##0 A4#11pmos@136_poly-right##1 9.558
R6020 A4#11pmos@136_poly-right##1 A4#11pmos@136_poly-right##2 9.558
R6021 A4#11pmos@136_poly-right##2 A4#11pmos@136_poly-right##3 9.558
R6022 A4#11pmos@136_poly-right##3 A4#11pmos@136_poly-right##4 9.558
R6023 A4#11pmos@136_poly-right##4 A4#10pin@764_polysilicon-1 9.558
R6024 B4#10pin@768_polysilicon-1 B4#10pin@768_polysilicon-1##0 8.138
R6025 B4#10pin@768_polysilicon-1##0 B4#10pin@768_polysilicon-1##1 8.138
R6026 B4#10pin@768_polysilicon-1##1 B4#10pin@768_polysilicon-1##2 8.138
R6027 B4#10pin@768_polysilicon-1##2 B4#0contact@884_metal-1-metal-2 8.138
R6028 B4#11nmos@124_poly-right B4#11nmos@124_poly-right##0 5.425
R6029 B4#11nmos@124_poly-right##0 B4#12pin@718_polysilicon-1 5.425
R6030 NAND2_to_Nand7 NAND2_to_Nand7##0 6.717
R6031 NAND2_to_Nand7##0 NAND2_to_Nand7##1 6.717
R6032 NAND2_to_Nand7##1 NAND2_to_Nand7#9pin@770_polysilicon-1 6.717
R6033 NAND2_to_Nand7#10pmos@138_poly-right NAND2_to_Nand7#10pmos@138_poly-right##0 9.558
R6034 NAND2_to_Nand7#10pmos@138_poly-right##0 NAND2_to_Nand7#10pmos@138_poly-right##1 9.558
R6035 NAND2_to_Nand7#10pmos@138_poly-right##1 NAND2_to_Nand7#10pmos@138_poly-right##2 9.558
R6036 NAND2_to_Nand7#10pmos@138_poly-right##2 NAND2_to_Nand7#10pmos@138_poly-right##3 9.558
R6037 NAND2_to_Nand7#10pmos@138_poly-right##3 NAND2_to_Nand7#10pmos@138_poly-right##4 9.558
R6038 NAND2_to_Nand7#10pmos@138_poly-right##4 NAND2_to_Nand7#9pin@770_polysilicon-1 9.558
R6039 B4#1pin@769_metal-2 B4#1pin@769_metal-2##0 8.99
R6040 B4#1pin@769_metal-2##0 B4#1pin@769_metal-2##1 8.99
R6041 B4#1pin@769_metal-2##1 B4#1pin@769_metal-2##2 8.99
R6042 B4#1pin@769_metal-2##2 B4#1pin@769_metal-2##3 8.99
R6043 B4#1pin@769_metal-2##3 B4#12pin@718_polysilicon-1 8.99
R6044 NAND1_to_NAND7#11pmos@139_poly-right NAND1_to_NAND7#11pmos@139_poly-right##0 5.425
R6045 NAND1_to_NAND7#11pmos@139_poly-right##0 NAND1_to_NAND7#12pin@774_polysilicon-1 5.425
R6046 NAND1_to_NAND7#12pin@774_polysilicon-1 NAND1_to_NAND7#12pin@774_polysilicon-1##0 9.3
R6047 NAND1_to_NAND7#12pin@774_polysilicon-1##0 NAND1_to_NAND7#12pin@774_polysilicon-1##1 9.3
R6048 NAND1_to_NAND7#12pin@774_polysilicon-1##1 NAND1_to_NAND7 9.3
R6049 Cin_to_XOR2___NAND5#25nmos@135_poly-right Cin_to_XOR2___NAND5#25nmos@135_poly-right##0 8.636
R6050 Cin_to_XOR2___NAND5#25nmos@135_poly-right##0 Cin_to_XOR2___NAND5#25nmos@135_poly-right##1 8.636
R6051 Cin_to_XOR2___NAND5#25nmos@135_poly-right##1 Cin_to_XOR2___NAND5#25nmos@135_poly-right##2 8.636
R6052 Cin_to_XOR2___NAND5#25nmos@135_poly-right##2 Cin_to_XOR2___NAND5#25nmos@135_poly-right##3 8.636
R6053 Cin_to_XOR2___NAND5#25nmos@135_poly-right##3 Cin_to_XOR2___NAND5#25nmos@135_poly-right##4 8.636
R6054 Cin_to_XOR2___NAND5#25nmos@135_poly-right##4 Cin_to_XOR2___NAND5#25nmos@135_poly-right##5 8.636
R6055 Cin_to_XOR2___NAND5#25nmos@135_poly-right##5 Cin_to_XOR2___NAND5#23pin@761_polysilicon-1 8.636
R6056 B4#13nmos@137_poly-right B4#13nmos@137_poly-right##0 8.956
R6057 B4#13nmos@137_poly-right##0 B4#13nmos@137_poly-right##1 8.956
R6058 B4#13nmos@137_poly-right##1 B4#13nmos@137_poly-right##2 8.956
R6059 B4#13nmos@137_poly-right##2 B4#13nmos@137_poly-right##3 8.956
R6060 B4#13nmos@137_poly-right##3 B4#13nmos@137_poly-right##4 8.956
R6061 B4#13nmos@137_poly-right##4 B4#13nmos@137_poly-right##5 8.956
R6062 B4#13nmos@137_poly-right##5 B4#13nmos@137_poly-right##6 8.956
R6063 B4#13nmos@137_poly-right##6 B4#13nmos@137_poly-right##7 8.956
R6064 B4#13nmos@137_poly-right##7 B4#10pin@768_polysilicon-1 8.956
R6065 A4#12pmos@120_poly-left A4#12pmos@120_poly-left##0 8.138
R6066 A4#12pmos@120_poly-left##0 A4#12pmos@120_poly-left##1 8.138
R6067 A4#12pmos@120_poly-left##1 A4#12pmos@120_poly-left##2 8.138
R6068 A4#12pmos@120_poly-left##2 A4#13pin@715_polysilicon-1 8.138
R6069 B4#14pin@708_polysilicon-1 B4#14pin@708_polysilicon-1##0 9.843
R6070 B4#14pin@708_polysilicon-1##0 B4#14pin@708_polysilicon-1##1 9.843
R6071 B4#14pin@708_polysilicon-1##1 B4#14pin@708_polysilicon-1##2 9.843
R6072 B4#14pin@708_polysilicon-1##2 B4#14pin@708_polysilicon-1##3 9.843
R6073 B4#14pin@708_polysilicon-1##3 B4#14pin@708_polysilicon-1##4 9.843
R6074 B4#14pin@708_polysilicon-1##4 B4#14pin@708_polysilicon-1##5 9.843
R6075 B4#14pin@708_polysilicon-1##5 B4#14pin@708_polysilicon-1##6 9.843
R6076 B4#14pin@708_polysilicon-1##6 B4#14pin@708_polysilicon-1##7 9.843
R6077 B4#14pin@708_polysilicon-1##7 B4#14pin@708_polysilicon-1##8 9.843
R6078 B4#14pin@708_polysilicon-1##8 B4#14pin@708_polysilicon-1##9 9.843
R6079 B4#14pin@708_polysilicon-1##9 B4#14pin@708_polysilicon-1##10 9.843
R6080 B4#14pin@708_polysilicon-1##10 B4#14pin@708_polysilicon-1##11 9.843
R6081 B4#14pin@708_polysilicon-1##11 B4#14pin@708_polysilicon-1##12 9.843
R6082 B4#14pin@708_polysilicon-1##12 B4#14pin@708_polysilicon-1##13 9.843
R6083 B4#14pin@708_polysilicon-1##13 B4#14pin@708_polysilicon-1##14 9.843
R6084 B4#14pin@708_polysilicon-1##14 B4#14pin@708_polysilicon-1##15 9.843
R6085 B4#14pin@708_polysilicon-1##15 B4#14pin@708_polysilicon-1##16 9.843
R6086 B4#14pin@708_polysilicon-1##16 B4#14pin@708_polysilicon-1##17 9.843
R6087 B4#14pin@708_polysilicon-1##17 B4#14pin@708_polysilicon-1##18 9.843
R6088 B4#14pin@708_polysilicon-1##18 B4#15pin@725_polysilicon-1 9.843
R6089 net@2490#4nmos@126_poly-right net@2490#4nmos@126_poly-right##0 7.233
R6090 net@2490#4nmos@126_poly-right##0 net@2490#4nmos@126_poly-right##1 7.233
R6091 net@2490#4nmos@126_poly-right##1 net@2490#5pin@720_polysilicon-1 7.233
R6092 net@2490#2contact@822_metal-1-polysilicon-1 net@2490#2contact@822_metal-1-polysilicon-1##0 8.99
R6093 net@2490#2contact@822_metal-1-polysilicon-1##0 net@2490#2contact@822_metal-1-polysilicon-1##1 8.99
R6094 net@2490#2contact@822_metal-1-polysilicon-1##1 net@2490#2contact@822_metal-1-polysilicon-1##2 8.99
R6095 net@2490#2contact@822_metal-1-polysilicon-1##2 net@2490#2contact@822_metal-1-polysilicon-1##3 8.99
R6096 net@2490#2contact@822_metal-1-polysilicon-1##3 net@2490#5pin@720_polysilicon-1 8.99
R6097 A4#1pin@767_metal-2 A4#1pin@767_metal-2##0 6.717
R6098 A4#1pin@767_metal-2##0 A4#1pin@767_metal-2##1 6.717
R6099 A4#1pin@767_metal-2##1 A4#15pin@716_polysilicon-1 6.717
R6100 A4#13pin@715_polysilicon-1 A4#13pin@715_polysilicon-1##0 7.75
R6101 A4#13pin@715_polysilicon-1##0 A4#13pin@715_polysilicon-1##1 7.75
R6102 A4#13pin@715_polysilicon-1##1 A4#15pin@716_polysilicon-1 7.75
R6103 B4#15pin@725_polysilicon-1 B4#15pin@725_polysilicon-1##0 9.743
R6104 B4#15pin@725_polysilicon-1##0 B4#15pin@725_polysilicon-1##1 9.743
R6105 B4#15pin@725_polysilicon-1##1 B4#15pin@725_polysilicon-1##2 9.743
R6106 B4#15pin@725_polysilicon-1##2 B4#15pin@725_polysilicon-1##3 9.743
R6107 B4#15pin@725_polysilicon-1##3 B4#15pin@725_polysilicon-1##4 9.743
R6108 B4#15pin@725_polysilicon-1##4 B4#15pin@725_polysilicon-1##5 9.743
R6109 B4#15pin@725_polysilicon-1##5 B4#1pin@769_metal-2 9.743
R6110 net@2392#7pmos@121_poly-left net@2392#7pmos@121_poly-left##0 7.75
R6111 net@2392#7pmos@121_poly-left##0 net@2392 7.75
R6112 B4#16nmos@122_poly-left B4#16nmos@122_poly-left##0 6.2
R6113 B4#16nmos@122_poly-left##0 B4#14pin@708_polysilicon-1 6.2
R6114 net@2497#9nmos@123_poly-left net@2497#9nmos@123_poly-left##0 8.37
R6115 net@2497#9nmos@123_poly-left##0 net@2497#9nmos@123_poly-left##1 8.37
R6116 net@2497#9nmos@123_poly-left##1 net@2497#9nmos@123_poly-left##2 8.37
R6117 net@2497#9nmos@123_poly-left##2 net@2497#9nmos@123_poly-left##3 8.37
R6118 net@2497#9nmos@123_poly-left##3 net@2497#2contact@798_metal-1-metal-2 8.37
R6119 A4#3pin@728_polysilicon-1 A4#3pin@728_polysilicon-1##0 9.881
R6120 A4#3pin@728_polysilicon-1##0 A4#3pin@728_polysilicon-1##1 9.881
R6121 A4#3pin@728_polysilicon-1##1 A4#3pin@728_polysilicon-1##2 9.881
R6122 A4#3pin@728_polysilicon-1##2 A4#3pin@728_polysilicon-1##3 9.881
R6123 A4#3pin@728_polysilicon-1##3 A4#3pin@728_polysilicon-1##4 9.881
R6124 A4#3pin@728_polysilicon-1##4 A4#3pin@728_polysilicon-1##5 9.881
R6125 A4#3pin@728_polysilicon-1##5 A4#3pin@728_polysilicon-1##6 9.881
R6126 A4#3pin@728_polysilicon-1##6 A4#3pin@728_polysilicon-1##7 9.881
R6127 A4#3pin@728_polysilicon-1##7 A4#3pin@728_polysilicon-1##8 9.881
R6128 A4#3pin@728_polysilicon-1##8 A4#3pin@728_polysilicon-1##9 9.881
R6129 A4#3pin@728_polysilicon-1##9 A4#3pin@728_polysilicon-1##10 9.881
R6130 A4#3pin@728_polysilicon-1##10 A4#3pin@728_polysilicon-1##11 9.881
R6131 A4#3pin@728_polysilicon-1##11 A4#3pin@728_polysilicon-1##12 9.881
R6132 A4#3pin@728_polysilicon-1##12 A4#3pin@728_polysilicon-1##13 9.881
R6133 A4#3pin@728_polysilicon-1##13 A4#3pin@728_polysilicon-1##14 9.881
R6134 A4#3pin@728_polysilicon-1##14 A4#3pin@728_polysilicon-1##15 9.881
R6135 A4#3pin@728_polysilicon-1##15 A4#3pin@728_polysilicon-1##16 9.881
R6136 A4#3pin@728_polysilicon-1##16 A4#3pin@728_polysilicon-1##17 9.881
R6137 A4#3pin@728_polysilicon-1##17 A4#3pin@728_polysilicon-1##18 9.881
R6138 A4#3pin@728_polysilicon-1##18 A4#3pin@728_polysilicon-1##19 9.881
R6139 A4#3pin@728_polysilicon-1##19 A4#3pin@728_polysilicon-1##20 9.881
R6140 A4#3pin@728_polysilicon-1##20 A4#3pin@728_polysilicon-1##21 9.881
R6141 A4#3pin@728_polysilicon-1##21 A4#3pin@728_polysilicon-1##22 9.881
R6142 A4#3pin@728_polysilicon-1##22 A4#3pin@728_polysilicon-1##23 9.881
R6143 A4#3pin@728_polysilicon-1##23 A4#3pin@728_polysilicon-1##24 9.881
R6144 A4#3pin@728_polysilicon-1##24 A4#3pin@728_polysilicon-1##25 9.881
R6145 A4#3pin@728_polysilicon-1##25 A4#3pin@728_polysilicon-1##26 9.881
R6146 A4#3pin@728_polysilicon-1##26 A4#3pin@728_polysilicon-1##27 9.881
R6147 A4#3pin@728_polysilicon-1##27 A4#3pin@728_polysilicon-1##28 9.881
R6148 A4#3pin@728_polysilicon-1##28 A4#3pin@728_polysilicon-1##29 9.881
R6149 A4#3pin@728_polysilicon-1##29 A4#3pin@728_polysilicon-1##30 9.881
R6150 A4#3pin@728_polysilicon-1##30 A4#3pin@728_polysilicon-1##31 9.881
R6151 A4#3pin@728_polysilicon-1##31 A4#3pin@728_polysilicon-1##32 9.881
R6152 A4#3pin@728_polysilicon-1##32 A4#3pin@728_polysilicon-1##33 9.881
R6153 A4#3pin@728_polysilicon-1##33 A4#3pin@728_polysilicon-1##34 9.881
R6154 A4#3pin@728_polysilicon-1##34 A4#3pin@728_polysilicon-1##35 9.881
R6155 A4#3pin@728_polysilicon-1##35 A4#3pin@728_polysilicon-1##36 9.881
R6156 A4#3pin@728_polysilicon-1##36 A4#3pin@728_polysilicon-1##37 9.881
R6157 A4#3pin@728_polysilicon-1##37 A4#3pin@728_polysilicon-1##38 9.881
R6158 A4#3pin@728_polysilicon-1##38 A4#3pin@728_polysilicon-1##39 9.881
R6159 A4#3pin@728_polysilicon-1##39 A4#3pin@728_polysilicon-1##40 9.881
R6160 A4#3pin@728_polysilicon-1##40 A4#3pin@728_polysilicon-1##41 9.881
R6161 A4#3pin@728_polysilicon-1##41 A4#3pin@728_polysilicon-1##42 9.881
R6162 A4#3pin@728_polysilicon-1##42 A4#3pin@728_polysilicon-1##43 9.881
R6163 A4#3pin@728_polysilicon-1##43 A4#3pin@728_polysilicon-1##44 9.881
R6164 A4#3pin@728_polysilicon-1##44 A4#3pin@728_polysilicon-1##45 9.881
R6165 A4#3pin@728_polysilicon-1##45 A4#3pin@728_polysilicon-1##46 9.881
R6166 A4#3pin@728_polysilicon-1##46 A4#3pin@728_polysilicon-1##47 9.881
R6167 A4#3pin@728_polysilicon-1##47 A4#3pin@728_polysilicon-1##48 9.881
R6168 A4#3pin@728_polysilicon-1##48 A4#3pin@728_polysilicon-1##49 9.881
R6169 A4#3pin@728_polysilicon-1##49 A4#3pin@728_polysilicon-1##50 9.881
R6170 A4#3pin@728_polysilicon-1##50 A4#3pin@728_polysilicon-1##51 9.881
R6171 A4#3pin@728_polysilicon-1##51 A4#3pin@728_polysilicon-1##52 9.881
R6172 A4#3pin@728_polysilicon-1##52 A4#3pin@728_polysilicon-1##53 9.881
R6173 A4#3pin@728_polysilicon-1##53 A4#3pin@728_polysilicon-1##54 9.881
R6174 A4#3pin@728_polysilicon-1##54 A4#16nmos@125_poly-right 9.881
R6175 net@2392#5pmos@125_diff-top net@2392#2pin@717_metal-1 4.81
R6176 net@2392#1pin@727_polysilicon-1 net@2392#1pin@727_polysilicon-1##0 9.85
R6177 net@2392#1pin@727_polysilicon-1##0 net@2392#1pin@727_polysilicon-1##1 9.85
R6178 net@2392#1pin@727_polysilicon-1##1 net@2392#1pin@727_polysilicon-1##2 9.85
R6179 net@2392#1pin@727_polysilicon-1##2 net@2392#1pin@727_polysilicon-1##3 9.85
R6180 net@2392#1pin@727_polysilicon-1##3 net@2392#1pin@727_polysilicon-1##4 9.85
R6181 net@2392#1pin@727_polysilicon-1##4 net@2392#1pin@727_polysilicon-1##5 9.85
R6182 net@2392#1pin@727_polysilicon-1##5 net@2392#1pin@727_polysilicon-1##6 9.85
R6183 net@2392#1pin@727_polysilicon-1##6 net@2392#1pin@727_polysilicon-1##7 9.85
R6184 net@2392#1pin@727_polysilicon-1##7 net@2392#1pin@727_polysilicon-1##8 9.85
R6185 net@2392#1pin@727_polysilicon-1##8 net@2392#1pin@727_polysilicon-1##9 9.85
R6186 net@2392#1pin@727_polysilicon-1##9 net@2392#1pin@727_polysilicon-1##10 9.85
R6187 net@2392#1pin@727_polysilicon-1##10 net@2392#1pin@727_polysilicon-1##11 9.85
R6188 net@2392#1pin@727_polysilicon-1##11 net@2392#1pin@727_polysilicon-1##12 9.85
R6189 net@2392#1pin@727_polysilicon-1##12 net@2392#1pin@727_polysilicon-1##13 9.85
R6190 net@2392#1pin@727_polysilicon-1##13 net@2392#1pin@727_polysilicon-1##14 9.85
R6191 net@2392#1pin@727_polysilicon-1##14 net@2392#1pin@727_polysilicon-1##15 9.85
R6192 net@2392#1pin@727_polysilicon-1##15 net@2392#1pin@727_polysilicon-1##16 9.85
R6193 net@2392#1pin@727_polysilicon-1##16 net@2392#1pin@727_polysilicon-1##17 9.85
R6194 net@2392#1pin@727_polysilicon-1##17 net@2392#1pin@727_polysilicon-1##18 9.85
R6195 net@2392#1pin@727_polysilicon-1##18 net@2392#1pin@727_polysilicon-1##19 9.85
R6196 net@2392#1pin@727_polysilicon-1##19 net@2392#1pin@727_polysilicon-1##20 9.85
R6197 net@2392#1pin@727_polysilicon-1##20 net@2392#1pin@727_polysilicon-1##21 9.85
R6198 net@2392#1pin@727_polysilicon-1##21 net@2392#1pin@727_polysilicon-1##22 9.85
R6199 net@2392#1pin@727_polysilicon-1##22 net@2392#1pin@727_polysilicon-1##23 9.85
R6200 net@2392#1pin@727_polysilicon-1##23 net@2392#1pin@727_polysilicon-1##24 9.85
R6201 net@2392#1pin@727_polysilicon-1##24 net@2392#1pin@727_polysilicon-1##25 9.85
R6202 net@2392#1pin@727_polysilicon-1##25 net@2392#1pin@727_polysilicon-1##26 9.85
R6203 net@2392#1pin@727_polysilicon-1##26 net@2392#1pin@727_polysilicon-1##27 9.85
R6204 net@2392#1pin@727_polysilicon-1##27 net@2392#1pin@727_polysilicon-1##28 9.85
R6205 net@2392#1pin@727_polysilicon-1##28 net@2392#1pin@727_polysilicon-1##29 9.85
R6206 net@2392#1pin@727_polysilicon-1##29 net@2392#1pin@727_polysilicon-1##30 9.85
R6207 net@2392#1pin@727_polysilicon-1##30 net@2392#1pin@727_polysilicon-1##31 9.85
R6208 net@2392#1pin@727_polysilicon-1##31 net@2392#1pin@727_polysilicon-1##32 9.85
R6209 net@2392#1pin@727_polysilicon-1##32 net@2392#1pin@727_polysilicon-1##33 9.85
R6210 net@2392#1pin@727_polysilicon-1##33 net@2392#1pin@727_polysilicon-1##34 9.85
R6211 net@2392#1pin@727_polysilicon-1##34 net@2392#1pin@727_polysilicon-1##35 9.85
R6212 net@2392#1pin@727_polysilicon-1##35 net@2392#1pin@727_polysilicon-1##36 9.85
R6213 net@2392#1pin@727_polysilicon-1##36 net@2392#1pin@727_polysilicon-1##37 9.85
R6214 net@2392#1pin@727_polysilicon-1##37 net@2392#1pin@727_polysilicon-1##38 9.85
R6215 net@2392#1pin@727_polysilicon-1##38 net@2392#1pin@727_polysilicon-1##39 9.85
R6216 net@2392#1pin@727_polysilicon-1##39 net@2392#1pin@727_polysilicon-1##40 9.85
R6217 net@2392#1pin@727_polysilicon-1##40 net@2392#1pin@727_polysilicon-1##41 9.85
R6218 net@2392#1pin@727_polysilicon-1##41 net@2392#1pin@727_polysilicon-1##42 9.85
R6219 net@2392#1pin@727_polysilicon-1##42 net@2392#1pin@727_polysilicon-1##43 9.85
R6220 net@2392#1pin@727_polysilicon-1##43 net@2392#1pin@727_polysilicon-1##44 9.85
R6221 net@2392#1pin@727_polysilicon-1##44 net@2392#1pin@727_polysilicon-1##45 9.85
R6222 net@2392#1pin@727_polysilicon-1##45 net@2392#1pin@727_polysilicon-1##46 9.85
R6223 net@2392#1pin@727_polysilicon-1##46 net@2392#1pin@727_polysilicon-1##47 9.85
R6224 net@2392#1pin@727_polysilicon-1##47 net@2392#1pin@727_polysilicon-1##48 9.85
R6225 net@2392#1pin@727_polysilicon-1##48 net@2392#1pin@727_polysilicon-1##49 9.85
R6226 net@2392#1pin@727_polysilicon-1##49 net@2392#1pin@727_polysilicon-1##50 9.85
R6227 net@2392#1pin@727_polysilicon-1##50 net@2392#1pin@727_polysilicon-1##51 9.85
R6228 net@2392#1pin@727_polysilicon-1##51 net@2392#1pin@727_polysilicon-1##52 9.85
R6229 net@2392#1pin@727_polysilicon-1##52 net@2392#1pin@727_polysilicon-1##53 9.85
R6230 net@2392#1pin@727_polysilicon-1##53 net@2392#1pin@727_polysilicon-1##54 9.85
R6231 net@2392#1pin@727_polysilicon-1##54 net@2392#1pin@727_polysilicon-1##55 9.85
R6232 net@2392#1pin@727_polysilicon-1##55 net@2392#1pin@727_polysilicon-1##56 9.85
R6233 net@2392#1pin@727_polysilicon-1##56 net@2392#1pin@727_polysilicon-1##57 9.85
R6234 net@2392#1pin@727_polysilicon-1##57 net@2392#1pin@727_polysilicon-1##58 9.85
R6235 net@2392#1pin@727_polysilicon-1##58 net@2392#1pin@727_polysilicon-1##59 9.85
R6236 net@2392#1pin@727_polysilicon-1##59 net@2392#1pin@727_polysilicon-1##60 9.85
R6237 net@2392#1pin@727_polysilicon-1##60 net@2392#2pin@717_metal-1 9.85
R6238 B4#17pmos@124_poly-right B4#17pmos@124_poly-right##0 9.854
R6239 B4#17pmos@124_poly-right##0 B4#17pmos@124_poly-right##1 9.854
R6240 B4#17pmos@124_poly-right##1 B4#17pmos@124_poly-right##2 9.854
R6241 B4#17pmos@124_poly-right##2 B4#17pmos@124_poly-right##3 9.854
R6242 B4#17pmos@124_poly-right##3 B4#17pmos@124_poly-right##4 9.854
R6243 B4#17pmos@124_poly-right##4 B4#17pmos@124_poly-right##5 9.854
R6244 B4#17pmos@124_poly-right##5 B4#17pmos@124_poly-right##6 9.854
R6245 B4#17pmos@124_poly-right##6 B4#17pmos@124_poly-right##7 9.854
R6246 B4#17pmos@124_poly-right##7 B4#17pmos@124_poly-right##8 9.854
R6247 B4#17pmos@124_poly-right##8 B4#17pmos@124_poly-right##9 9.854
R6248 B4#17pmos@124_poly-right##9 B4#17pmos@124_poly-right##10 9.854
R6249 B4#17pmos@124_poly-right##10 B4#17pmos@124_poly-right##11 9.854
R6250 B4#17pmos@124_poly-right##11 B4#17pmos@124_poly-right##12 9.854
R6251 B4#17pmos@124_poly-right##12 B4#17pmos@124_poly-right##13 9.854
R6252 B4#17pmos@124_poly-right##13 B4#17pmos@124_poly-right##14 9.854
R6253 B4#17pmos@124_poly-right##14 B4#17pmos@124_poly-right##15 9.854
R6254 B4#17pmos@124_poly-right##15 B4#17pmos@124_poly-right##16 9.854
R6255 B4#17pmos@124_poly-right##16 B4#17pmos@124_poly-right##17 9.854
R6256 B4#17pmos@124_poly-right##17 B4#17pmos@124_poly-right##18 9.854
R6257 B4#17pmos@124_poly-right##18 B4#17pmos@124_poly-right##19 9.854
R6258 B4#17pmos@124_poly-right##19 B4#17pmos@124_poly-right##20 9.854
R6259 B4#17pmos@124_poly-right##20 B4#17pmos@124_poly-right##21 9.854
R6260 B4#17pmos@124_poly-right##21 B4#17pmos@124_poly-right##22 9.854
R6261 B4#17pmos@124_poly-right##22 B4#17pmos@124_poly-right##23 9.854
R6262 B4#17pmos@124_poly-right##23 B4#17pmos@124_poly-right##24 9.854
R6263 B4#17pmos@124_poly-right##24 B4#17pmos@124_poly-right##25 9.854
R6264 B4#17pmos@124_poly-right##25 B4#17pmos@124_poly-right##26 9.854
R6265 B4#17pmos@124_poly-right##26 B4#17pmos@124_poly-right##27 9.854
R6266 B4#17pmos@124_poly-right##27 B4#17pmos@124_poly-right##28 9.854
R6267 B4#17pmos@124_poly-right##28 B4#17pmos@124_poly-right##29 9.854
R6268 B4#17pmos@124_poly-right##29 B4#17pmos@124_poly-right##30 9.854
R6269 B4#17pmos@124_poly-right##30 B4#17pmos@124_poly-right##31 9.854
R6270 B4#17pmos@124_poly-right##31 B4#17pmos@124_poly-right##32 9.854
R6271 B4#17pmos@124_poly-right##32 B4#17pmos@124_poly-right##33 9.854
R6272 B4#17pmos@124_poly-right##33 B4#17pmos@124_poly-right##34 9.854
R6273 B4#17pmos@124_poly-right##34 B4#17pmos@124_poly-right##35 9.854
R6274 B4#17pmos@124_poly-right##35 B4#17pmos@124_poly-right##36 9.854
R6275 B4#17pmos@124_poly-right##36 B4#17pmos@124_poly-right##37 9.854
R6276 B4#17pmos@124_poly-right##37 B4#17pmos@124_poly-right##38 9.854
R6277 B4#17pmos@124_poly-right##38 B4#17pmos@124_poly-right##39 9.854
R6278 B4#17pmos@124_poly-right##39 B4#17pmos@124_poly-right##40 9.854
R6279 B4#17pmos@124_poly-right##40 B4#17pmos@124_poly-right##41 9.854
R6280 B4#17pmos@124_poly-right##41 B4#17pmos@124_poly-right##42 9.854
R6281 B4#17pmos@124_poly-right##42 B4#17pmos@124_poly-right##43 9.854
R6282 B4#17pmos@124_poly-right##43 B4#17pmos@124_poly-right##44 9.854
R6283 B4#17pmos@124_poly-right##44 B4#17pmos@124_poly-right##45 9.854
R6284 B4#17pmos@124_poly-right##45 B4#17pmos@124_poly-right##46 9.854
R6285 B4#17pmos@124_poly-right##46 B4#17pmos@124_poly-right##47 9.854
R6286 B4#17pmos@124_poly-right##47 B4#17pmos@124_poly-right##48 9.854
R6287 B4#17pmos@124_poly-right##48 B4#17pmos@124_poly-right##49 9.854
R6288 B4#17pmos@124_poly-right##49 B4#17pmos@124_poly-right##50 9.854
R6289 B4#17pmos@124_poly-right##50 B4#17pmos@124_poly-right##51 9.854
R6290 B4#17pmos@124_poly-right##51 B4#17pmos@124_poly-right##52 9.854
R6291 B4#17pmos@124_poly-right##52 B4#17pmos@124_poly-right##53 9.854
R6292 B4#17pmos@124_poly-right##53 B4#17pmos@124_poly-right##54 9.854
R6293 B4#17pmos@124_poly-right##54 B4#12pin@718_polysilicon-1 9.854
R6294 net@2497 net@2497#2contact@798_metal-1-metal-2 4.797
R6295 A4#17nmos@120_poly-right A4#17nmos@120_poly-right##0 9.871
R6296 A4#17nmos@120_poly-right##0 A4#17nmos@120_poly-right##1 9.871
R6297 A4#17nmos@120_poly-right##1 A4#17nmos@120_poly-right##2 9.871
R6298 A4#17nmos@120_poly-right##2 A4#17nmos@120_poly-right##3 9.871
R6299 A4#17nmos@120_poly-right##3 A4#17nmos@120_poly-right##4 9.871
R6300 A4#17nmos@120_poly-right##4 A4#17nmos@120_poly-right##5 9.871
R6301 A4#17nmos@120_poly-right##5 A4#17nmos@120_poly-right##6 9.871
R6302 A4#17nmos@120_poly-right##6 A4#17nmos@120_poly-right##7 9.871
R6303 A4#17nmos@120_poly-right##7 A4#17nmos@120_poly-right##8 9.871
R6304 A4#17nmos@120_poly-right##8 A4#17nmos@120_poly-right##9 9.871
R6305 A4#17nmos@120_poly-right##9 A4#17nmos@120_poly-right##10 9.871
R6306 A4#17nmos@120_poly-right##10 A4#17nmos@120_poly-right##11 9.871
R6307 A4#17nmos@120_poly-right##11 A4#17nmos@120_poly-right##12 9.871
R6308 A4#17nmos@120_poly-right##12 A4#17nmos@120_poly-right##13 9.871
R6309 A4#17nmos@120_poly-right##13 A4#17nmos@120_poly-right##14 9.871
R6310 A4#17nmos@120_poly-right##14 A4#17nmos@120_poly-right##15 9.871
R6311 A4#17nmos@120_poly-right##15 A4#17nmos@120_poly-right##16 9.871
R6312 A4#17nmos@120_poly-right##16 A4#17nmos@120_poly-right##17 9.871
R6313 A4#17nmos@120_poly-right##17 A4#17nmos@120_poly-right##18 9.871
R6314 A4#17nmos@120_poly-right##18 A4#17nmos@120_poly-right##19 9.871
R6315 A4#17nmos@120_poly-right##19 A4#17nmos@120_poly-right##20 9.871
R6316 A4#17nmos@120_poly-right##20 A4#17nmos@120_poly-right##21 9.871
R6317 A4#17nmos@120_poly-right##21 A4#17nmos@120_poly-right##22 9.871
R6318 A4#17nmos@120_poly-right##22 A4#17nmos@120_poly-right##23 9.871
R6319 A4#17nmos@120_poly-right##23 A4#17nmos@120_poly-right##24 9.871
R6320 A4#17nmos@120_poly-right##24 A4#17nmos@120_poly-right##25 9.871
R6321 A4#17nmos@120_poly-right##25 A4#17nmos@120_poly-right##26 9.871
R6322 A4#17nmos@120_poly-right##26 A4#17nmos@120_poly-right##27 9.871
R6323 A4#17nmos@120_poly-right##27 A4#17nmos@120_poly-right##28 9.871
R6324 A4#17nmos@120_poly-right##28 A4#17nmos@120_poly-right##29 9.871
R6325 A4#17nmos@120_poly-right##29 A4#17nmos@120_poly-right##30 9.871
R6326 A4#17nmos@120_poly-right##30 A4#17nmos@120_poly-right##31 9.871
R6327 A4#17nmos@120_poly-right##31 A4#17nmos@120_poly-right##32 9.871
R6328 A4#17nmos@120_poly-right##32 A4#17nmos@120_poly-right##33 9.871
R6329 A4#17nmos@120_poly-right##33 A4#17nmos@120_poly-right##34 9.871
R6330 A4#17nmos@120_poly-right##34 A4#17nmos@120_poly-right##35 9.871
R6331 A4#17nmos@120_poly-right##35 A4#17nmos@120_poly-right##36 9.871
R6332 A4#17nmos@120_poly-right##36 A4#17nmos@120_poly-right##37 9.871
R6333 A4#17nmos@120_poly-right##37 A4#17nmos@120_poly-right##38 9.871
R6334 A4#17nmos@120_poly-right##38 A4#17nmos@120_poly-right##39 9.871
R6335 A4#17nmos@120_poly-right##39 A4#17nmos@120_poly-right##40 9.871
R6336 A4#17nmos@120_poly-right##40 A4#17nmos@120_poly-right##41 9.871
R6337 A4#17nmos@120_poly-right##41 A4#17nmos@120_poly-right##42 9.871
R6338 A4#17nmos@120_poly-right##42 A4#17nmos@120_poly-right##43 9.871
R6339 A4#17nmos@120_poly-right##43 A4#17nmos@120_poly-right##44 9.871
R6340 A4#17nmos@120_poly-right##44 A4#17nmos@120_poly-right##45 9.871
R6341 A4#17nmos@120_poly-right##45 A4#17nmos@120_poly-right##46 9.871
R6342 A4#17nmos@120_poly-right##46 A4#17nmos@120_poly-right##47 9.871
R6343 A4#17nmos@120_poly-right##47 A4#17nmos@120_poly-right##48 9.871
R6344 A4#17nmos@120_poly-right##48 A4#17nmos@120_poly-right##49 9.871
R6345 A4#17nmos@120_poly-right##49 A4#17nmos@120_poly-right##50 9.871
R6346 A4#17nmos@120_poly-right##50 A4#17nmos@120_poly-right##51 9.871
R6347 A4#17nmos@120_poly-right##51 A4#17nmos@120_poly-right##52 9.871
R6348 A4#17nmos@120_poly-right##52 A4#17nmos@120_poly-right##53 9.871
R6349 A4#17nmos@120_poly-right##53 A4#17nmos@120_poly-right##54 9.871
R6350 A4#17nmos@120_poly-right##54 A4#17nmos@120_poly-right##55 9.871
R6351 A4#17nmos@120_poly-right##55 A4#12pmos@120_poly-left 9.871
R6352 net@2392#7pmos@121_poly-left net@2392#7pmos@121_poly-left##0 9.871
R6353 net@2392#7pmos@121_poly-left##0 net@2392#7pmos@121_poly-left##1 9.871
R6354 net@2392#7pmos@121_poly-left##1 net@2392#7pmos@121_poly-left##2 9.871
R6355 net@2392#7pmos@121_poly-left##2 net@2392#7pmos@121_poly-left##3 9.871
R6356 net@2392#7pmos@121_poly-left##3 net@2392#7pmos@121_poly-left##4 9.871
R6357 net@2392#7pmos@121_poly-left##4 net@2392#7pmos@121_poly-left##5 9.871
R6358 net@2392#7pmos@121_poly-left##5 net@2392#7pmos@121_poly-left##6 9.871
R6359 net@2392#7pmos@121_poly-left##6 net@2392#7pmos@121_poly-left##7 9.871
R6360 net@2392#7pmos@121_poly-left##7 net@2392#7pmos@121_poly-left##8 9.871
R6361 net@2392#7pmos@121_poly-left##8 net@2392#7pmos@121_poly-left##9 9.871
R6362 net@2392#7pmos@121_poly-left##9 net@2392#7pmos@121_poly-left##10 9.871
R6363 net@2392#7pmos@121_poly-left##10 net@2392#7pmos@121_poly-left##11 9.871
R6364 net@2392#7pmos@121_poly-left##11 net@2392#7pmos@121_poly-left##12 9.871
R6365 net@2392#7pmos@121_poly-left##12 net@2392#7pmos@121_poly-left##13 9.871
R6366 net@2392#7pmos@121_poly-left##13 net@2392#7pmos@121_poly-left##14 9.871
R6367 net@2392#7pmos@121_poly-left##14 net@2392#7pmos@121_poly-left##15 9.871
R6368 net@2392#7pmos@121_poly-left##15 net@2392#7pmos@121_poly-left##16 9.871
R6369 net@2392#7pmos@121_poly-left##16 net@2392#7pmos@121_poly-left##17 9.871
R6370 net@2392#7pmos@121_poly-left##17 net@2392#7pmos@121_poly-left##18 9.871
R6371 net@2392#7pmos@121_poly-left##18 net@2392#7pmos@121_poly-left##19 9.871
R6372 net@2392#7pmos@121_poly-left##19 net@2392#7pmos@121_poly-left##20 9.871
R6373 net@2392#7pmos@121_poly-left##20 net@2392#7pmos@121_poly-left##21 9.871
R6374 net@2392#7pmos@121_poly-left##21 net@2392#7pmos@121_poly-left##22 9.871
R6375 net@2392#7pmos@121_poly-left##22 net@2392#7pmos@121_poly-left##23 9.871
R6376 net@2392#7pmos@121_poly-left##23 net@2392#7pmos@121_poly-left##24 9.871
R6377 net@2392#7pmos@121_poly-left##24 net@2392#7pmos@121_poly-left##25 9.871
R6378 net@2392#7pmos@121_poly-left##25 net@2392#7pmos@121_poly-left##26 9.871
R6379 net@2392#7pmos@121_poly-left##26 net@2392#7pmos@121_poly-left##27 9.871
R6380 net@2392#7pmos@121_poly-left##27 net@2392#7pmos@121_poly-left##28 9.871
R6381 net@2392#7pmos@121_poly-left##28 net@2392#7pmos@121_poly-left##29 9.871
R6382 net@2392#7pmos@121_poly-left##29 net@2392#7pmos@121_poly-left##30 9.871
R6383 net@2392#7pmos@121_poly-left##30 net@2392#7pmos@121_poly-left##31 9.871
R6384 net@2392#7pmos@121_poly-left##31 net@2392#7pmos@121_poly-left##32 9.871
R6385 net@2392#7pmos@121_poly-left##32 net@2392#7pmos@121_poly-left##33 9.871
R6386 net@2392#7pmos@121_poly-left##33 net@2392#7pmos@121_poly-left##34 9.871
R6387 net@2392#7pmos@121_poly-left##34 net@2392#7pmos@121_poly-left##35 9.871
R6388 net@2392#7pmos@121_poly-left##35 net@2392#7pmos@121_poly-left##36 9.871
R6389 net@2392#7pmos@121_poly-left##36 net@2392#7pmos@121_poly-left##37 9.871
R6390 net@2392#7pmos@121_poly-left##37 net@2392#7pmos@121_poly-left##38 9.871
R6391 net@2392#7pmos@121_poly-left##38 net@2392#7pmos@121_poly-left##39 9.871
R6392 net@2392#7pmos@121_poly-left##39 net@2392#7pmos@121_poly-left##40 9.871
R6393 net@2392#7pmos@121_poly-left##40 net@2392#7pmos@121_poly-left##41 9.871
R6394 net@2392#7pmos@121_poly-left##41 net@2392#7pmos@121_poly-left##42 9.871
R6395 net@2392#7pmos@121_poly-left##42 net@2392#7pmos@121_poly-left##43 9.871
R6396 net@2392#7pmos@121_poly-left##43 net@2392#7pmos@121_poly-left##44 9.871
R6397 net@2392#7pmos@121_poly-left##44 net@2392#7pmos@121_poly-left##45 9.871
R6398 net@2392#7pmos@121_poly-left##45 net@2392#7pmos@121_poly-left##46 9.871
R6399 net@2392#7pmos@121_poly-left##46 net@2392#7pmos@121_poly-left##47 9.871
R6400 net@2392#7pmos@121_poly-left##47 net@2392#7pmos@121_poly-left##48 9.871
R6401 net@2392#7pmos@121_poly-left##48 net@2392#7pmos@121_poly-left##49 9.871
R6402 net@2392#7pmos@121_poly-left##49 net@2392#7pmos@121_poly-left##50 9.871
R6403 net@2392#7pmos@121_poly-left##50 net@2392#7pmos@121_poly-left##51 9.871
R6404 net@2392#7pmos@121_poly-left##51 net@2392#7pmos@121_poly-left##52 9.871
R6405 net@2392#7pmos@121_poly-left##52 net@2392#7pmos@121_poly-left##53 9.871
R6406 net@2392#7pmos@121_poly-left##53 net@2392#7pmos@121_poly-left##54 9.871
R6407 net@2392#7pmos@121_poly-left##54 net@2392#7pmos@121_poly-left##55 9.871
R6408 net@2392#7pmos@121_poly-left##55 net@2392#11nmos@121_poly-right 9.871
R6409 B4#18pmos@122_poly-right B4#18pmos@122_poly-right##0 9.871
R6410 B4#18pmos@122_poly-right##0 B4#18pmos@122_poly-right##1 9.871
R6411 B4#18pmos@122_poly-right##1 B4#18pmos@122_poly-right##2 9.871
R6412 B4#18pmos@122_poly-right##2 B4#18pmos@122_poly-right##3 9.871
R6413 B4#18pmos@122_poly-right##3 B4#18pmos@122_poly-right##4 9.871
R6414 B4#18pmos@122_poly-right##4 B4#18pmos@122_poly-right##5 9.871
R6415 B4#18pmos@122_poly-right##5 B4#18pmos@122_poly-right##6 9.871
R6416 B4#18pmos@122_poly-right##6 B4#18pmos@122_poly-right##7 9.871
R6417 B4#18pmos@122_poly-right##7 B4#18pmos@122_poly-right##8 9.871
R6418 B4#18pmos@122_poly-right##8 B4#18pmos@122_poly-right##9 9.871
R6419 B4#18pmos@122_poly-right##9 B4#18pmos@122_poly-right##10 9.871
R6420 B4#18pmos@122_poly-right##10 B4#18pmos@122_poly-right##11 9.871
R6421 B4#18pmos@122_poly-right##11 B4#18pmos@122_poly-right##12 9.871
R6422 B4#18pmos@122_poly-right##12 B4#18pmos@122_poly-right##13 9.871
R6423 B4#18pmos@122_poly-right##13 B4#18pmos@122_poly-right##14 9.871
R6424 B4#18pmos@122_poly-right##14 B4#18pmos@122_poly-right##15 9.871
R6425 B4#18pmos@122_poly-right##15 B4#18pmos@122_poly-right##16 9.871
R6426 B4#18pmos@122_poly-right##16 B4#18pmos@122_poly-right##17 9.871
R6427 B4#18pmos@122_poly-right##17 B4#18pmos@122_poly-right##18 9.871
R6428 B4#18pmos@122_poly-right##18 B4#18pmos@122_poly-right##19 9.871
R6429 B4#18pmos@122_poly-right##19 B4#18pmos@122_poly-right##20 9.871
R6430 B4#18pmos@122_poly-right##20 B4#18pmos@122_poly-right##21 9.871
R6431 B4#18pmos@122_poly-right##21 B4#18pmos@122_poly-right##22 9.871
R6432 B4#18pmos@122_poly-right##22 B4#18pmos@122_poly-right##23 9.871
R6433 B4#18pmos@122_poly-right##23 B4#18pmos@122_poly-right##24 9.871
R6434 B4#18pmos@122_poly-right##24 B4#18pmos@122_poly-right##25 9.871
R6435 B4#18pmos@122_poly-right##25 B4#18pmos@122_poly-right##26 9.871
R6436 B4#18pmos@122_poly-right##26 B4#18pmos@122_poly-right##27 9.871
R6437 B4#18pmos@122_poly-right##27 B4#18pmos@122_poly-right##28 9.871
R6438 B4#18pmos@122_poly-right##28 B4#18pmos@122_poly-right##29 9.871
R6439 B4#18pmos@122_poly-right##29 B4#18pmos@122_poly-right##30 9.871
R6440 B4#18pmos@122_poly-right##30 B4#18pmos@122_poly-right##31 9.871
R6441 B4#18pmos@122_poly-right##31 B4#18pmos@122_poly-right##32 9.871
R6442 B4#18pmos@122_poly-right##32 B4#18pmos@122_poly-right##33 9.871
R6443 B4#18pmos@122_poly-right##33 B4#18pmos@122_poly-right##34 9.871
R6444 B4#18pmos@122_poly-right##34 B4#18pmos@122_poly-right##35 9.871
R6445 B4#18pmos@122_poly-right##35 B4#18pmos@122_poly-right##36 9.871
R6446 B4#18pmos@122_poly-right##36 B4#18pmos@122_poly-right##37 9.871
R6447 B4#18pmos@122_poly-right##37 B4#18pmos@122_poly-right##38 9.871
R6448 B4#18pmos@122_poly-right##38 B4#18pmos@122_poly-right##39 9.871
R6449 B4#18pmos@122_poly-right##39 B4#18pmos@122_poly-right##40 9.871
R6450 B4#18pmos@122_poly-right##40 B4#18pmos@122_poly-right##41 9.871
R6451 B4#18pmos@122_poly-right##41 B4#18pmos@122_poly-right##42 9.871
R6452 B4#18pmos@122_poly-right##42 B4#18pmos@122_poly-right##43 9.871
R6453 B4#18pmos@122_poly-right##43 B4#18pmos@122_poly-right##44 9.871
R6454 B4#18pmos@122_poly-right##44 B4#18pmos@122_poly-right##45 9.871
R6455 B4#18pmos@122_poly-right##45 B4#18pmos@122_poly-right##46 9.871
R6456 B4#18pmos@122_poly-right##46 B4#18pmos@122_poly-right##47 9.871
R6457 B4#18pmos@122_poly-right##47 B4#18pmos@122_poly-right##48 9.871
R6458 B4#18pmos@122_poly-right##48 B4#18pmos@122_poly-right##49 9.871
R6459 B4#18pmos@122_poly-right##49 B4#18pmos@122_poly-right##50 9.871
R6460 B4#18pmos@122_poly-right##50 B4#18pmos@122_poly-right##51 9.871
R6461 B4#18pmos@122_poly-right##51 B4#18pmos@122_poly-right##52 9.871
R6462 B4#18pmos@122_poly-right##52 B4#18pmos@122_poly-right##53 9.871
R6463 B4#18pmos@122_poly-right##53 B4#18pmos@122_poly-right##54 9.871
R6464 B4#18pmos@122_poly-right##54 B4#18pmos@122_poly-right##55 9.871
R6465 B4#18pmos@122_poly-right##55 B4#16nmos@122_poly-left 9.871
R6466 net@2497#14pmos@123_poly-right net@2497#14pmos@123_poly-right##0 9.871
R6467 net@2497#14pmos@123_poly-right##0 net@2497#14pmos@123_poly-right##1 9.871
R6468 net@2497#14pmos@123_poly-right##1 net@2497#14pmos@123_poly-right##2 9.871
R6469 net@2497#14pmos@123_poly-right##2 net@2497#14pmos@123_poly-right##3 9.871
R6470 net@2497#14pmos@123_poly-right##3 net@2497#14pmos@123_poly-right##4 9.871
R6471 net@2497#14pmos@123_poly-right##4 net@2497#14pmos@123_poly-right##5 9.871
R6472 net@2497#14pmos@123_poly-right##5 net@2497#14pmos@123_poly-right##6 9.871
R6473 net@2497#14pmos@123_poly-right##6 net@2497#14pmos@123_poly-right##7 9.871
R6474 net@2497#14pmos@123_poly-right##7 net@2497#14pmos@123_poly-right##8 9.871
R6475 net@2497#14pmos@123_poly-right##8 net@2497#14pmos@123_poly-right##9 9.871
R6476 net@2497#14pmos@123_poly-right##9 net@2497#14pmos@123_poly-right##10 9.871
R6477 net@2497#14pmos@123_poly-right##10 net@2497#14pmos@123_poly-right##11 9.871
R6478 net@2497#14pmos@123_poly-right##11 net@2497#14pmos@123_poly-right##12 9.871
R6479 net@2497#14pmos@123_poly-right##12 net@2497#14pmos@123_poly-right##13 9.871
R6480 net@2497#14pmos@123_poly-right##13 net@2497#14pmos@123_poly-right##14 9.871
R6481 net@2497#14pmos@123_poly-right##14 net@2497#14pmos@123_poly-right##15 9.871
R6482 net@2497#14pmos@123_poly-right##15 net@2497#14pmos@123_poly-right##16 9.871
R6483 net@2497#14pmos@123_poly-right##16 net@2497#14pmos@123_poly-right##17 9.871
R6484 net@2497#14pmos@123_poly-right##17 net@2497#14pmos@123_poly-right##18 9.871
R6485 net@2497#14pmos@123_poly-right##18 net@2497#14pmos@123_poly-right##19 9.871
R6486 net@2497#14pmos@123_poly-right##19 net@2497#14pmos@123_poly-right##20 9.871
R6487 net@2497#14pmos@123_poly-right##20 net@2497#14pmos@123_poly-right##21 9.871
R6488 net@2497#14pmos@123_poly-right##21 net@2497#14pmos@123_poly-right##22 9.871
R6489 net@2497#14pmos@123_poly-right##22 net@2497#14pmos@123_poly-right##23 9.871
R6490 net@2497#14pmos@123_poly-right##23 net@2497#14pmos@123_poly-right##24 9.871
R6491 net@2497#14pmos@123_poly-right##24 net@2497#14pmos@123_poly-right##25 9.871
R6492 net@2497#14pmos@123_poly-right##25 net@2497#14pmos@123_poly-right##26 9.871
R6493 net@2497#14pmos@123_poly-right##26 net@2497#14pmos@123_poly-right##27 9.871
R6494 net@2497#14pmos@123_poly-right##27 net@2497#14pmos@123_poly-right##28 9.871
R6495 net@2497#14pmos@123_poly-right##28 net@2497#14pmos@123_poly-right##29 9.871
R6496 net@2497#14pmos@123_poly-right##29 net@2497#14pmos@123_poly-right##30 9.871
R6497 net@2497#14pmos@123_poly-right##30 net@2497#14pmos@123_poly-right##31 9.871
R6498 net@2497#14pmos@123_poly-right##31 net@2497#14pmos@123_poly-right##32 9.871
R6499 net@2497#14pmos@123_poly-right##32 net@2497#14pmos@123_poly-right##33 9.871
R6500 net@2497#14pmos@123_poly-right##33 net@2497#14pmos@123_poly-right##34 9.871
R6501 net@2497#14pmos@123_poly-right##34 net@2497#14pmos@123_poly-right##35 9.871
R6502 net@2497#14pmos@123_poly-right##35 net@2497#14pmos@123_poly-right##36 9.871
R6503 net@2497#14pmos@123_poly-right##36 net@2497#14pmos@123_poly-right##37 9.871
R6504 net@2497#14pmos@123_poly-right##37 net@2497#14pmos@123_poly-right##38 9.871
R6505 net@2497#14pmos@123_poly-right##38 net@2497#14pmos@123_poly-right##39 9.871
R6506 net@2497#14pmos@123_poly-right##39 net@2497#14pmos@123_poly-right##40 9.871
R6507 net@2497#14pmos@123_poly-right##40 net@2497#14pmos@123_poly-right##41 9.871
R6508 net@2497#14pmos@123_poly-right##41 net@2497#14pmos@123_poly-right##42 9.871
R6509 net@2497#14pmos@123_poly-right##42 net@2497#14pmos@123_poly-right##43 9.871
R6510 net@2497#14pmos@123_poly-right##43 net@2497#14pmos@123_poly-right##44 9.871
R6511 net@2497#14pmos@123_poly-right##44 net@2497#14pmos@123_poly-right##45 9.871
R6512 net@2497#14pmos@123_poly-right##45 net@2497#14pmos@123_poly-right##46 9.871
R6513 net@2497#14pmos@123_poly-right##46 net@2497#14pmos@123_poly-right##47 9.871
R6514 net@2497#14pmos@123_poly-right##47 net@2497#14pmos@123_poly-right##48 9.871
R6515 net@2497#14pmos@123_poly-right##48 net@2497#14pmos@123_poly-right##49 9.871
R6516 net@2497#14pmos@123_poly-right##49 net@2497#14pmos@123_poly-right##50 9.871
R6517 net@2497#14pmos@123_poly-right##50 net@2497#14pmos@123_poly-right##51 9.871
R6518 net@2497#14pmos@123_poly-right##51 net@2497#14pmos@123_poly-right##52 9.871
R6519 net@2497#14pmos@123_poly-right##52 net@2497#14pmos@123_poly-right##53 9.871
R6520 net@2497#14pmos@123_poly-right##53 net@2497#14pmos@123_poly-right##54 9.871
R6521 net@2497#14pmos@123_poly-right##54 net@2497#14pmos@123_poly-right##55 9.871
R6522 net@2497#14pmos@123_poly-right##55 net@2497#9nmos@123_poly-left 9.871
R6523 net@2490#2contact@822_metal-1-polysilicon-1 net@2490 4.706
R6524 net@2490#12pmos@126_poly-right net@2490#12pmos@126_poly-right##0 9.864
R6525 net@2490#12pmos@126_poly-right##0 net@2490#12pmos@126_poly-right##1 9.864
R6526 net@2490#12pmos@126_poly-right##1 net@2490#12pmos@126_poly-right##2 9.864
R6527 net@2490#12pmos@126_poly-right##2 net@2490#12pmos@126_poly-right##3 9.864
R6528 net@2490#12pmos@126_poly-right##3 net@2490#12pmos@126_poly-right##4 9.864
R6529 net@2490#12pmos@126_poly-right##4 net@2490#12pmos@126_poly-right##5 9.864
R6530 net@2490#12pmos@126_poly-right##5 net@2490#12pmos@126_poly-right##6 9.864
R6531 net@2490#12pmos@126_poly-right##6 net@2490#12pmos@126_poly-right##7 9.864
R6532 net@2490#12pmos@126_poly-right##7 net@2490#12pmos@126_poly-right##8 9.864
R6533 net@2490#12pmos@126_poly-right##8 net@2490#12pmos@126_poly-right##9 9.864
R6534 net@2490#12pmos@126_poly-right##9 net@2490#12pmos@126_poly-right##10 9.864
R6535 net@2490#12pmos@126_poly-right##10 net@2490#12pmos@126_poly-right##11 9.864
R6536 net@2490#12pmos@126_poly-right##11 net@2490#12pmos@126_poly-right##12 9.864
R6537 net@2490#12pmos@126_poly-right##12 net@2490#12pmos@126_poly-right##13 9.864
R6538 net@2490#12pmos@126_poly-right##13 net@2490#12pmos@126_poly-right##14 9.864
R6539 net@2490#12pmos@126_poly-right##14 net@2490#12pmos@126_poly-right##15 9.864
R6540 net@2490#12pmos@126_poly-right##15 net@2490#12pmos@126_poly-right##16 9.864
R6541 net@2490#12pmos@126_poly-right##16 net@2490#12pmos@126_poly-right##17 9.864
R6542 net@2490#12pmos@126_poly-right##17 net@2490#12pmos@126_poly-right##18 9.864
R6543 net@2490#12pmos@126_poly-right##18 net@2490#12pmos@126_poly-right##19 9.864
R6544 net@2490#12pmos@126_poly-right##19 net@2490#12pmos@126_poly-right##20 9.864
R6545 net@2490#12pmos@126_poly-right##20 net@2490#12pmos@126_poly-right##21 9.864
R6546 net@2490#12pmos@126_poly-right##21 net@2490#12pmos@126_poly-right##22 9.864
R6547 net@2490#12pmos@126_poly-right##22 net@2490#12pmos@126_poly-right##23 9.864
R6548 net@2490#12pmos@126_poly-right##23 net@2490#12pmos@126_poly-right##24 9.864
R6549 net@2490#12pmos@126_poly-right##24 net@2490#12pmos@126_poly-right##25 9.864
R6550 net@2490#12pmos@126_poly-right##25 net@2490#12pmos@126_poly-right##26 9.864
R6551 net@2490#12pmos@126_poly-right##26 net@2490#12pmos@126_poly-right##27 9.864
R6552 net@2490#12pmos@126_poly-right##27 net@2490#12pmos@126_poly-right##28 9.864
R6553 net@2490#12pmos@126_poly-right##28 net@2490#12pmos@126_poly-right##29 9.864
R6554 net@2490#12pmos@126_poly-right##29 net@2490#12pmos@126_poly-right##30 9.864
R6555 net@2490#12pmos@126_poly-right##30 net@2490#12pmos@126_poly-right##31 9.864
R6556 net@2490#12pmos@126_poly-right##31 net@2490#12pmos@126_poly-right##32 9.864
R6557 net@2490#12pmos@126_poly-right##32 net@2490#12pmos@126_poly-right##33 9.864
R6558 net@2490#12pmos@126_poly-right##33 net@2490#12pmos@126_poly-right##34 9.864
R6559 net@2490#12pmos@126_poly-right##34 net@2490#12pmos@126_poly-right##35 9.864
R6560 net@2490#12pmos@126_poly-right##35 net@2490#12pmos@126_poly-right##36 9.864
R6561 net@2490#12pmos@126_poly-right##36 net@2490#12pmos@126_poly-right##37 9.864
R6562 net@2490#12pmos@126_poly-right##37 net@2490#12pmos@126_poly-right##38 9.864
R6563 net@2490#12pmos@126_poly-right##38 net@2490#12pmos@126_poly-right##39 9.864
R6564 net@2490#12pmos@126_poly-right##39 net@2490#12pmos@126_poly-right##40 9.864
R6565 net@2490#12pmos@126_poly-right##40 net@2490#12pmos@126_poly-right##41 9.864
R6566 net@2490#12pmos@126_poly-right##41 net@2490#12pmos@126_poly-right##42 9.864
R6567 net@2490#12pmos@126_poly-right##42 net@2490#12pmos@126_poly-right##43 9.864
R6568 net@2490#12pmos@126_poly-right##43 net@2490#12pmos@126_poly-right##44 9.864
R6569 net@2490#12pmos@126_poly-right##44 net@2490#12pmos@126_poly-right##45 9.864
R6570 net@2490#12pmos@126_poly-right##45 net@2490#12pmos@126_poly-right##46 9.864
R6571 net@2490#12pmos@126_poly-right##46 net@2490#12pmos@126_poly-right##47 9.864
R6572 net@2490#12pmos@126_poly-right##47 net@2490#12pmos@126_poly-right##48 9.864
R6573 net@2490#12pmos@126_poly-right##48 net@2490#12pmos@126_poly-right##49 9.864
R6574 net@2490#12pmos@126_poly-right##49 net@2490#12pmos@126_poly-right##50 9.864
R6575 net@2490#12pmos@126_poly-right##50 net@2490#12pmos@126_poly-right##51 9.864
R6576 net@2490#12pmos@126_poly-right##51 net@2490#12pmos@126_poly-right##52 9.864
R6577 net@2490#12pmos@126_poly-right##52 net@2490#12pmos@126_poly-right##53 9.864
R6578 net@2490#12pmos@126_poly-right##53 net@2490#5pin@720_polysilicon-1 9.864
R6579 XOR1_to_NAND5#22pmos@126_diff-top XOR1_to_NAND5#1contact@875_metal-1-metal-2 4.862
R6580 XOR1_to_NAND5#3pin@753_polysilicon-1 XOR1_to_NAND5#3pin@753_polysilicon-1##0 9.881
R6581 XOR1_to_NAND5#3pin@753_polysilicon-1##0 XOR1_to_NAND5#3pin@753_polysilicon-1##1 9.881
R6582 XOR1_to_NAND5#3pin@753_polysilicon-1##1 XOR1_to_NAND5#3pin@753_polysilicon-1##2 9.881
R6583 XOR1_to_NAND5#3pin@753_polysilicon-1##2 XOR1_to_NAND5#3pin@753_polysilicon-1##3 9.881
R6584 XOR1_to_NAND5#3pin@753_polysilicon-1##3 XOR1_to_NAND5#3pin@753_polysilicon-1##4 9.881
R6585 XOR1_to_NAND5#3pin@753_polysilicon-1##4 XOR1_to_NAND5#3pin@753_polysilicon-1##5 9.881
R6586 XOR1_to_NAND5#3pin@753_polysilicon-1##5 XOR1_to_NAND5#3pin@753_polysilicon-1##6 9.881
R6587 XOR1_to_NAND5#3pin@753_polysilicon-1##6 XOR1_to_NAND5#3pin@753_polysilicon-1##7 9.881
R6588 XOR1_to_NAND5#3pin@753_polysilicon-1##7 XOR1_to_NAND5#3pin@753_polysilicon-1##8 9.881
R6589 XOR1_to_NAND5#3pin@753_polysilicon-1##8 XOR1_to_NAND5#3pin@753_polysilicon-1##9 9.881
R6590 XOR1_to_NAND5#3pin@753_polysilicon-1##9 XOR1_to_NAND5#3pin@753_polysilicon-1##10 9.881
R6591 XOR1_to_NAND5#3pin@753_polysilicon-1##10 XOR1_to_NAND5#3pin@753_polysilicon-1##11 9.881
R6592 XOR1_to_NAND5#3pin@753_polysilicon-1##11 XOR1_to_NAND5#3pin@753_polysilicon-1##12 9.881
R6593 XOR1_to_NAND5#3pin@753_polysilicon-1##12 XOR1_to_NAND5#3pin@753_polysilicon-1##13 9.881
R6594 XOR1_to_NAND5#3pin@753_polysilicon-1##13 XOR1_to_NAND5#3pin@753_polysilicon-1##14 9.881
R6595 XOR1_to_NAND5#3pin@753_polysilicon-1##14 XOR1_to_NAND5#3pin@753_polysilicon-1##15 9.881
R6596 XOR1_to_NAND5#3pin@753_polysilicon-1##15 XOR1_to_NAND5#3pin@753_polysilicon-1##16 9.881
R6597 XOR1_to_NAND5#3pin@753_polysilicon-1##16 XOR1_to_NAND5#3pin@753_polysilicon-1##17 9.881
R6598 XOR1_to_NAND5#3pin@753_polysilicon-1##17 XOR1_to_NAND5#3pin@753_polysilicon-1##18 9.881
R6599 XOR1_to_NAND5#3pin@753_polysilicon-1##18 XOR1_to_NAND5#3pin@753_polysilicon-1##19 9.881
R6600 XOR1_to_NAND5#3pin@753_polysilicon-1##19 XOR1_to_NAND5#3pin@753_polysilicon-1##20 9.881
R6601 XOR1_to_NAND5#3pin@753_polysilicon-1##20 XOR1_to_NAND5#3pin@753_polysilicon-1##21 9.881
R6602 XOR1_to_NAND5#3pin@753_polysilicon-1##21 XOR1_to_NAND5#3pin@753_polysilicon-1##22 9.881
R6603 XOR1_to_NAND5#3pin@753_polysilicon-1##22 XOR1_to_NAND5#3pin@753_polysilicon-1##23 9.881
R6604 XOR1_to_NAND5#3pin@753_polysilicon-1##23 XOR1_to_NAND5#3pin@753_polysilicon-1##24 9.881
R6605 XOR1_to_NAND5#3pin@753_polysilicon-1##24 XOR1_to_NAND5#3pin@753_polysilicon-1##25 9.881
R6606 XOR1_to_NAND5#3pin@753_polysilicon-1##25 XOR1_to_NAND5#3pin@753_polysilicon-1##26 9.881
R6607 XOR1_to_NAND5#3pin@753_polysilicon-1##26 XOR1_to_NAND5#3pin@753_polysilicon-1##27 9.881
R6608 XOR1_to_NAND5#3pin@753_polysilicon-1##27 XOR1_to_NAND5#3pin@753_polysilicon-1##28 9.881
R6609 XOR1_to_NAND5#3pin@753_polysilicon-1##28 XOR1_to_NAND5#3pin@753_polysilicon-1##29 9.881
R6610 XOR1_to_NAND5#3pin@753_polysilicon-1##29 XOR1_to_NAND5#3pin@753_polysilicon-1##30 9.881
R6611 XOR1_to_NAND5#3pin@753_polysilicon-1##30 XOR1_to_NAND5#3pin@753_polysilicon-1##31 9.881
R6612 XOR1_to_NAND5#3pin@753_polysilicon-1##31 XOR1_to_NAND5#3pin@753_polysilicon-1##32 9.881
R6613 XOR1_to_NAND5#3pin@753_polysilicon-1##32 XOR1_to_NAND5#3pin@753_polysilicon-1##33 9.881
R6614 XOR1_to_NAND5#3pin@753_polysilicon-1##33 XOR1_to_NAND5#3pin@753_polysilicon-1##34 9.881
R6615 XOR1_to_NAND5#3pin@753_polysilicon-1##34 XOR1_to_NAND5#3pin@753_polysilicon-1##35 9.881
R6616 XOR1_to_NAND5#3pin@753_polysilicon-1##35 XOR1_to_NAND5#3pin@753_polysilicon-1##36 9.881
R6617 XOR1_to_NAND5#3pin@753_polysilicon-1##36 XOR1_to_NAND5#3pin@753_polysilicon-1##37 9.881
R6618 XOR1_to_NAND5#3pin@753_polysilicon-1##37 XOR1_to_NAND5#3pin@753_polysilicon-1##38 9.881
R6619 XOR1_to_NAND5#3pin@753_polysilicon-1##38 XOR1_to_NAND5#3pin@753_polysilicon-1##39 9.881
R6620 XOR1_to_NAND5#3pin@753_polysilicon-1##39 XOR1_to_NAND5#3pin@753_polysilicon-1##40 9.881
R6621 XOR1_to_NAND5#3pin@753_polysilicon-1##40 XOR1_to_NAND5#3pin@753_polysilicon-1##41 9.881
R6622 XOR1_to_NAND5#3pin@753_polysilicon-1##41 XOR1_to_NAND5#3pin@753_polysilicon-1##42 9.881
R6623 XOR1_to_NAND5#3pin@753_polysilicon-1##42 XOR1_to_NAND5#3pin@753_polysilicon-1##43 9.881
R6624 XOR1_to_NAND5#3pin@753_polysilicon-1##43 XOR1_to_NAND5#3pin@753_polysilicon-1##44 9.881
R6625 XOR1_to_NAND5#3pin@753_polysilicon-1##44 XOR1_to_NAND5#3pin@753_polysilicon-1##45 9.881
R6626 XOR1_to_NAND5#3pin@753_polysilicon-1##45 XOR1_to_NAND5#3pin@753_polysilicon-1##46 9.881
R6627 XOR1_to_NAND5#3pin@753_polysilicon-1##46 XOR1_to_NAND5#3pin@753_polysilicon-1##47 9.881
R6628 XOR1_to_NAND5#3pin@753_polysilicon-1##47 XOR1_to_NAND5#3pin@753_polysilicon-1##48 9.881
R6629 XOR1_to_NAND5#3pin@753_polysilicon-1##48 XOR1_to_NAND5#3pin@753_polysilicon-1##49 9.881
R6630 XOR1_to_NAND5#3pin@753_polysilicon-1##49 XOR1_to_NAND5#3pin@753_polysilicon-1##50 9.881
R6631 XOR1_to_NAND5#3pin@753_polysilicon-1##50 XOR1_to_NAND5#3pin@753_polysilicon-1##51 9.881
R6632 XOR1_to_NAND5#3pin@753_polysilicon-1##51 XOR1_to_NAND5#3pin@753_polysilicon-1##52 9.881
R6633 XOR1_to_NAND5#3pin@753_polysilicon-1##52 XOR1_to_NAND5#3pin@753_polysilicon-1##53 9.881
R6634 XOR1_to_NAND5#3pin@753_polysilicon-1##53 XOR1_to_NAND5#3pin@753_polysilicon-1##54 9.881
R6635 XOR1_to_NAND5#3pin@753_polysilicon-1##54 XOR1_to_NAND5#24nmos@132_poly-right 9.881
R6636 net@2394#5pmos@132_diff-top net@2394#2pin@742_metal-1 4.81
R6637 net@2394#1pin@752_polysilicon-1 net@2394#1pin@752_polysilicon-1##0 9.85
R6638 net@2394#1pin@752_polysilicon-1##0 net@2394#1pin@752_polysilicon-1##1 9.85
R6639 net@2394#1pin@752_polysilicon-1##1 net@2394#1pin@752_polysilicon-1##2 9.85
R6640 net@2394#1pin@752_polysilicon-1##2 net@2394#1pin@752_polysilicon-1##3 9.85
R6641 net@2394#1pin@752_polysilicon-1##3 net@2394#1pin@752_polysilicon-1##4 9.85
R6642 net@2394#1pin@752_polysilicon-1##4 net@2394#1pin@752_polysilicon-1##5 9.85
R6643 net@2394#1pin@752_polysilicon-1##5 net@2394#1pin@752_polysilicon-1##6 9.85
R6644 net@2394#1pin@752_polysilicon-1##6 net@2394#1pin@752_polysilicon-1##7 9.85
R6645 net@2394#1pin@752_polysilicon-1##7 net@2394#1pin@752_polysilicon-1##8 9.85
R6646 net@2394#1pin@752_polysilicon-1##8 net@2394#1pin@752_polysilicon-1##9 9.85
R6647 net@2394#1pin@752_polysilicon-1##9 net@2394#1pin@752_polysilicon-1##10 9.85
R6648 net@2394#1pin@752_polysilicon-1##10 net@2394#1pin@752_polysilicon-1##11 9.85
R6649 net@2394#1pin@752_polysilicon-1##11 net@2394#1pin@752_polysilicon-1##12 9.85
R6650 net@2394#1pin@752_polysilicon-1##12 net@2394#1pin@752_polysilicon-1##13 9.85
R6651 net@2394#1pin@752_polysilicon-1##13 net@2394#1pin@752_polysilicon-1##14 9.85
R6652 net@2394#1pin@752_polysilicon-1##14 net@2394#1pin@752_polysilicon-1##15 9.85
R6653 net@2394#1pin@752_polysilicon-1##15 net@2394#1pin@752_polysilicon-1##16 9.85
R6654 net@2394#1pin@752_polysilicon-1##16 net@2394#1pin@752_polysilicon-1##17 9.85
R6655 net@2394#1pin@752_polysilicon-1##17 net@2394#1pin@752_polysilicon-1##18 9.85
R6656 net@2394#1pin@752_polysilicon-1##18 net@2394#1pin@752_polysilicon-1##19 9.85
R6657 net@2394#1pin@752_polysilicon-1##19 net@2394#1pin@752_polysilicon-1##20 9.85
R6658 net@2394#1pin@752_polysilicon-1##20 net@2394#1pin@752_polysilicon-1##21 9.85
R6659 net@2394#1pin@752_polysilicon-1##21 net@2394#1pin@752_polysilicon-1##22 9.85
R6660 net@2394#1pin@752_polysilicon-1##22 net@2394#1pin@752_polysilicon-1##23 9.85
R6661 net@2394#1pin@752_polysilicon-1##23 net@2394#1pin@752_polysilicon-1##24 9.85
R6662 net@2394#1pin@752_polysilicon-1##24 net@2394#1pin@752_polysilicon-1##25 9.85
R6663 net@2394#1pin@752_polysilicon-1##25 net@2394#1pin@752_polysilicon-1##26 9.85
R6664 net@2394#1pin@752_polysilicon-1##26 net@2394#1pin@752_polysilicon-1##27 9.85
R6665 net@2394#1pin@752_polysilicon-1##27 net@2394#1pin@752_polysilicon-1##28 9.85
R6666 net@2394#1pin@752_polysilicon-1##28 net@2394#1pin@752_polysilicon-1##29 9.85
R6667 net@2394#1pin@752_polysilicon-1##29 net@2394#1pin@752_polysilicon-1##30 9.85
R6668 net@2394#1pin@752_polysilicon-1##30 net@2394#1pin@752_polysilicon-1##31 9.85
R6669 net@2394#1pin@752_polysilicon-1##31 net@2394#1pin@752_polysilicon-1##32 9.85
R6670 net@2394#1pin@752_polysilicon-1##32 net@2394#1pin@752_polysilicon-1##33 9.85
R6671 net@2394#1pin@752_polysilicon-1##33 net@2394#1pin@752_polysilicon-1##34 9.85
R6672 net@2394#1pin@752_polysilicon-1##34 net@2394#1pin@752_polysilicon-1##35 9.85
R6673 net@2394#1pin@752_polysilicon-1##35 net@2394#1pin@752_polysilicon-1##36 9.85
R6674 net@2394#1pin@752_polysilicon-1##36 net@2394#1pin@752_polysilicon-1##37 9.85
R6675 net@2394#1pin@752_polysilicon-1##37 net@2394#1pin@752_polysilicon-1##38 9.85
R6676 net@2394#1pin@752_polysilicon-1##38 net@2394#1pin@752_polysilicon-1##39 9.85
R6677 net@2394#1pin@752_polysilicon-1##39 net@2394#1pin@752_polysilicon-1##40 9.85
R6678 net@2394#1pin@752_polysilicon-1##40 net@2394#1pin@752_polysilicon-1##41 9.85
R6679 net@2394#1pin@752_polysilicon-1##41 net@2394#1pin@752_polysilicon-1##42 9.85
R6680 net@2394#1pin@752_polysilicon-1##42 net@2394#1pin@752_polysilicon-1##43 9.85
R6681 net@2394#1pin@752_polysilicon-1##43 net@2394#1pin@752_polysilicon-1##44 9.85
R6682 net@2394#1pin@752_polysilicon-1##44 net@2394#1pin@752_polysilicon-1##45 9.85
R6683 net@2394#1pin@752_polysilicon-1##45 net@2394#1pin@752_polysilicon-1##46 9.85
R6684 net@2394#1pin@752_polysilicon-1##46 net@2394#1pin@752_polysilicon-1##47 9.85
R6685 net@2394#1pin@752_polysilicon-1##47 net@2394#1pin@752_polysilicon-1##48 9.85
R6686 net@2394#1pin@752_polysilicon-1##48 net@2394#1pin@752_polysilicon-1##49 9.85
R6687 net@2394#1pin@752_polysilicon-1##49 net@2394#1pin@752_polysilicon-1##50 9.85
R6688 net@2394#1pin@752_polysilicon-1##50 net@2394#1pin@752_polysilicon-1##51 9.85
R6689 net@2394#1pin@752_polysilicon-1##51 net@2394#1pin@752_polysilicon-1##52 9.85
R6690 net@2394#1pin@752_polysilicon-1##52 net@2394#1pin@752_polysilicon-1##53 9.85
R6691 net@2394#1pin@752_polysilicon-1##53 net@2394#1pin@752_polysilicon-1##54 9.85
R6692 net@2394#1pin@752_polysilicon-1##54 net@2394#1pin@752_polysilicon-1##55 9.85
R6693 net@2394#1pin@752_polysilicon-1##55 net@2394#1pin@752_polysilicon-1##56 9.85
R6694 net@2394#1pin@752_polysilicon-1##56 net@2394#1pin@752_polysilicon-1##57 9.85
R6695 net@2394#1pin@752_polysilicon-1##57 net@2394#1pin@752_polysilicon-1##58 9.85
R6696 net@2394#1pin@752_polysilicon-1##58 net@2394#1pin@752_polysilicon-1##59 9.85
R6697 net@2394#1pin@752_polysilicon-1##59 net@2394#1pin@752_polysilicon-1##60 9.85
R6698 net@2394#1pin@752_polysilicon-1##60 net@2394#2pin@742_metal-1 9.85
R6699 Cin_to_XOR2___NAND5#26pmos@131_poly-right Cin_to_XOR2___NAND5#26pmos@131_poly-right##0 9.854
R6700 Cin_to_XOR2___NAND5#26pmos@131_poly-right##0 Cin_to_XOR2___NAND5#26pmos@131_poly-right##1 9.854
R6701 Cin_to_XOR2___NAND5#26pmos@131_poly-right##1 Cin_to_XOR2___NAND5#26pmos@131_poly-right##2 9.854
R6702 Cin_to_XOR2___NAND5#26pmos@131_poly-right##2 Cin_to_XOR2___NAND5#26pmos@131_poly-right##3 9.854
R6703 Cin_to_XOR2___NAND5#26pmos@131_poly-right##3 Cin_to_XOR2___NAND5#26pmos@131_poly-right##4 9.854
R6704 Cin_to_XOR2___NAND5#26pmos@131_poly-right##4 Cin_to_XOR2___NAND5#26pmos@131_poly-right##5 9.854
R6705 Cin_to_XOR2___NAND5#26pmos@131_poly-right##5 Cin_to_XOR2___NAND5#26pmos@131_poly-right##6 9.854
R6706 Cin_to_XOR2___NAND5#26pmos@131_poly-right##6 Cin_to_XOR2___NAND5#26pmos@131_poly-right##7 9.854
R6707 Cin_to_XOR2___NAND5#26pmos@131_poly-right##7 Cin_to_XOR2___NAND5#26pmos@131_poly-right##8 9.854
R6708 Cin_to_XOR2___NAND5#26pmos@131_poly-right##8 Cin_to_XOR2___NAND5#26pmos@131_poly-right##9 9.854
R6709 Cin_to_XOR2___NAND5#26pmos@131_poly-right##9 Cin_to_XOR2___NAND5#26pmos@131_poly-right##10 9.854
R6710 Cin_to_XOR2___NAND5#26pmos@131_poly-right##10 Cin_to_XOR2___NAND5#26pmos@131_poly-right##11 9.854
R6711 Cin_to_XOR2___NAND5#26pmos@131_poly-right##11 Cin_to_XOR2___NAND5#26pmos@131_poly-right##12 9.854
R6712 Cin_to_XOR2___NAND5#26pmos@131_poly-right##12 Cin_to_XOR2___NAND5#26pmos@131_poly-right##13 9.854
R6713 Cin_to_XOR2___NAND5#26pmos@131_poly-right##13 Cin_to_XOR2___NAND5#26pmos@131_poly-right##14 9.854
R6714 Cin_to_XOR2___NAND5#26pmos@131_poly-right##14 Cin_to_XOR2___NAND5#26pmos@131_poly-right##15 9.854
R6715 Cin_to_XOR2___NAND5#26pmos@131_poly-right##15 Cin_to_XOR2___NAND5#26pmos@131_poly-right##16 9.854
R6716 Cin_to_XOR2___NAND5#26pmos@131_poly-right##16 Cin_to_XOR2___NAND5#26pmos@131_poly-right##17 9.854
R6717 Cin_to_XOR2___NAND5#26pmos@131_poly-right##17 Cin_to_XOR2___NAND5#26pmos@131_poly-right##18 9.854
R6718 Cin_to_XOR2___NAND5#26pmos@131_poly-right##18 Cin_to_XOR2___NAND5#26pmos@131_poly-right##19 9.854
R6719 Cin_to_XOR2___NAND5#26pmos@131_poly-right##19 Cin_to_XOR2___NAND5#26pmos@131_poly-right##20 9.854
R6720 Cin_to_XOR2___NAND5#26pmos@131_poly-right##20 Cin_to_XOR2___NAND5#26pmos@131_poly-right##21 9.854
R6721 Cin_to_XOR2___NAND5#26pmos@131_poly-right##21 Cin_to_XOR2___NAND5#26pmos@131_poly-right##22 9.854
R6722 Cin_to_XOR2___NAND5#26pmos@131_poly-right##22 Cin_to_XOR2___NAND5#26pmos@131_poly-right##23 9.854
R6723 Cin_to_XOR2___NAND5#26pmos@131_poly-right##23 Cin_to_XOR2___NAND5#26pmos@131_poly-right##24 9.854
R6724 Cin_to_XOR2___NAND5#26pmos@131_poly-right##24 Cin_to_XOR2___NAND5#26pmos@131_poly-right##25 9.854
R6725 Cin_to_XOR2___NAND5#26pmos@131_poly-right##25 Cin_to_XOR2___NAND5#26pmos@131_poly-right##26 9.854
R6726 Cin_to_XOR2___NAND5#26pmos@131_poly-right##26 Cin_to_XOR2___NAND5#26pmos@131_poly-right##27 9.854
R6727 Cin_to_XOR2___NAND5#26pmos@131_poly-right##27 Cin_to_XOR2___NAND5#26pmos@131_poly-right##28 9.854
R6728 Cin_to_XOR2___NAND5#26pmos@131_poly-right##28 Cin_to_XOR2___NAND5#26pmos@131_poly-right##29 9.854
R6729 Cin_to_XOR2___NAND5#26pmos@131_poly-right##29 Cin_to_XOR2___NAND5#26pmos@131_poly-right##30 9.854
R6730 Cin_to_XOR2___NAND5#26pmos@131_poly-right##30 Cin_to_XOR2___NAND5#26pmos@131_poly-right##31 9.854
R6731 Cin_to_XOR2___NAND5#26pmos@131_poly-right##31 Cin_to_XOR2___NAND5#26pmos@131_poly-right##32 9.854
R6732 Cin_to_XOR2___NAND5#26pmos@131_poly-right##32 Cin_to_XOR2___NAND5#26pmos@131_poly-right##33 9.854
R6733 Cin_to_XOR2___NAND5#26pmos@131_poly-right##33 Cin_to_XOR2___NAND5#26pmos@131_poly-right##34 9.854
R6734 Cin_to_XOR2___NAND5#26pmos@131_poly-right##34 Cin_to_XOR2___NAND5#26pmos@131_poly-right##35 9.854
R6735 Cin_to_XOR2___NAND5#26pmos@131_poly-right##35 Cin_to_XOR2___NAND5#26pmos@131_poly-right##36 9.854
R6736 Cin_to_XOR2___NAND5#26pmos@131_poly-right##36 Cin_to_XOR2___NAND5#26pmos@131_poly-right##37 9.854
R6737 Cin_to_XOR2___NAND5#26pmos@131_poly-right##37 Cin_to_XOR2___NAND5#26pmos@131_poly-right##38 9.854
R6738 Cin_to_XOR2___NAND5#26pmos@131_poly-right##38 Cin_to_XOR2___NAND5#26pmos@131_poly-right##39 9.854
R6739 Cin_to_XOR2___NAND5#26pmos@131_poly-right##39 Cin_to_XOR2___NAND5#26pmos@131_poly-right##40 9.854
R6740 Cin_to_XOR2___NAND5#26pmos@131_poly-right##40 Cin_to_XOR2___NAND5#26pmos@131_poly-right##41 9.854
R6741 Cin_to_XOR2___NAND5#26pmos@131_poly-right##41 Cin_to_XOR2___NAND5#26pmos@131_poly-right##42 9.854
R6742 Cin_to_XOR2___NAND5#26pmos@131_poly-right##42 Cin_to_XOR2___NAND5#26pmos@131_poly-right##43 9.854
R6743 Cin_to_XOR2___NAND5#26pmos@131_poly-right##43 Cin_to_XOR2___NAND5#26pmos@131_poly-right##44 9.854
R6744 Cin_to_XOR2___NAND5#26pmos@131_poly-right##44 Cin_to_XOR2___NAND5#26pmos@131_poly-right##45 9.854
R6745 Cin_to_XOR2___NAND5#26pmos@131_poly-right##45 Cin_to_XOR2___NAND5#26pmos@131_poly-right##46 9.854
R6746 Cin_to_XOR2___NAND5#26pmos@131_poly-right##46 Cin_to_XOR2___NAND5#26pmos@131_poly-right##47 9.854
R6747 Cin_to_XOR2___NAND5#26pmos@131_poly-right##47 Cin_to_XOR2___NAND5#26pmos@131_poly-right##48 9.854
R6748 Cin_to_XOR2___NAND5#26pmos@131_poly-right##48 Cin_to_XOR2___NAND5#26pmos@131_poly-right##49 9.854
R6749 Cin_to_XOR2___NAND5#26pmos@131_poly-right##49 Cin_to_XOR2___NAND5#26pmos@131_poly-right##50 9.854
R6750 Cin_to_XOR2___NAND5#26pmos@131_poly-right##50 Cin_to_XOR2___NAND5#26pmos@131_poly-right##51 9.854
R6751 Cin_to_XOR2___NAND5#26pmos@131_poly-right##51 Cin_to_XOR2___NAND5#26pmos@131_poly-right##52 9.854
R6752 Cin_to_XOR2___NAND5#26pmos@131_poly-right##52 Cin_to_XOR2___NAND5#26pmos@131_poly-right##53 9.854
R6753 Cin_to_XOR2___NAND5#26pmos@131_poly-right##53 Cin_to_XOR2___NAND5#26pmos@131_poly-right##54 9.854
R6754 Cin_to_XOR2___NAND5#26pmos@131_poly-right##54 Cin_to_XOR2___NAND5#15pin@743_polysilicon-1 9.854
R6755 net@2404 net@2404#2contact@836_metal-1-metal-2 4.797
R6756 XOR1_to_NAND5#9pmos@127_poly-left XOR1_to_NAND5#9pmos@127_poly-left##0 9.871
R6757 XOR1_to_NAND5#9pmos@127_poly-left##0 XOR1_to_NAND5#9pmos@127_poly-left##1 9.871
R6758 XOR1_to_NAND5#9pmos@127_poly-left##1 XOR1_to_NAND5#9pmos@127_poly-left##2 9.871
R6759 XOR1_to_NAND5#9pmos@127_poly-left##2 XOR1_to_NAND5#9pmos@127_poly-left##3 9.871
R6760 XOR1_to_NAND5#9pmos@127_poly-left##3 XOR1_to_NAND5#9pmos@127_poly-left##4 9.871
R6761 XOR1_to_NAND5#9pmos@127_poly-left##4 XOR1_to_NAND5#9pmos@127_poly-left##5 9.871
R6762 XOR1_to_NAND5#9pmos@127_poly-left##5 XOR1_to_NAND5#9pmos@127_poly-left##6 9.871
R6763 XOR1_to_NAND5#9pmos@127_poly-left##6 XOR1_to_NAND5#9pmos@127_poly-left##7 9.871
R6764 XOR1_to_NAND5#9pmos@127_poly-left##7 XOR1_to_NAND5#9pmos@127_poly-left##8 9.871
R6765 XOR1_to_NAND5#9pmos@127_poly-left##8 XOR1_to_NAND5#9pmos@127_poly-left##9 9.871
R6766 XOR1_to_NAND5#9pmos@127_poly-left##9 XOR1_to_NAND5#9pmos@127_poly-left##10 9.871
R6767 XOR1_to_NAND5#9pmos@127_poly-left##10 XOR1_to_NAND5#9pmos@127_poly-left##11 9.871
R6768 XOR1_to_NAND5#9pmos@127_poly-left##11 XOR1_to_NAND5#9pmos@127_poly-left##12 9.871
R6769 XOR1_to_NAND5#9pmos@127_poly-left##12 XOR1_to_NAND5#9pmos@127_poly-left##13 9.871
R6770 XOR1_to_NAND5#9pmos@127_poly-left##13 XOR1_to_NAND5#9pmos@127_poly-left##14 9.871
R6771 XOR1_to_NAND5#9pmos@127_poly-left##14 XOR1_to_NAND5#9pmos@127_poly-left##15 9.871
R6772 XOR1_to_NAND5#9pmos@127_poly-left##15 XOR1_to_NAND5#9pmos@127_poly-left##16 9.871
R6773 XOR1_to_NAND5#9pmos@127_poly-left##16 XOR1_to_NAND5#9pmos@127_poly-left##17 9.871
R6774 XOR1_to_NAND5#9pmos@127_poly-left##17 XOR1_to_NAND5#9pmos@127_poly-left##18 9.871
R6775 XOR1_to_NAND5#9pmos@127_poly-left##18 XOR1_to_NAND5#9pmos@127_poly-left##19 9.871
R6776 XOR1_to_NAND5#9pmos@127_poly-left##19 XOR1_to_NAND5#9pmos@127_poly-left##20 9.871
R6777 XOR1_to_NAND5#9pmos@127_poly-left##20 XOR1_to_NAND5#9pmos@127_poly-left##21 9.871
R6778 XOR1_to_NAND5#9pmos@127_poly-left##21 XOR1_to_NAND5#9pmos@127_poly-left##22 9.871
R6779 XOR1_to_NAND5#9pmos@127_poly-left##22 XOR1_to_NAND5#9pmos@127_poly-left##23 9.871
R6780 XOR1_to_NAND5#9pmos@127_poly-left##23 XOR1_to_NAND5#9pmos@127_poly-left##24 9.871
R6781 XOR1_to_NAND5#9pmos@127_poly-left##24 XOR1_to_NAND5#9pmos@127_poly-left##25 9.871
R6782 XOR1_to_NAND5#9pmos@127_poly-left##25 XOR1_to_NAND5#9pmos@127_poly-left##26 9.871
R6783 XOR1_to_NAND5#9pmos@127_poly-left##26 XOR1_to_NAND5#9pmos@127_poly-left##27 9.871
R6784 XOR1_to_NAND5#9pmos@127_poly-left##27 XOR1_to_NAND5#9pmos@127_poly-left##28 9.871
R6785 XOR1_to_NAND5#9pmos@127_poly-left##28 XOR1_to_NAND5#9pmos@127_poly-left##29 9.871
R6786 XOR1_to_NAND5#9pmos@127_poly-left##29 XOR1_to_NAND5#9pmos@127_poly-left##30 9.871
R6787 XOR1_to_NAND5#9pmos@127_poly-left##30 XOR1_to_NAND5#9pmos@127_poly-left##31 9.871
R6788 XOR1_to_NAND5#9pmos@127_poly-left##31 XOR1_to_NAND5#9pmos@127_poly-left##32 9.871
R6789 XOR1_to_NAND5#9pmos@127_poly-left##32 XOR1_to_NAND5#9pmos@127_poly-left##33 9.871
R6790 XOR1_to_NAND5#9pmos@127_poly-left##33 XOR1_to_NAND5#9pmos@127_poly-left##34 9.871
R6791 XOR1_to_NAND5#9pmos@127_poly-left##34 XOR1_to_NAND5#9pmos@127_poly-left##35 9.871
R6792 XOR1_to_NAND5#9pmos@127_poly-left##35 XOR1_to_NAND5#9pmos@127_poly-left##36 9.871
R6793 XOR1_to_NAND5#9pmos@127_poly-left##36 XOR1_to_NAND5#9pmos@127_poly-left##37 9.871
R6794 XOR1_to_NAND5#9pmos@127_poly-left##37 XOR1_to_NAND5#9pmos@127_poly-left##38 9.871
R6795 XOR1_to_NAND5#9pmos@127_poly-left##38 XOR1_to_NAND5#9pmos@127_poly-left##39 9.871
R6796 XOR1_to_NAND5#9pmos@127_poly-left##39 XOR1_to_NAND5#9pmos@127_poly-left##40 9.871
R6797 XOR1_to_NAND5#9pmos@127_poly-left##40 XOR1_to_NAND5#9pmos@127_poly-left##41 9.871
R6798 XOR1_to_NAND5#9pmos@127_poly-left##41 XOR1_to_NAND5#9pmos@127_poly-left##42 9.871
R6799 XOR1_to_NAND5#9pmos@127_poly-left##42 XOR1_to_NAND5#9pmos@127_poly-left##43 9.871
R6800 XOR1_to_NAND5#9pmos@127_poly-left##43 XOR1_to_NAND5#9pmos@127_poly-left##44 9.871
R6801 XOR1_to_NAND5#9pmos@127_poly-left##44 XOR1_to_NAND5#9pmos@127_poly-left##45 9.871
R6802 XOR1_to_NAND5#9pmos@127_poly-left##45 XOR1_to_NAND5#9pmos@127_poly-left##46 9.871
R6803 XOR1_to_NAND5#9pmos@127_poly-left##46 XOR1_to_NAND5#9pmos@127_poly-left##47 9.871
R6804 XOR1_to_NAND5#9pmos@127_poly-left##47 XOR1_to_NAND5#9pmos@127_poly-left##48 9.871
R6805 XOR1_to_NAND5#9pmos@127_poly-left##48 XOR1_to_NAND5#9pmos@127_poly-left##49 9.871
R6806 XOR1_to_NAND5#9pmos@127_poly-left##49 XOR1_to_NAND5#9pmos@127_poly-left##50 9.871
R6807 XOR1_to_NAND5#9pmos@127_poly-left##50 XOR1_to_NAND5#9pmos@127_poly-left##51 9.871
R6808 XOR1_to_NAND5#9pmos@127_poly-left##51 XOR1_to_NAND5#9pmos@127_poly-left##52 9.871
R6809 XOR1_to_NAND5#9pmos@127_poly-left##52 XOR1_to_NAND5#9pmos@127_poly-left##53 9.871
R6810 XOR1_to_NAND5#9pmos@127_poly-left##53 XOR1_to_NAND5#9pmos@127_poly-left##54 9.871
R6811 XOR1_to_NAND5#9pmos@127_poly-left##54 XOR1_to_NAND5#9pmos@127_poly-left##55 9.871
R6812 XOR1_to_NAND5#9pmos@127_poly-left##55 XOR1_to_NAND5#26nmos@127_poly-right 9.871
R6813 net@2394#7pmos@128_poly-left net@2394#7pmos@128_poly-left##0 9.871
R6814 net@2394#7pmos@128_poly-left##0 net@2394#7pmos@128_poly-left##1 9.871
R6815 net@2394#7pmos@128_poly-left##1 net@2394#7pmos@128_poly-left##2 9.871
R6816 net@2394#7pmos@128_poly-left##2 net@2394#7pmos@128_poly-left##3 9.871
R6817 net@2394#7pmos@128_poly-left##3 net@2394#7pmos@128_poly-left##4 9.871
R6818 net@2394#7pmos@128_poly-left##4 net@2394#7pmos@128_poly-left##5 9.871
R6819 net@2394#7pmos@128_poly-left##5 net@2394#7pmos@128_poly-left##6 9.871
R6820 net@2394#7pmos@128_poly-left##6 net@2394#7pmos@128_poly-left##7 9.871
R6821 net@2394#7pmos@128_poly-left##7 net@2394#7pmos@128_poly-left##8 9.871
R6822 net@2394#7pmos@128_poly-left##8 net@2394#7pmos@128_poly-left##9 9.871
R6823 net@2394#7pmos@128_poly-left##9 net@2394#7pmos@128_poly-left##10 9.871
R6824 net@2394#7pmos@128_poly-left##10 net@2394#7pmos@128_poly-left##11 9.871
R6825 net@2394#7pmos@128_poly-left##11 net@2394#7pmos@128_poly-left##12 9.871
R6826 net@2394#7pmos@128_poly-left##12 net@2394#7pmos@128_poly-left##13 9.871
R6827 net@2394#7pmos@128_poly-left##13 net@2394#7pmos@128_poly-left##14 9.871
R6828 net@2394#7pmos@128_poly-left##14 net@2394#7pmos@128_poly-left##15 9.871
R6829 net@2394#7pmos@128_poly-left##15 net@2394#7pmos@128_poly-left##16 9.871
R6830 net@2394#7pmos@128_poly-left##16 net@2394#7pmos@128_poly-left##17 9.871
R6831 net@2394#7pmos@128_poly-left##17 net@2394#7pmos@128_poly-left##18 9.871
R6832 net@2394#7pmos@128_poly-left##18 net@2394#7pmos@128_poly-left##19 9.871
R6833 net@2394#7pmos@128_poly-left##19 net@2394#7pmos@128_poly-left##20 9.871
R6834 net@2394#7pmos@128_poly-left##20 net@2394#7pmos@128_poly-left##21 9.871
R6835 net@2394#7pmos@128_poly-left##21 net@2394#7pmos@128_poly-left##22 9.871
R6836 net@2394#7pmos@128_poly-left##22 net@2394#7pmos@128_poly-left##23 9.871
R6837 net@2394#7pmos@128_poly-left##23 net@2394#7pmos@128_poly-left##24 9.871
R6838 net@2394#7pmos@128_poly-left##24 net@2394#7pmos@128_poly-left##25 9.871
R6839 net@2394#7pmos@128_poly-left##25 net@2394#7pmos@128_poly-left##26 9.871
R6840 net@2394#7pmos@128_poly-left##26 net@2394#7pmos@128_poly-left##27 9.871
R6841 net@2394#7pmos@128_poly-left##27 net@2394#7pmos@128_poly-left##28 9.871
R6842 net@2394#7pmos@128_poly-left##28 net@2394#7pmos@128_poly-left##29 9.871
R6843 net@2394#7pmos@128_poly-left##29 net@2394#7pmos@128_poly-left##30 9.871
R6844 net@2394#7pmos@128_poly-left##30 net@2394#7pmos@128_poly-left##31 9.871
R6845 net@2394#7pmos@128_poly-left##31 net@2394#7pmos@128_poly-left##32 9.871
R6846 net@2394#7pmos@128_poly-left##32 net@2394#7pmos@128_poly-left##33 9.871
R6847 net@2394#7pmos@128_poly-left##33 net@2394#7pmos@128_poly-left##34 9.871
R6848 net@2394#7pmos@128_poly-left##34 net@2394#7pmos@128_poly-left##35 9.871
R6849 net@2394#7pmos@128_poly-left##35 net@2394#7pmos@128_poly-left##36 9.871
R6850 net@2394#7pmos@128_poly-left##36 net@2394#7pmos@128_poly-left##37 9.871
R6851 net@2394#7pmos@128_poly-left##37 net@2394#7pmos@128_poly-left##38 9.871
R6852 net@2394#7pmos@128_poly-left##38 net@2394#7pmos@128_poly-left##39 9.871
R6853 net@2394#7pmos@128_poly-left##39 net@2394#7pmos@128_poly-left##40 9.871
R6854 net@2394#7pmos@128_poly-left##40 net@2394#7pmos@128_poly-left##41 9.871
R6855 net@2394#7pmos@128_poly-left##41 net@2394#7pmos@128_poly-left##42 9.871
R6856 net@2394#7pmos@128_poly-left##42 net@2394#7pmos@128_poly-left##43 9.871
R6857 net@2394#7pmos@128_poly-left##43 net@2394#7pmos@128_poly-left##44 9.871
R6858 net@2394#7pmos@128_poly-left##44 net@2394#7pmos@128_poly-left##45 9.871
R6859 net@2394#7pmos@128_poly-left##45 net@2394#7pmos@128_poly-left##46 9.871
R6860 net@2394#7pmos@128_poly-left##46 net@2394#7pmos@128_poly-left##47 9.871
R6861 net@2394#7pmos@128_poly-left##47 net@2394#7pmos@128_poly-left##48 9.871
R6862 net@2394#7pmos@128_poly-left##48 net@2394#7pmos@128_poly-left##49 9.871
R6863 net@2394#7pmos@128_poly-left##49 net@2394#7pmos@128_poly-left##50 9.871
R6864 net@2394#7pmos@128_poly-left##50 net@2394#7pmos@128_poly-left##51 9.871
R6865 net@2394#7pmos@128_poly-left##51 net@2394#7pmos@128_poly-left##52 9.871
R6866 net@2394#7pmos@128_poly-left##52 net@2394#7pmos@128_poly-left##53 9.871
R6867 net@2394#7pmos@128_poly-left##53 net@2394#7pmos@128_poly-left##54 9.871
R6868 net@2394#7pmos@128_poly-left##54 net@2394#7pmos@128_poly-left##55 9.871
R6869 net@2394#7pmos@128_poly-left##55 net@2394#11nmos@128_poly-right 9.871
R6870 Cin_to_XOR2___NAND5#27pmos@129_poly-right Cin_to_XOR2___NAND5#27pmos@129_poly-right##0 9.871
R6871 Cin_to_XOR2___NAND5#27pmos@129_poly-right##0 Cin_to_XOR2___NAND5#27pmos@129_poly-right##1 9.871
R6872 Cin_to_XOR2___NAND5#27pmos@129_poly-right##1 Cin_to_XOR2___NAND5#27pmos@129_poly-right##2 9.871
R6873 Cin_to_XOR2___NAND5#27pmos@129_poly-right##2 Cin_to_XOR2___NAND5#27pmos@129_poly-right##3 9.871
R6874 Cin_to_XOR2___NAND5#27pmos@129_poly-right##3 Cin_to_XOR2___NAND5#27pmos@129_poly-right##4 9.871
R6875 Cin_to_XOR2___NAND5#27pmos@129_poly-right##4 Cin_to_XOR2___NAND5#27pmos@129_poly-right##5 9.871
R6876 Cin_to_XOR2___NAND5#27pmos@129_poly-right##5 Cin_to_XOR2___NAND5#27pmos@129_poly-right##6 9.871
R6877 Cin_to_XOR2___NAND5#27pmos@129_poly-right##6 Cin_to_XOR2___NAND5#27pmos@129_poly-right##7 9.871
R6878 Cin_to_XOR2___NAND5#27pmos@129_poly-right##7 Cin_to_XOR2___NAND5#27pmos@129_poly-right##8 9.871
R6879 Cin_to_XOR2___NAND5#27pmos@129_poly-right##8 Cin_to_XOR2___NAND5#27pmos@129_poly-right##9 9.871
R6880 Cin_to_XOR2___NAND5#27pmos@129_poly-right##9 Cin_to_XOR2___NAND5#27pmos@129_poly-right##10 9.871
R6881 Cin_to_XOR2___NAND5#27pmos@129_poly-right##10 Cin_to_XOR2___NAND5#27pmos@129_poly-right##11 9.871
R6882 Cin_to_XOR2___NAND5#27pmos@129_poly-right##11 Cin_to_XOR2___NAND5#27pmos@129_poly-right##12 9.871
R6883 Cin_to_XOR2___NAND5#27pmos@129_poly-right##12 Cin_to_XOR2___NAND5#27pmos@129_poly-right##13 9.871
R6884 Cin_to_XOR2___NAND5#27pmos@129_poly-right##13 Cin_to_XOR2___NAND5#27pmos@129_poly-right##14 9.871
R6885 Cin_to_XOR2___NAND5#27pmos@129_poly-right##14 Cin_to_XOR2___NAND5#27pmos@129_poly-right##15 9.871
R6886 Cin_to_XOR2___NAND5#27pmos@129_poly-right##15 Cin_to_XOR2___NAND5#27pmos@129_poly-right##16 9.871
R6887 Cin_to_XOR2___NAND5#27pmos@129_poly-right##16 Cin_to_XOR2___NAND5#27pmos@129_poly-right##17 9.871
R6888 Cin_to_XOR2___NAND5#27pmos@129_poly-right##17 Cin_to_XOR2___NAND5#27pmos@129_poly-right##18 9.871
R6889 Cin_to_XOR2___NAND5#27pmos@129_poly-right##18 Cin_to_XOR2___NAND5#27pmos@129_poly-right##19 9.871
R6890 Cin_to_XOR2___NAND5#27pmos@129_poly-right##19 Cin_to_XOR2___NAND5#27pmos@129_poly-right##20 9.871
R6891 Cin_to_XOR2___NAND5#27pmos@129_poly-right##20 Cin_to_XOR2___NAND5#27pmos@129_poly-right##21 9.871
R6892 Cin_to_XOR2___NAND5#27pmos@129_poly-right##21 Cin_to_XOR2___NAND5#27pmos@129_poly-right##22 9.871
R6893 Cin_to_XOR2___NAND5#27pmos@129_poly-right##22 Cin_to_XOR2___NAND5#27pmos@129_poly-right##23 9.871
R6894 Cin_to_XOR2___NAND5#27pmos@129_poly-right##23 Cin_to_XOR2___NAND5#27pmos@129_poly-right##24 9.871
R6895 Cin_to_XOR2___NAND5#27pmos@129_poly-right##24 Cin_to_XOR2___NAND5#27pmos@129_poly-right##25 9.871
R6896 Cin_to_XOR2___NAND5#27pmos@129_poly-right##25 Cin_to_XOR2___NAND5#27pmos@129_poly-right##26 9.871
R6897 Cin_to_XOR2___NAND5#27pmos@129_poly-right##26 Cin_to_XOR2___NAND5#27pmos@129_poly-right##27 9.871
R6898 Cin_to_XOR2___NAND5#27pmos@129_poly-right##27 Cin_to_XOR2___NAND5#27pmos@129_poly-right##28 9.871
R6899 Cin_to_XOR2___NAND5#27pmos@129_poly-right##28 Cin_to_XOR2___NAND5#27pmos@129_poly-right##29 9.871
R6900 Cin_to_XOR2___NAND5#27pmos@129_poly-right##29 Cin_to_XOR2___NAND5#27pmos@129_poly-right##30 9.871
R6901 Cin_to_XOR2___NAND5#27pmos@129_poly-right##30 Cin_to_XOR2___NAND5#27pmos@129_poly-right##31 9.871
R6902 Cin_to_XOR2___NAND5#27pmos@129_poly-right##31 Cin_to_XOR2___NAND5#27pmos@129_poly-right##32 9.871
R6903 Cin_to_XOR2___NAND5#27pmos@129_poly-right##32 Cin_to_XOR2___NAND5#27pmos@129_poly-right##33 9.871
R6904 Cin_to_XOR2___NAND5#27pmos@129_poly-right##33 Cin_to_XOR2___NAND5#27pmos@129_poly-right##34 9.871
R6905 Cin_to_XOR2___NAND5#27pmos@129_poly-right##34 Cin_to_XOR2___NAND5#27pmos@129_poly-right##35 9.871
R6906 Cin_to_XOR2___NAND5#27pmos@129_poly-right##35 Cin_to_XOR2___NAND5#27pmos@129_poly-right##36 9.871
R6907 Cin_to_XOR2___NAND5#27pmos@129_poly-right##36 Cin_to_XOR2___NAND5#27pmos@129_poly-right##37 9.871
R6908 Cin_to_XOR2___NAND5#27pmos@129_poly-right##37 Cin_to_XOR2___NAND5#27pmos@129_poly-right##38 9.871
R6909 Cin_to_XOR2___NAND5#27pmos@129_poly-right##38 Cin_to_XOR2___NAND5#27pmos@129_poly-right##39 9.871
R6910 Cin_to_XOR2___NAND5#27pmos@129_poly-right##39 Cin_to_XOR2___NAND5#27pmos@129_poly-right##40 9.871
R6911 Cin_to_XOR2___NAND5#27pmos@129_poly-right##40 Cin_to_XOR2___NAND5#27pmos@129_poly-right##41 9.871
R6912 Cin_to_XOR2___NAND5#27pmos@129_poly-right##41 Cin_to_XOR2___NAND5#27pmos@129_poly-right##42 9.871
R6913 Cin_to_XOR2___NAND5#27pmos@129_poly-right##42 Cin_to_XOR2___NAND5#27pmos@129_poly-right##43 9.871
R6914 Cin_to_XOR2___NAND5#27pmos@129_poly-right##43 Cin_to_XOR2___NAND5#27pmos@129_poly-right##44 9.871
R6915 Cin_to_XOR2___NAND5#27pmos@129_poly-right##44 Cin_to_XOR2___NAND5#27pmos@129_poly-right##45 9.871
R6916 Cin_to_XOR2___NAND5#27pmos@129_poly-right##45 Cin_to_XOR2___NAND5#27pmos@129_poly-right##46 9.871
R6917 Cin_to_XOR2___NAND5#27pmos@129_poly-right##46 Cin_to_XOR2___NAND5#27pmos@129_poly-right##47 9.871
R6918 Cin_to_XOR2___NAND5#27pmos@129_poly-right##47 Cin_to_XOR2___NAND5#27pmos@129_poly-right##48 9.871
R6919 Cin_to_XOR2___NAND5#27pmos@129_poly-right##48 Cin_to_XOR2___NAND5#27pmos@129_poly-right##49 9.871
R6920 Cin_to_XOR2___NAND5#27pmos@129_poly-right##49 Cin_to_XOR2___NAND5#27pmos@129_poly-right##50 9.871
R6921 Cin_to_XOR2___NAND5#27pmos@129_poly-right##50 Cin_to_XOR2___NAND5#27pmos@129_poly-right##51 9.871
R6922 Cin_to_XOR2___NAND5#27pmos@129_poly-right##51 Cin_to_XOR2___NAND5#27pmos@129_poly-right##52 9.871
R6923 Cin_to_XOR2___NAND5#27pmos@129_poly-right##52 Cin_to_XOR2___NAND5#27pmos@129_poly-right##53 9.871
R6924 Cin_to_XOR2___NAND5#27pmos@129_poly-right##53 Cin_to_XOR2___NAND5#27pmos@129_poly-right##54 9.871
R6925 Cin_to_XOR2___NAND5#27pmos@129_poly-right##54 Cin_to_XOR2___NAND5#27pmos@129_poly-right##55 9.871
R6926 Cin_to_XOR2___NAND5#27pmos@129_poly-right##55 Cin_to_XOR2___NAND5#18nmos@129_poly-left 9.871
R6927 net@2404#14pmos@130_poly-right net@2404#14pmos@130_poly-right##0 9.871
R6928 net@2404#14pmos@130_poly-right##0 net@2404#14pmos@130_poly-right##1 9.871
R6929 net@2404#14pmos@130_poly-right##1 net@2404#14pmos@130_poly-right##2 9.871
R6930 net@2404#14pmos@130_poly-right##2 net@2404#14pmos@130_poly-right##3 9.871
R6931 net@2404#14pmos@130_poly-right##3 net@2404#14pmos@130_poly-right##4 9.871
R6932 net@2404#14pmos@130_poly-right##4 net@2404#14pmos@130_poly-right##5 9.871
R6933 net@2404#14pmos@130_poly-right##5 net@2404#14pmos@130_poly-right##6 9.871
R6934 net@2404#14pmos@130_poly-right##6 net@2404#14pmos@130_poly-right##7 9.871
R6935 net@2404#14pmos@130_poly-right##7 net@2404#14pmos@130_poly-right##8 9.871
R6936 net@2404#14pmos@130_poly-right##8 net@2404#14pmos@130_poly-right##9 9.871
R6937 net@2404#14pmos@130_poly-right##9 net@2404#14pmos@130_poly-right##10 9.871
R6938 net@2404#14pmos@130_poly-right##10 net@2404#14pmos@130_poly-right##11 9.871
R6939 net@2404#14pmos@130_poly-right##11 net@2404#14pmos@130_poly-right##12 9.871
R6940 net@2404#14pmos@130_poly-right##12 net@2404#14pmos@130_poly-right##13 9.871
R6941 net@2404#14pmos@130_poly-right##13 net@2404#14pmos@130_poly-right##14 9.871
R6942 net@2404#14pmos@130_poly-right##14 net@2404#14pmos@130_poly-right##15 9.871
R6943 net@2404#14pmos@130_poly-right##15 net@2404#14pmos@130_poly-right##16 9.871
R6944 net@2404#14pmos@130_poly-right##16 net@2404#14pmos@130_poly-right##17 9.871
R6945 net@2404#14pmos@130_poly-right##17 net@2404#14pmos@130_poly-right##18 9.871
R6946 net@2404#14pmos@130_poly-right##18 net@2404#14pmos@130_poly-right##19 9.871
R6947 net@2404#14pmos@130_poly-right##19 net@2404#14pmos@130_poly-right##20 9.871
R6948 net@2404#14pmos@130_poly-right##20 net@2404#14pmos@130_poly-right##21 9.871
R6949 net@2404#14pmos@130_poly-right##21 net@2404#14pmos@130_poly-right##22 9.871
R6950 net@2404#14pmos@130_poly-right##22 net@2404#14pmos@130_poly-right##23 9.871
R6951 net@2404#14pmos@130_poly-right##23 net@2404#14pmos@130_poly-right##24 9.871
R6952 net@2404#14pmos@130_poly-right##24 net@2404#14pmos@130_poly-right##25 9.871
R6953 net@2404#14pmos@130_poly-right##25 net@2404#14pmos@130_poly-right##26 9.871
R6954 net@2404#14pmos@130_poly-right##26 net@2404#14pmos@130_poly-right##27 9.871
R6955 net@2404#14pmos@130_poly-right##27 net@2404#14pmos@130_poly-right##28 9.871
R6956 net@2404#14pmos@130_poly-right##28 net@2404#14pmos@130_poly-right##29 9.871
R6957 net@2404#14pmos@130_poly-right##29 net@2404#14pmos@130_poly-right##30 9.871
R6958 net@2404#14pmos@130_poly-right##30 net@2404#14pmos@130_poly-right##31 9.871
R6959 net@2404#14pmos@130_poly-right##31 net@2404#14pmos@130_poly-right##32 9.871
R6960 net@2404#14pmos@130_poly-right##32 net@2404#14pmos@130_poly-right##33 9.871
R6961 net@2404#14pmos@130_poly-right##33 net@2404#14pmos@130_poly-right##34 9.871
R6962 net@2404#14pmos@130_poly-right##34 net@2404#14pmos@130_poly-right##35 9.871
R6963 net@2404#14pmos@130_poly-right##35 net@2404#14pmos@130_poly-right##36 9.871
R6964 net@2404#14pmos@130_poly-right##36 net@2404#14pmos@130_poly-right##37 9.871
R6965 net@2404#14pmos@130_poly-right##37 net@2404#14pmos@130_poly-right##38 9.871
R6966 net@2404#14pmos@130_poly-right##38 net@2404#14pmos@130_poly-right##39 9.871
R6967 net@2404#14pmos@130_poly-right##39 net@2404#14pmos@130_poly-right##40 9.871
R6968 net@2404#14pmos@130_poly-right##40 net@2404#14pmos@130_poly-right##41 9.871
R6969 net@2404#14pmos@130_poly-right##41 net@2404#14pmos@130_poly-right##42 9.871
R6970 net@2404#14pmos@130_poly-right##42 net@2404#14pmos@130_poly-right##43 9.871
R6971 net@2404#14pmos@130_poly-right##43 net@2404#14pmos@130_poly-right##44 9.871
R6972 net@2404#14pmos@130_poly-right##44 net@2404#14pmos@130_poly-right##45 9.871
R6973 net@2404#14pmos@130_poly-right##45 net@2404#14pmos@130_poly-right##46 9.871
R6974 net@2404#14pmos@130_poly-right##46 net@2404#14pmos@130_poly-right##47 9.871
R6975 net@2404#14pmos@130_poly-right##47 net@2404#14pmos@130_poly-right##48 9.871
R6976 net@2404#14pmos@130_poly-right##48 net@2404#14pmos@130_poly-right##49 9.871
R6977 net@2404#14pmos@130_poly-right##49 net@2404#14pmos@130_poly-right##50 9.871
R6978 net@2404#14pmos@130_poly-right##50 net@2404#14pmos@130_poly-right##51 9.871
R6979 net@2404#14pmos@130_poly-right##51 net@2404#14pmos@130_poly-right##52 9.871
R6980 net@2404#14pmos@130_poly-right##52 net@2404#14pmos@130_poly-right##53 9.871
R6981 net@2404#14pmos@130_poly-right##53 net@2404#14pmos@130_poly-right##54 9.871
R6982 net@2404#14pmos@130_poly-right##54 net@2404#14pmos@130_poly-right##55 9.871
R6983 net@2404#14pmos@130_poly-right##55 net@2404#9nmos@130_poly-left 9.871
R6984 net@2403#2contact@861_metal-1-polysilicon-1 net@2403 4.654
R6985 net@2403#12pmos@133_poly-right net@2403#12pmos@133_poly-right##0 9.931
R6986 net@2403#12pmos@133_poly-right##0 net@2403#12pmos@133_poly-right##1 9.931
R6987 net@2403#12pmos@133_poly-right##1 net@2403#12pmos@133_poly-right##2 9.931
R6988 net@2403#12pmos@133_poly-right##2 net@2403#12pmos@133_poly-right##3 9.931
R6989 net@2403#12pmos@133_poly-right##3 net@2403#12pmos@133_poly-right##4 9.931
R6990 net@2403#12pmos@133_poly-right##4 net@2403#12pmos@133_poly-right##5 9.931
R6991 net@2403#12pmos@133_poly-right##5 net@2403#12pmos@133_poly-right##6 9.931
R6992 net@2403#12pmos@133_poly-right##6 net@2403#12pmos@133_poly-right##7 9.931
R6993 net@2403#12pmos@133_poly-right##7 net@2403#12pmos@133_poly-right##8 9.931
R6994 net@2403#12pmos@133_poly-right##8 net@2403#12pmos@133_poly-right##9 9.931
R6995 net@2403#12pmos@133_poly-right##9 net@2403#12pmos@133_poly-right##10 9.931
R6996 net@2403#12pmos@133_poly-right##10 net@2403#12pmos@133_poly-right##11 9.931
R6997 net@2403#12pmos@133_poly-right##11 net@2403#12pmos@133_poly-right##12 9.931
R6998 net@2403#12pmos@133_poly-right##12 net@2403#12pmos@133_poly-right##13 9.931
R6999 net@2403#12pmos@133_poly-right##13 net@2403#12pmos@133_poly-right##14 9.931
R7000 net@2403#12pmos@133_poly-right##14 net@2403#12pmos@133_poly-right##15 9.931
R7001 net@2403#12pmos@133_poly-right##15 net@2403#12pmos@133_poly-right##16 9.931
R7002 net@2403#12pmos@133_poly-right##16 net@2403#12pmos@133_poly-right##17 9.931
R7003 net@2403#12pmos@133_poly-right##17 net@2403#12pmos@133_poly-right##18 9.931
R7004 net@2403#12pmos@133_poly-right##18 net@2403#12pmos@133_poly-right##19 9.931
R7005 net@2403#12pmos@133_poly-right##19 net@2403#12pmos@133_poly-right##20 9.931
R7006 net@2403#12pmos@133_poly-right##20 net@2403#12pmos@133_poly-right##21 9.931
R7007 net@2403#12pmos@133_poly-right##21 net@2403#12pmos@133_poly-right##22 9.931
R7008 net@2403#12pmos@133_poly-right##22 net@2403#12pmos@133_poly-right##23 9.931
R7009 net@2403#12pmos@133_poly-right##23 net@2403#12pmos@133_poly-right##24 9.931
R7010 net@2403#12pmos@133_poly-right##24 net@2403#12pmos@133_poly-right##25 9.931
R7011 net@2403#12pmos@133_poly-right##25 net@2403#12pmos@133_poly-right##26 9.931
R7012 net@2403#12pmos@133_poly-right##26 net@2403#12pmos@133_poly-right##27 9.931
R7013 net@2403#12pmos@133_poly-right##27 net@2403#12pmos@133_poly-right##28 9.931
R7014 net@2403#12pmos@133_poly-right##28 net@2403#12pmos@133_poly-right##29 9.931
R7015 net@2403#12pmos@133_poly-right##29 net@2403#12pmos@133_poly-right##30 9.931
R7016 net@2403#12pmos@133_poly-right##30 net@2403#12pmos@133_poly-right##31 9.931
R7017 net@2403#12pmos@133_poly-right##31 net@2403#12pmos@133_poly-right##32 9.931
R7018 net@2403#12pmos@133_poly-right##32 net@2403#12pmos@133_poly-right##33 9.931
R7019 net@2403#12pmos@133_poly-right##33 net@2403#12pmos@133_poly-right##34 9.931
R7020 net@2403#12pmos@133_poly-right##34 net@2403#12pmos@133_poly-right##35 9.931
R7021 net@2403#12pmos@133_poly-right##35 net@2403#12pmos@133_poly-right##36 9.931
R7022 net@2403#12pmos@133_poly-right##36 net@2403#12pmos@133_poly-right##37 9.931
R7023 net@2403#12pmos@133_poly-right##37 net@2403#12pmos@133_poly-right##38 9.931
R7024 net@2403#12pmos@133_poly-right##38 net@2403#12pmos@133_poly-right##39 9.931
R7025 net@2403#12pmos@133_poly-right##39 net@2403#12pmos@133_poly-right##40 9.931
R7026 net@2403#12pmos@133_poly-right##40 net@2403#12pmos@133_poly-right##41 9.931
R7027 net@2403#12pmos@133_poly-right##41 net@2403#12pmos@133_poly-right##42 9.931
R7028 net@2403#12pmos@133_poly-right##42 net@2403#12pmos@133_poly-right##43 9.931
R7029 net@2403#12pmos@133_poly-right##43 net@2403#12pmos@133_poly-right##44 9.931
R7030 net@2403#12pmos@133_poly-right##44 net@2403#12pmos@133_poly-right##45 9.931
R7031 net@2403#12pmos@133_poly-right##45 net@2403#12pmos@133_poly-right##46 9.931
R7032 net@2403#12pmos@133_poly-right##46 net@2403#12pmos@133_poly-right##47 9.931
R7033 net@2403#12pmos@133_poly-right##47 net@2403#12pmos@133_poly-right##48 9.931
R7034 net@2403#12pmos@133_poly-right##48 net@2403#12pmos@133_poly-right##49 9.931
R7035 net@2403#12pmos@133_poly-right##49 net@2403#12pmos@133_poly-right##50 9.931
R7036 net@2403#12pmos@133_poly-right##50 net@2403#12pmos@133_poly-right##51 9.931
R7037 net@2403#12pmos@133_poly-right##51 net@2403#12pmos@133_poly-right##52 9.931
R7038 net@2403#12pmos@133_poly-right##52 net@2403#5pin@745_polysilicon-1 9.931
R7039 Sum4#4pmos@133_diff-top Sum4 4.823
R7040 XOR1_to_NAND5#14pin@757_polysilicon-1 XOR1_to_NAND5#14pin@757_polysilicon-1##0 9.854
R7041 XOR1_to_NAND5#14pin@757_polysilicon-1##0 XOR1_to_NAND5#14pin@757_polysilicon-1##1 9.854
R7042 XOR1_to_NAND5#14pin@757_polysilicon-1##1 XOR1_to_NAND5#14pin@757_polysilicon-1##2 9.854
R7043 XOR1_to_NAND5#14pin@757_polysilicon-1##2 XOR1_to_NAND5#14pin@757_polysilicon-1##3 9.854
R7044 XOR1_to_NAND5#14pin@757_polysilicon-1##3 XOR1_to_NAND5#14pin@757_polysilicon-1##4 9.854
R7045 XOR1_to_NAND5#14pin@757_polysilicon-1##4 XOR1_to_NAND5#14pin@757_polysilicon-1##5 9.854
R7046 XOR1_to_NAND5#14pin@757_polysilicon-1##5 XOR1_to_NAND5#14pin@757_polysilicon-1##6 9.854
R7047 XOR1_to_NAND5#14pin@757_polysilicon-1##6 XOR1_to_NAND5#14pin@757_polysilicon-1##7 9.854
R7048 XOR1_to_NAND5#14pin@757_polysilicon-1##7 XOR1_to_NAND5#14pin@757_polysilicon-1##8 9.854
R7049 XOR1_to_NAND5#14pin@757_polysilicon-1##8 XOR1_to_NAND5#14pin@757_polysilicon-1##9 9.854
R7050 XOR1_to_NAND5#14pin@757_polysilicon-1##9 XOR1_to_NAND5#14pin@757_polysilicon-1##10 9.854
R7051 XOR1_to_NAND5#14pin@757_polysilicon-1##10 XOR1_to_NAND5#14pin@757_polysilicon-1##11 9.854
R7052 XOR1_to_NAND5#14pin@757_polysilicon-1##11 XOR1_to_NAND5#14pin@757_polysilicon-1##12 9.854
R7053 XOR1_to_NAND5#14pin@757_polysilicon-1##12 XOR1_to_NAND5#14pin@757_polysilicon-1##13 9.854
R7054 XOR1_to_NAND5#14pin@757_polysilicon-1##13 XOR1_to_NAND5#14pin@757_polysilicon-1##14 9.854
R7055 XOR1_to_NAND5#14pin@757_polysilicon-1##14 XOR1_to_NAND5#14pin@757_polysilicon-1##15 9.854
R7056 XOR1_to_NAND5#14pin@757_polysilicon-1##15 XOR1_to_NAND5#14pin@757_polysilicon-1##16 9.854
R7057 XOR1_to_NAND5#14pin@757_polysilicon-1##16 XOR1_to_NAND5#14pin@757_polysilicon-1##17 9.854
R7058 XOR1_to_NAND5#14pin@757_polysilicon-1##17 XOR1_to_NAND5#14pin@757_polysilicon-1##18 9.854
R7059 XOR1_to_NAND5#14pin@757_polysilicon-1##18 XOR1_to_NAND5#14pin@757_polysilicon-1##19 9.854
R7060 XOR1_to_NAND5#14pin@757_polysilicon-1##19 XOR1_to_NAND5#14pin@757_polysilicon-1##20 9.854
R7061 XOR1_to_NAND5#14pin@757_polysilicon-1##20 XOR1_to_NAND5#14pin@757_polysilicon-1##21 9.854
R7062 XOR1_to_NAND5#14pin@757_polysilicon-1##21 XOR1_to_NAND5#14pin@757_polysilicon-1##22 9.854
R7063 XOR1_to_NAND5#14pin@757_polysilicon-1##22 XOR1_to_NAND5#14pin@757_polysilicon-1##23 9.854
R7064 XOR1_to_NAND5#14pin@757_polysilicon-1##23 XOR1_to_NAND5#14pin@757_polysilicon-1##24 9.854
R7065 XOR1_to_NAND5#14pin@757_polysilicon-1##24 XOR1_to_NAND5#14pin@757_polysilicon-1##25 9.854
R7066 XOR1_to_NAND5#14pin@757_polysilicon-1##25 XOR1_to_NAND5#14pin@757_polysilicon-1##26 9.854
R7067 XOR1_to_NAND5#14pin@757_polysilicon-1##26 XOR1_to_NAND5#14pin@757_polysilicon-1##27 9.854
R7068 XOR1_to_NAND5#14pin@757_polysilicon-1##27 XOR1_to_NAND5#14pin@757_polysilicon-1##28 9.854
R7069 XOR1_to_NAND5#14pin@757_polysilicon-1##28 XOR1_to_NAND5#14pin@757_polysilicon-1##29 9.854
R7070 XOR1_to_NAND5#14pin@757_polysilicon-1##29 XOR1_to_NAND5#14pin@757_polysilicon-1##30 9.854
R7071 XOR1_to_NAND5#14pin@757_polysilicon-1##30 XOR1_to_NAND5#14pin@757_polysilicon-1##31 9.854
R7072 XOR1_to_NAND5#14pin@757_polysilicon-1##31 XOR1_to_NAND5#14pin@757_polysilicon-1##32 9.854
R7073 XOR1_to_NAND5#14pin@757_polysilicon-1##32 XOR1_to_NAND5#14pin@757_polysilicon-1##33 9.854
R7074 XOR1_to_NAND5#14pin@757_polysilicon-1##33 XOR1_to_NAND5#14pin@757_polysilicon-1##34 9.854
R7075 XOR1_to_NAND5#14pin@757_polysilicon-1##34 XOR1_to_NAND5#14pin@757_polysilicon-1##35 9.854
R7076 XOR1_to_NAND5#14pin@757_polysilicon-1##35 XOR1_to_NAND5#14pin@757_polysilicon-1##36 9.854
R7077 XOR1_to_NAND5#14pin@757_polysilicon-1##36 XOR1_to_NAND5#14pin@757_polysilicon-1##37 9.854
R7078 XOR1_to_NAND5#14pin@757_polysilicon-1##37 XOR1_to_NAND5#14pin@757_polysilicon-1##38 9.854
R7079 XOR1_to_NAND5#14pin@757_polysilicon-1##38 XOR1_to_NAND5#14pin@757_polysilicon-1##39 9.854
R7080 XOR1_to_NAND5#14pin@757_polysilicon-1##39 XOR1_to_NAND5#14pin@757_polysilicon-1##40 9.854
R7081 XOR1_to_NAND5#14pin@757_polysilicon-1##40 XOR1_to_NAND5#14pin@757_polysilicon-1##41 9.854
R7082 XOR1_to_NAND5#14pin@757_polysilicon-1##41 XOR1_to_NAND5#14pin@757_polysilicon-1##42 9.854
R7083 XOR1_to_NAND5#14pin@757_polysilicon-1##42 XOR1_to_NAND5#14pin@757_polysilicon-1##43 9.854
R7084 XOR1_to_NAND5#14pin@757_polysilicon-1##43 XOR1_to_NAND5#14pin@757_polysilicon-1##44 9.854
R7085 XOR1_to_NAND5#14pin@757_polysilicon-1##44 XOR1_to_NAND5#14pin@757_polysilicon-1##45 9.854
R7086 XOR1_to_NAND5#14pin@757_polysilicon-1##45 XOR1_to_NAND5#14pin@757_polysilicon-1##46 9.854
R7087 XOR1_to_NAND5#14pin@757_polysilicon-1##46 XOR1_to_NAND5#14pin@757_polysilicon-1##47 9.854
R7088 XOR1_to_NAND5#14pin@757_polysilicon-1##47 XOR1_to_NAND5#14pin@757_polysilicon-1##48 9.854
R7089 XOR1_to_NAND5#14pin@757_polysilicon-1##48 XOR1_to_NAND5#14pin@757_polysilicon-1##49 9.854
R7090 XOR1_to_NAND5#14pin@757_polysilicon-1##49 XOR1_to_NAND5#14pin@757_polysilicon-1##50 9.854
R7091 XOR1_to_NAND5#14pin@757_polysilicon-1##50 XOR1_to_NAND5#14pin@757_polysilicon-1##51 9.854
R7092 XOR1_to_NAND5#14pin@757_polysilicon-1##51 XOR1_to_NAND5#14pin@757_polysilicon-1##52 9.854
R7093 XOR1_to_NAND5#14pin@757_polysilicon-1##52 XOR1_to_NAND5#14pin@757_polysilicon-1##53 9.854
R7094 XOR1_to_NAND5#14pin@757_polysilicon-1##53 XOR1_to_NAND5#14pin@757_polysilicon-1##54 9.854
R7095 XOR1_to_NAND5#14pin@757_polysilicon-1##54 XOR1_to_NAND5#27nmos@134_poly-right 9.854
R7096 Cin_to_XOR2___NAND5#29pmos@135_poly-right Cin_to_XOR2___NAND5#29pmos@135_poly-right##0 9.877
R7097 Cin_to_XOR2___NAND5#29pmos@135_poly-right##0 Cin_to_XOR2___NAND5#29pmos@135_poly-right##1 9.877
R7098 Cin_to_XOR2___NAND5#29pmos@135_poly-right##1 Cin_to_XOR2___NAND5#29pmos@135_poly-right##2 9.877
R7099 Cin_to_XOR2___NAND5#29pmos@135_poly-right##2 Cin_to_XOR2___NAND5#29pmos@135_poly-right##3 9.877
R7100 Cin_to_XOR2___NAND5#29pmos@135_poly-right##3 Cin_to_XOR2___NAND5#29pmos@135_poly-right##4 9.877
R7101 Cin_to_XOR2___NAND5#29pmos@135_poly-right##4 Cin_to_XOR2___NAND5#29pmos@135_poly-right##5 9.877
R7102 Cin_to_XOR2___NAND5#29pmos@135_poly-right##5 Cin_to_XOR2___NAND5#29pmos@135_poly-right##6 9.877
R7103 Cin_to_XOR2___NAND5#29pmos@135_poly-right##6 Cin_to_XOR2___NAND5#29pmos@135_poly-right##7 9.877
R7104 Cin_to_XOR2___NAND5#29pmos@135_poly-right##7 Cin_to_XOR2___NAND5#29pmos@135_poly-right##8 9.877
R7105 Cin_to_XOR2___NAND5#29pmos@135_poly-right##8 Cin_to_XOR2___NAND5#29pmos@135_poly-right##9 9.877
R7106 Cin_to_XOR2___NAND5#29pmos@135_poly-right##9 Cin_to_XOR2___NAND5#29pmos@135_poly-right##10 9.877
R7107 Cin_to_XOR2___NAND5#29pmos@135_poly-right##10 Cin_to_XOR2___NAND5#29pmos@135_poly-right##11 9.877
R7108 Cin_to_XOR2___NAND5#29pmos@135_poly-right##11 Cin_to_XOR2___NAND5#29pmos@135_poly-right##12 9.877
R7109 Cin_to_XOR2___NAND5#29pmos@135_poly-right##12 Cin_to_XOR2___NAND5#29pmos@135_poly-right##13 9.877
R7110 Cin_to_XOR2___NAND5#29pmos@135_poly-right##13 Cin_to_XOR2___NAND5#29pmos@135_poly-right##14 9.877
R7111 Cin_to_XOR2___NAND5#29pmos@135_poly-right##14 Cin_to_XOR2___NAND5#29pmos@135_poly-right##15 9.877
R7112 Cin_to_XOR2___NAND5#29pmos@135_poly-right##15 Cin_to_XOR2___NAND5#29pmos@135_poly-right##16 9.877
R7113 Cin_to_XOR2___NAND5#29pmos@135_poly-right##16 Cin_to_XOR2___NAND5#29pmos@135_poly-right##17 9.877
R7114 Cin_to_XOR2___NAND5#29pmos@135_poly-right##17 Cin_to_XOR2___NAND5#29pmos@135_poly-right##18 9.877
R7115 Cin_to_XOR2___NAND5#29pmos@135_poly-right##18 Cin_to_XOR2___NAND5#29pmos@135_poly-right##19 9.877
R7116 Cin_to_XOR2___NAND5#29pmos@135_poly-right##19 Cin_to_XOR2___NAND5#29pmos@135_poly-right##20 9.877
R7117 Cin_to_XOR2___NAND5#29pmos@135_poly-right##20 Cin_to_XOR2___NAND5#29pmos@135_poly-right##21 9.877
R7118 Cin_to_XOR2___NAND5#29pmos@135_poly-right##21 Cin_to_XOR2___NAND5#29pmos@135_poly-right##22 9.877
R7119 Cin_to_XOR2___NAND5#29pmos@135_poly-right##22 Cin_to_XOR2___NAND5#29pmos@135_poly-right##23 9.877
R7120 Cin_to_XOR2___NAND5#29pmos@135_poly-right##23 Cin_to_XOR2___NAND5#29pmos@135_poly-right##24 9.877
R7121 Cin_to_XOR2___NAND5#29pmos@135_poly-right##24 Cin_to_XOR2___NAND5#29pmos@135_poly-right##25 9.877
R7122 Cin_to_XOR2___NAND5#29pmos@135_poly-right##25 Cin_to_XOR2___NAND5#29pmos@135_poly-right##26 9.877
R7123 Cin_to_XOR2___NAND5#29pmos@135_poly-right##26 Cin_to_XOR2___NAND5#29pmos@135_poly-right##27 9.877
R7124 Cin_to_XOR2___NAND5#29pmos@135_poly-right##27 Cin_to_XOR2___NAND5#29pmos@135_poly-right##28 9.877
R7125 Cin_to_XOR2___NAND5#29pmos@135_poly-right##28 Cin_to_XOR2___NAND5#29pmos@135_poly-right##29 9.877
R7126 Cin_to_XOR2___NAND5#29pmos@135_poly-right##29 Cin_to_XOR2___NAND5#29pmos@135_poly-right##30 9.877
R7127 Cin_to_XOR2___NAND5#29pmos@135_poly-right##30 Cin_to_XOR2___NAND5#29pmos@135_poly-right##31 9.877
R7128 Cin_to_XOR2___NAND5#29pmos@135_poly-right##31 Cin_to_XOR2___NAND5#29pmos@135_poly-right##32 9.877
R7129 Cin_to_XOR2___NAND5#29pmos@135_poly-right##32 Cin_to_XOR2___NAND5#29pmos@135_poly-right##33 9.877
R7130 Cin_to_XOR2___NAND5#29pmos@135_poly-right##33 Cin_to_XOR2___NAND5#29pmos@135_poly-right##34 9.877
R7131 Cin_to_XOR2___NAND5#29pmos@135_poly-right##34 Cin_to_XOR2___NAND5#29pmos@135_poly-right##35 9.877
R7132 Cin_to_XOR2___NAND5#29pmos@135_poly-right##35 Cin_to_XOR2___NAND5#29pmos@135_poly-right##36 9.877
R7133 Cin_to_XOR2___NAND5#29pmos@135_poly-right##36 Cin_to_XOR2___NAND5#29pmos@135_poly-right##37 9.877
R7134 Cin_to_XOR2___NAND5#29pmos@135_poly-right##37 Cin_to_XOR2___NAND5#29pmos@135_poly-right##38 9.877
R7135 Cin_to_XOR2___NAND5#29pmos@135_poly-right##38 Cin_to_XOR2___NAND5#29pmos@135_poly-right##39 9.877
R7136 Cin_to_XOR2___NAND5#29pmos@135_poly-right##39 Cin_to_XOR2___NAND5#29pmos@135_poly-right##40 9.877
R7137 Cin_to_XOR2___NAND5#29pmos@135_poly-right##40 Cin_to_XOR2___NAND5#29pmos@135_poly-right##41 9.877
R7138 Cin_to_XOR2___NAND5#29pmos@135_poly-right##41 Cin_to_XOR2___NAND5#29pmos@135_poly-right##42 9.877
R7139 Cin_to_XOR2___NAND5#29pmos@135_poly-right##42 Cin_to_XOR2___NAND5#29pmos@135_poly-right##43 9.877
R7140 Cin_to_XOR2___NAND5#29pmos@135_poly-right##43 Cin_to_XOR2___NAND5#29pmos@135_poly-right##44 9.877
R7141 Cin_to_XOR2___NAND5#29pmos@135_poly-right##44 Cin_to_XOR2___NAND5#29pmos@135_poly-right##45 9.877
R7142 Cin_to_XOR2___NAND5#29pmos@135_poly-right##45 Cin_to_XOR2___NAND5#29pmos@135_poly-right##46 9.877
R7143 Cin_to_XOR2___NAND5#29pmos@135_poly-right##46 Cin_to_XOR2___NAND5#29pmos@135_poly-right##47 9.877
R7144 Cin_to_XOR2___NAND5#29pmos@135_poly-right##47 Cin_to_XOR2___NAND5#29pmos@135_poly-right##48 9.877
R7145 Cin_to_XOR2___NAND5#29pmos@135_poly-right##48 Cin_to_XOR2___NAND5#29pmos@135_poly-right##49 9.877
R7146 Cin_to_XOR2___NAND5#29pmos@135_poly-right##49 Cin_to_XOR2___NAND5#23pin@761_polysilicon-1 9.877
R7147 NAND1_to_NAND7 NAND1_to_NAND7#4nmos@135_diff-bottom 4.823
R7148 A4#10pin@764_polysilicon-1 A4#10pin@764_polysilicon-1##0 9.938
R7149 A4#10pin@764_polysilicon-1##0 A4#10pin@764_polysilicon-1##1 9.938
R7150 A4#10pin@764_polysilicon-1##1 A4#10pin@764_polysilicon-1##2 9.938
R7151 A4#10pin@764_polysilicon-1##2 A4#10pin@764_polysilicon-1##3 9.938
R7152 A4#10pin@764_polysilicon-1##3 A4#10pin@764_polysilicon-1##4 9.938
R7153 A4#10pin@764_polysilicon-1##4 A4#10pin@764_polysilicon-1##5 9.938
R7154 A4#10pin@764_polysilicon-1##5 A4#10pin@764_polysilicon-1##6 9.938
R7155 A4#10pin@764_polysilicon-1##6 A4#10pin@764_polysilicon-1##7 9.938
R7156 A4#10pin@764_polysilicon-1##7 A4#10pin@764_polysilicon-1##8 9.938
R7157 A4#10pin@764_polysilicon-1##8 A4#10pin@764_polysilicon-1##9 9.938
R7158 A4#10pin@764_polysilicon-1##9 A4#10pin@764_polysilicon-1##10 9.938
R7159 A4#10pin@764_polysilicon-1##10 A4#10pin@764_polysilicon-1##11 9.938
R7160 A4#10pin@764_polysilicon-1##11 A4#10pin@764_polysilicon-1##12 9.938
R7161 A4#10pin@764_polysilicon-1##12 A4#10pin@764_polysilicon-1##13 9.938
R7162 A4#10pin@764_polysilicon-1##13 A4#10pin@764_polysilicon-1##14 9.938
R7163 A4#10pin@764_polysilicon-1##14 A4#10pin@764_polysilicon-1##15 9.938
R7164 A4#10pin@764_polysilicon-1##15 A4#10pin@764_polysilicon-1##16 9.938
R7165 A4#10pin@764_polysilicon-1##16 A4#10pin@764_polysilicon-1##17 9.938
R7166 A4#10pin@764_polysilicon-1##17 A4#10pin@764_polysilicon-1##18 9.938
R7167 A4#10pin@764_polysilicon-1##18 A4#10pin@764_polysilicon-1##19 9.938
R7168 A4#10pin@764_polysilicon-1##19 A4#10pin@764_polysilicon-1##20 9.938
R7169 A4#10pin@764_polysilicon-1##20 A4#10pin@764_polysilicon-1##21 9.938
R7170 A4#10pin@764_polysilicon-1##21 A4#10pin@764_polysilicon-1##22 9.938
R7171 A4#10pin@764_polysilicon-1##22 A4#10pin@764_polysilicon-1##23 9.938
R7172 A4#10pin@764_polysilicon-1##23 A4#10pin@764_polysilicon-1##24 9.938
R7173 A4#10pin@764_polysilicon-1##24 A4#10pin@764_polysilicon-1##25 9.938
R7174 A4#10pin@764_polysilicon-1##25 A4#10pin@764_polysilicon-1##26 9.938
R7175 A4#10pin@764_polysilicon-1##26 A4#10pin@764_polysilicon-1##27 9.938
R7176 A4#10pin@764_polysilicon-1##27 A4#10pin@764_polysilicon-1##28 9.938
R7177 A4#10pin@764_polysilicon-1##28 A4#10pin@764_polysilicon-1##29 9.938
R7178 A4#10pin@764_polysilicon-1##29 A4#10pin@764_polysilicon-1##30 9.938
R7179 A4#10pin@764_polysilicon-1##30 A4#10pin@764_polysilicon-1##31 9.938
R7180 A4#10pin@764_polysilicon-1##31 A4#10pin@764_polysilicon-1##32 9.938
R7181 A4#10pin@764_polysilicon-1##32 A4#10pin@764_polysilicon-1##33 9.938
R7182 A4#10pin@764_polysilicon-1##33 A4#10pin@764_polysilicon-1##34 9.938
R7183 A4#10pin@764_polysilicon-1##34 A4#10pin@764_polysilicon-1##35 9.938
R7184 A4#10pin@764_polysilicon-1##35 A4#10pin@764_polysilicon-1##36 9.938
R7185 A4#10pin@764_polysilicon-1##36 A4#10pin@764_polysilicon-1##37 9.938
R7186 A4#10pin@764_polysilicon-1##37 A4#10pin@764_polysilicon-1##38 9.938
R7187 A4#10pin@764_polysilicon-1##38 A4#10pin@764_polysilicon-1##39 9.938
R7188 A4#10pin@764_polysilicon-1##39 A4#10pin@764_polysilicon-1##40 9.938
R7189 A4#10pin@764_polysilicon-1##40 A4#10pin@764_polysilicon-1##41 9.938
R7190 A4#10pin@764_polysilicon-1##41 A4#10pin@764_polysilicon-1##42 9.938
R7191 A4#10pin@764_polysilicon-1##42 A4#10pin@764_polysilicon-1##43 9.938
R7192 A4#10pin@764_polysilicon-1##43 A4#10pin@764_polysilicon-1##44 9.938
R7193 A4#10pin@764_polysilicon-1##44 A4#10pin@764_polysilicon-1##45 9.938
R7194 A4#10pin@764_polysilicon-1##45 A4#10pin@764_polysilicon-1##46 9.938
R7195 A4#10pin@764_polysilicon-1##46 A4#10pin@764_polysilicon-1##47 9.938
R7196 A4#10pin@764_polysilicon-1##47 A4#10pin@764_polysilicon-1##48 9.938
R7197 A4#10pin@764_polysilicon-1##48 A4#10pin@764_polysilicon-1##49 9.938
R7198 A4#10pin@764_polysilicon-1##49 A4#19nmos@136_poly-right 9.938
R7199 B4#20pmos@137_poly-right B4#20pmos@137_poly-right##0 9.869
R7200 B4#20pmos@137_poly-right##0 B4#20pmos@137_poly-right##1 9.869
R7201 B4#20pmos@137_poly-right##1 B4#20pmos@137_poly-right##2 9.869
R7202 B4#20pmos@137_poly-right##2 B4#20pmos@137_poly-right##3 9.869
R7203 B4#20pmos@137_poly-right##3 B4#20pmos@137_poly-right##4 9.869
R7204 B4#20pmos@137_poly-right##4 B4#20pmos@137_poly-right##5 9.869
R7205 B4#20pmos@137_poly-right##5 B4#20pmos@137_poly-right##6 9.869
R7206 B4#20pmos@137_poly-right##6 B4#20pmos@137_poly-right##7 9.869
R7207 B4#20pmos@137_poly-right##7 B4#20pmos@137_poly-right##8 9.869
R7208 B4#20pmos@137_poly-right##8 B4#20pmos@137_poly-right##9 9.869
R7209 B4#20pmos@137_poly-right##9 B4#20pmos@137_poly-right##10 9.869
R7210 B4#20pmos@137_poly-right##10 B4#20pmos@137_poly-right##11 9.869
R7211 B4#20pmos@137_poly-right##11 B4#20pmos@137_poly-right##12 9.869
R7212 B4#20pmos@137_poly-right##12 B4#20pmos@137_poly-right##13 9.869
R7213 B4#20pmos@137_poly-right##13 B4#20pmos@137_poly-right##14 9.869
R7214 B4#20pmos@137_poly-right##14 B4#20pmos@137_poly-right##15 9.869
R7215 B4#20pmos@137_poly-right##15 B4#20pmos@137_poly-right##16 9.869
R7216 B4#20pmos@137_poly-right##16 B4#20pmos@137_poly-right##17 9.869
R7217 B4#20pmos@137_poly-right##17 B4#20pmos@137_poly-right##18 9.869
R7218 B4#20pmos@137_poly-right##18 B4#20pmos@137_poly-right##19 9.869
R7219 B4#20pmos@137_poly-right##19 B4#20pmos@137_poly-right##20 9.869
R7220 B4#20pmos@137_poly-right##20 B4#20pmos@137_poly-right##21 9.869
R7221 B4#20pmos@137_poly-right##21 B4#20pmos@137_poly-right##22 9.869
R7222 B4#20pmos@137_poly-right##22 B4#20pmos@137_poly-right##23 9.869
R7223 B4#20pmos@137_poly-right##23 B4#20pmos@137_poly-right##24 9.869
R7224 B4#20pmos@137_poly-right##24 B4#20pmos@137_poly-right##25 9.869
R7225 B4#20pmos@137_poly-right##25 B4#20pmos@137_poly-right##26 9.869
R7226 B4#20pmos@137_poly-right##26 B4#20pmos@137_poly-right##27 9.869
R7227 B4#20pmos@137_poly-right##27 B4#20pmos@137_poly-right##28 9.869
R7228 B4#20pmos@137_poly-right##28 B4#20pmos@137_poly-right##29 9.869
R7229 B4#20pmos@137_poly-right##29 B4#20pmos@137_poly-right##30 9.869
R7230 B4#20pmos@137_poly-right##30 B4#20pmos@137_poly-right##31 9.869
R7231 B4#20pmos@137_poly-right##31 B4#20pmos@137_poly-right##32 9.869
R7232 B4#20pmos@137_poly-right##32 B4#20pmos@137_poly-right##33 9.869
R7233 B4#20pmos@137_poly-right##33 B4#20pmos@137_poly-right##34 9.869
R7234 B4#20pmos@137_poly-right##34 B4#20pmos@137_poly-right##35 9.869
R7235 B4#20pmos@137_poly-right##35 B4#20pmos@137_poly-right##36 9.869
R7236 B4#20pmos@137_poly-right##36 B4#20pmos@137_poly-right##37 9.869
R7237 B4#20pmos@137_poly-right##37 B4#20pmos@137_poly-right##38 9.869
R7238 B4#20pmos@137_poly-right##38 B4#20pmos@137_poly-right##39 9.869
R7239 B4#20pmos@137_poly-right##39 B4#20pmos@137_poly-right##40 9.869
R7240 B4#20pmos@137_poly-right##40 B4#20pmos@137_poly-right##41 9.869
R7241 B4#20pmos@137_poly-right##41 B4#20pmos@137_poly-right##42 9.869
R7242 B4#20pmos@137_poly-right##42 B4#20pmos@137_poly-right##43 9.869
R7243 B4#20pmos@137_poly-right##43 B4#20pmos@137_poly-right##44 9.869
R7244 B4#20pmos@137_poly-right##44 B4#20pmos@137_poly-right##45 9.869
R7245 B4#20pmos@137_poly-right##45 B4#20pmos@137_poly-right##46 9.869
R7246 B4#20pmos@137_poly-right##46 B4#20pmos@137_poly-right##47 9.869
R7247 B4#20pmos@137_poly-right##47 B4#10pin@768_polysilicon-1 9.869
R7248 NAND2_to_Nand7#9pin@770_polysilicon-1 NAND2_to_Nand7#9pin@770_polysilicon-1##0 9.938
R7249 NAND2_to_Nand7#9pin@770_polysilicon-1##0 NAND2_to_Nand7#9pin@770_polysilicon-1##1 9.938
R7250 NAND2_to_Nand7#9pin@770_polysilicon-1##1 NAND2_to_Nand7#9pin@770_polysilicon-1##2 9.938
R7251 NAND2_to_Nand7#9pin@770_polysilicon-1##2 NAND2_to_Nand7#9pin@770_polysilicon-1##3 9.938
R7252 NAND2_to_Nand7#9pin@770_polysilicon-1##3 NAND2_to_Nand7#9pin@770_polysilicon-1##4 9.938
R7253 NAND2_to_Nand7#9pin@770_polysilicon-1##4 NAND2_to_Nand7#9pin@770_polysilicon-1##5 9.938
R7254 NAND2_to_Nand7#9pin@770_polysilicon-1##5 NAND2_to_Nand7#9pin@770_polysilicon-1##6 9.938
R7255 NAND2_to_Nand7#9pin@770_polysilicon-1##6 NAND2_to_Nand7#9pin@770_polysilicon-1##7 9.938
R7256 NAND2_to_Nand7#9pin@770_polysilicon-1##7 NAND2_to_Nand7#9pin@770_polysilicon-1##8 9.938
R7257 NAND2_to_Nand7#9pin@770_polysilicon-1##8 NAND2_to_Nand7#9pin@770_polysilicon-1##9 9.938
R7258 NAND2_to_Nand7#9pin@770_polysilicon-1##9 NAND2_to_Nand7#9pin@770_polysilicon-1##10 9.938
R7259 NAND2_to_Nand7#9pin@770_polysilicon-1##10 NAND2_to_Nand7#9pin@770_polysilicon-1##11 9.938
R7260 NAND2_to_Nand7#9pin@770_polysilicon-1##11 NAND2_to_Nand7#9pin@770_polysilicon-1##12 9.938
R7261 NAND2_to_Nand7#9pin@770_polysilicon-1##12 NAND2_to_Nand7#9pin@770_polysilicon-1##13 9.938
R7262 NAND2_to_Nand7#9pin@770_polysilicon-1##13 NAND2_to_Nand7#9pin@770_polysilicon-1##14 9.938
R7263 NAND2_to_Nand7#9pin@770_polysilicon-1##14 NAND2_to_Nand7#9pin@770_polysilicon-1##15 9.938
R7264 NAND2_to_Nand7#9pin@770_polysilicon-1##15 NAND2_to_Nand7#9pin@770_polysilicon-1##16 9.938
R7265 NAND2_to_Nand7#9pin@770_polysilicon-1##16 NAND2_to_Nand7#9pin@770_polysilicon-1##17 9.938
R7266 NAND2_to_Nand7#9pin@770_polysilicon-1##17 NAND2_to_Nand7#9pin@770_polysilicon-1##18 9.938
R7267 NAND2_to_Nand7#9pin@770_polysilicon-1##18 NAND2_to_Nand7#9pin@770_polysilicon-1##19 9.938
R7268 NAND2_to_Nand7#9pin@770_polysilicon-1##19 NAND2_to_Nand7#9pin@770_polysilicon-1##20 9.938
R7269 NAND2_to_Nand7#9pin@770_polysilicon-1##20 NAND2_to_Nand7#9pin@770_polysilicon-1##21 9.938
R7270 NAND2_to_Nand7#9pin@770_polysilicon-1##21 NAND2_to_Nand7#9pin@770_polysilicon-1##22 9.938
R7271 NAND2_to_Nand7#9pin@770_polysilicon-1##22 NAND2_to_Nand7#9pin@770_polysilicon-1##23 9.938
R7272 NAND2_to_Nand7#9pin@770_polysilicon-1##23 NAND2_to_Nand7#9pin@770_polysilicon-1##24 9.938
R7273 NAND2_to_Nand7#9pin@770_polysilicon-1##24 NAND2_to_Nand7#9pin@770_polysilicon-1##25 9.938
R7274 NAND2_to_Nand7#9pin@770_polysilicon-1##25 NAND2_to_Nand7#9pin@770_polysilicon-1##26 9.938
R7275 NAND2_to_Nand7#9pin@770_polysilicon-1##26 NAND2_to_Nand7#9pin@770_polysilicon-1##27 9.938
R7276 NAND2_to_Nand7#9pin@770_polysilicon-1##27 NAND2_to_Nand7#9pin@770_polysilicon-1##28 9.938
R7277 NAND2_to_Nand7#9pin@770_polysilicon-1##28 NAND2_to_Nand7#9pin@770_polysilicon-1##29 9.938
R7278 NAND2_to_Nand7#9pin@770_polysilicon-1##29 NAND2_to_Nand7#9pin@770_polysilicon-1##30 9.938
R7279 NAND2_to_Nand7#9pin@770_polysilicon-1##30 NAND2_to_Nand7#9pin@770_polysilicon-1##31 9.938
R7280 NAND2_to_Nand7#9pin@770_polysilicon-1##31 NAND2_to_Nand7#9pin@770_polysilicon-1##32 9.938
R7281 NAND2_to_Nand7#9pin@770_polysilicon-1##32 NAND2_to_Nand7#9pin@770_polysilicon-1##33 9.938
R7282 NAND2_to_Nand7#9pin@770_polysilicon-1##33 NAND2_to_Nand7#9pin@770_polysilicon-1##34 9.938
R7283 NAND2_to_Nand7#9pin@770_polysilicon-1##34 NAND2_to_Nand7#9pin@770_polysilicon-1##35 9.938
R7284 NAND2_to_Nand7#9pin@770_polysilicon-1##35 NAND2_to_Nand7#9pin@770_polysilicon-1##36 9.938
R7285 NAND2_to_Nand7#9pin@770_polysilicon-1##36 NAND2_to_Nand7#9pin@770_polysilicon-1##37 9.938
R7286 NAND2_to_Nand7#9pin@770_polysilicon-1##37 NAND2_to_Nand7#9pin@770_polysilicon-1##38 9.938
R7287 NAND2_to_Nand7#9pin@770_polysilicon-1##38 NAND2_to_Nand7#9pin@770_polysilicon-1##39 9.938
R7288 NAND2_to_Nand7#9pin@770_polysilicon-1##39 NAND2_to_Nand7#9pin@770_polysilicon-1##40 9.938
R7289 NAND2_to_Nand7#9pin@770_polysilicon-1##40 NAND2_to_Nand7#9pin@770_polysilicon-1##41 9.938
R7290 NAND2_to_Nand7#9pin@770_polysilicon-1##41 NAND2_to_Nand7#9pin@770_polysilicon-1##42 9.938
R7291 NAND2_to_Nand7#9pin@770_polysilicon-1##42 NAND2_to_Nand7#9pin@770_polysilicon-1##43 9.938
R7292 NAND2_to_Nand7#9pin@770_polysilicon-1##43 NAND2_to_Nand7#9pin@770_polysilicon-1##44 9.938
R7293 NAND2_to_Nand7#9pin@770_polysilicon-1##44 NAND2_to_Nand7#9pin@770_polysilicon-1##45 9.938
R7294 NAND2_to_Nand7#9pin@770_polysilicon-1##45 NAND2_to_Nand7#9pin@770_polysilicon-1##46 9.938
R7295 NAND2_to_Nand7#9pin@770_polysilicon-1##46 NAND2_to_Nand7#9pin@770_polysilicon-1##47 9.938
R7296 NAND2_to_Nand7#9pin@770_polysilicon-1##47 NAND2_to_Nand7#9pin@770_polysilicon-1##48 9.938
R7297 NAND2_to_Nand7#9pin@770_polysilicon-1##48 NAND2_to_Nand7#9pin@770_polysilicon-1##49 9.938
R7298 NAND2_to_Nand7#9pin@770_polysilicon-1##49 NAND2_to_Nand7#11nmos@138_poly-right 9.938
R7299 NAND1_to_NAND7#14nmos@139_poly-right NAND1_to_NAND7#14nmos@139_poly-right##0 9.898
R7300 NAND1_to_NAND7#14nmos@139_poly-right##0 NAND1_to_NAND7#14nmos@139_poly-right##1 9.898
R7301 NAND1_to_NAND7#14nmos@139_poly-right##1 NAND1_to_NAND7#14nmos@139_poly-right##2 9.898
R7302 NAND1_to_NAND7#14nmos@139_poly-right##2 NAND1_to_NAND7#14nmos@139_poly-right##3 9.898
R7303 NAND1_to_NAND7#14nmos@139_poly-right##3 NAND1_to_NAND7#14nmos@139_poly-right##4 9.898
R7304 NAND1_to_NAND7#14nmos@139_poly-right##4 NAND1_to_NAND7#14nmos@139_poly-right##5 9.898
R7305 NAND1_to_NAND7#14nmos@139_poly-right##5 NAND1_to_NAND7#14nmos@139_poly-right##6 9.898
R7306 NAND1_to_NAND7#14nmos@139_poly-right##6 NAND1_to_NAND7#14nmos@139_poly-right##7 9.898
R7307 NAND1_to_NAND7#14nmos@139_poly-right##7 NAND1_to_NAND7#14nmos@139_poly-right##8 9.898
R7308 NAND1_to_NAND7#14nmos@139_poly-right##8 NAND1_to_NAND7#14nmos@139_poly-right##9 9.898
R7309 NAND1_to_NAND7#14nmos@139_poly-right##9 NAND1_to_NAND7#14nmos@139_poly-right##10 9.898
R7310 NAND1_to_NAND7#14nmos@139_poly-right##10 NAND1_to_NAND7#14nmos@139_poly-right##11 9.898
R7311 NAND1_to_NAND7#14nmos@139_poly-right##11 NAND1_to_NAND7#14nmos@139_poly-right##12 9.898
R7312 NAND1_to_NAND7#14nmos@139_poly-right##12 NAND1_to_NAND7#14nmos@139_poly-right##13 9.898
R7313 NAND1_to_NAND7#14nmos@139_poly-right##13 NAND1_to_NAND7#14nmos@139_poly-right##14 9.898
R7314 NAND1_to_NAND7#14nmos@139_poly-right##14 NAND1_to_NAND7#14nmos@139_poly-right##15 9.898
R7315 NAND1_to_NAND7#14nmos@139_poly-right##15 NAND1_to_NAND7#14nmos@139_poly-right##16 9.898
R7316 NAND1_to_NAND7#14nmos@139_poly-right##16 NAND1_to_NAND7#14nmos@139_poly-right##17 9.898
R7317 NAND1_to_NAND7#14nmos@139_poly-right##17 NAND1_to_NAND7#14nmos@139_poly-right##18 9.898
R7318 NAND1_to_NAND7#14nmos@139_poly-right##18 NAND1_to_NAND7#14nmos@139_poly-right##19 9.898
R7319 NAND1_to_NAND7#14nmos@139_poly-right##19 NAND1_to_NAND7#14nmos@139_poly-right##20 9.898
R7320 NAND1_to_NAND7#14nmos@139_poly-right##20 NAND1_to_NAND7#14nmos@139_poly-right##21 9.898
R7321 NAND1_to_NAND7#14nmos@139_poly-right##21 NAND1_to_NAND7#14nmos@139_poly-right##22 9.898
R7322 NAND1_to_NAND7#14nmos@139_poly-right##22 NAND1_to_NAND7#14nmos@139_poly-right##23 9.898
R7323 NAND1_to_NAND7#14nmos@139_poly-right##23 NAND1_to_NAND7#14nmos@139_poly-right##24 9.898
R7324 NAND1_to_NAND7#14nmos@139_poly-right##24 NAND1_to_NAND7#14nmos@139_poly-right##25 9.898
R7325 NAND1_to_NAND7#14nmos@139_poly-right##25 NAND1_to_NAND7#14nmos@139_poly-right##26 9.898
R7326 NAND1_to_NAND7#14nmos@139_poly-right##26 NAND1_to_NAND7#14nmos@139_poly-right##27 9.898
R7327 NAND1_to_NAND7#14nmos@139_poly-right##27 NAND1_to_NAND7#14nmos@139_poly-right##28 9.898
R7328 NAND1_to_NAND7#14nmos@139_poly-right##28 NAND1_to_NAND7#14nmos@139_poly-right##29 9.898
R7329 NAND1_to_NAND7#14nmos@139_poly-right##29 NAND1_to_NAND7#14nmos@139_poly-right##30 9.898
R7330 NAND1_to_NAND7#14nmos@139_poly-right##30 NAND1_to_NAND7#14nmos@139_poly-right##31 9.898
R7331 NAND1_to_NAND7#14nmos@139_poly-right##31 NAND1_to_NAND7#14nmos@139_poly-right##32 9.898
R7332 NAND1_to_NAND7#14nmos@139_poly-right##32 NAND1_to_NAND7#14nmos@139_poly-right##33 9.898
R7333 NAND1_to_NAND7#14nmos@139_poly-right##33 NAND1_to_NAND7#14nmos@139_poly-right##34 9.898
R7334 NAND1_to_NAND7#14nmos@139_poly-right##34 NAND1_to_NAND7#14nmos@139_poly-right##35 9.898
R7335 NAND1_to_NAND7#14nmos@139_poly-right##35 NAND1_to_NAND7#14nmos@139_poly-right##36 9.898
R7336 NAND1_to_NAND7#14nmos@139_poly-right##36 NAND1_to_NAND7#14nmos@139_poly-right##37 9.898
R7337 NAND1_to_NAND7#14nmos@139_poly-right##37 NAND1_to_NAND7#14nmos@139_poly-right##38 9.898
R7338 NAND1_to_NAND7#14nmos@139_poly-right##38 NAND1_to_NAND7#14nmos@139_poly-right##39 9.898
R7339 NAND1_to_NAND7#14nmos@139_poly-right##39 NAND1_to_NAND7#14nmos@139_poly-right##40 9.898
R7340 NAND1_to_NAND7#14nmos@139_poly-right##40 NAND1_to_NAND7#14nmos@139_poly-right##41 9.898
R7341 NAND1_to_NAND7#14nmos@139_poly-right##41 NAND1_to_NAND7#14nmos@139_poly-right##42 9.898
R7342 NAND1_to_NAND7#14nmos@139_poly-right##42 NAND1_to_NAND7#14nmos@139_poly-right##43 9.898
R7343 NAND1_to_NAND7#14nmos@139_poly-right##43 NAND1_to_NAND7#14nmos@139_poly-right##44 9.898
R7344 NAND1_to_NAND7#14nmos@139_poly-right##44 NAND1_to_NAND7#14nmos@139_poly-right##45 9.898
R7345 NAND1_to_NAND7#14nmos@139_poly-right##45 NAND1_to_NAND7#14nmos@139_poly-right##46 9.898
R7346 NAND1_to_NAND7#14nmos@139_poly-right##46 NAND1_to_NAND7#14nmos@139_poly-right##47 9.898
R7347 NAND1_to_NAND7#14nmos@139_poly-right##47 NAND1_to_NAND7#14nmos@139_poly-right##48 9.898
R7348 NAND1_to_NAND7#14nmos@139_poly-right##48 NAND1_to_NAND7#14nmos@139_poly-right##49 9.898
R7349 NAND1_to_NAND7#14nmos@139_poly-right##49 NAND1_to_NAND7#14nmos@139_poly-right##50 9.898
R7350 NAND1_to_NAND7#14nmos@139_poly-right##50 NAND1_to_NAND7#14nmos@139_poly-right##51 9.898
R7351 NAND1_to_NAND7#14nmos@139_poly-right##51 NAND1_to_NAND7#14nmos@139_poly-right##52 9.898
R7352 NAND1_to_NAND7#14nmos@139_poly-right##52 NAND1_to_NAND7#14nmos@139_poly-right##53 9.898
R7353 NAND1_to_NAND7#14nmos@139_poly-right##53 NAND1_to_NAND7#14nmos@139_poly-right##54 9.898
R7354 NAND1_to_NAND7#14nmos@139_poly-right##54 NAND1_to_NAND7#14nmos@139_poly-right##55 9.898
R7355 NAND1_to_NAND7#14nmos@139_poly-right##55 NAND1_to_NAND7#11pmos@139_poly-right 9.898
R7356 Cout Cout#2nmos@139_diff-bottom 4.42
R7357 NAND2_to_Nand7 NAND2_to_Nand7#4nmos@137_diff-bottom 4.42
R7358 A3 A3##0 7.79
C349 A3##0 0 10.028fF
R7359 A3##0 A3##1 7.79
C350 A3##1 0 10.028fF
R7360 A3##1 A3##2 7.79
C351 A3##2 0 10.028fF
R7361 A3##2 A3#1pin@681_metal-2 7.79
R7362 B3 B3##0 7.767
C352 B3##0 0 9.999fF
R7363 B3##0 B3##1 7.767
C353 B3##1 0 9.999fF
R7364 B3##1 B3##2 7.767
C354 B3##2 0 9.999fF
R7365 B3##2 B3#1pin@683_metal-2 7.767
R7366 B4 B4##0 8.523
C355 B4##0 0 11.428fF
R7367 B4##0 B4##1 8.523
C356 B4##1 0 11.428fF
R7368 B4##1 B4##2 8.523
C357 B4##2 0 11.428fF
R7369 B4##2 B4##3 8.523
C358 B4##3 0 11.428fF
R7370 B4##3 B4#1pin@769_metal-2 8.523
R7371 A4 A4##0 8.541
C359 A4##0 0 11.452fF
R7372 A4##0 A4##1 8.541
C360 A4##1 0 11.452fF
R7373 A4##1 A4##2 8.541
C361 A4##2 0 11.452fF
R7374 A4##2 A4##3 8.541
C362 A4##3 0 11.452fF
R7375 A4##3 A4#1pin@767_metal-2 8.541

* Spice Code nodes in cell cell 'Eight_bit_adder{lay}'
VDD VDD 0 DC 3.3
VGND GND 0 DC 0
vin1 A0 vdd
vin2 A1 vdd
vin3 A2 vdd
vin4 A3 0
vin5 A4 vdd
vin6 B0 vdd
vin7 B1 vdd
vin8 B2 0
vin9 B3 vdd
vin10 B4 vdd
vin11 Cin 0
cload out 0 250fF
.tran 0 100n
.include C:\Electric\C5_models.txt
.END
