*** SPICE deck for cell Eight_bit_adder{lay} from library Proj2
*** Created on Wed Mar 18, 2020 20:18:53
*** Last revised on Thu Mar 19, 2020 01:53:37
*** Written on Thu Mar 19, 2020 01:53:39 by Electric VLSI Design System, version 9.07
*** Layout tech: mocmos, foundry MOSIS
*** UC SPICE *** , MIN_RESIST 4.0, MIN_CAPAC 0.1FF
***    P-Active:	areacap=0.9FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    N-Active:	areacap=0.9FF/um^2,	edgecap=0.0FF/um,	res=3.0ohms/sq
***    Polysilicon-1:	areacap=0.1467FF/um^2,	edgecap=0.0608FF/um,	res=6.2ohms/sq
***    Polysilicon-2:	areacap=1.0FF/um^2,	edgecap=0.0FF/um,	res=50.0ohms/sq
***    Transistor-Poly:	areacap=0.09FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    Poly-Cut:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=2.2ohms/sq
***    Active-Cut:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    Metal-1:	areacap=0.1209FF/um^2,	edgecap=0.1104FF/um,	res=0.078ohms/sq
***    Via1:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=1.0ohms/sq
***    Metal-2:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via2:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.9ohms/sq
***    Metal-3:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via3:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-4:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via4:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-5:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via5:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-6:	areacap=0.0423FF/um^2,	edgecap=0.1273FF/um,	res=0.036ohms/sq
***    Hi-Res:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=1.0ohms/sq

*** TOP LEVEL CELL: Eight_bit_adder{lay}
Mnmos@40 net@676#2contact@256_metal-1-polysilicon-1 A0#15nmos@40_poly-right net@560 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@41 net@817 net@562#11nmos@41_poly-right net@676#2contact@256_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@42 gnd B0#14nmos@42_poly-left net@817 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@43 net@560 net@684#9nmos@43_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@44 net@684#2contact@231_metal-1-metal-2 B0#9nmos@44_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@45 net@562#2pin@166_metal-1 A0#14nmos@45_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@46 XOR1_to_NAND1#1contact@309_metal-1-metal-2 net@676#4nmos@46_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@47 net@576#2contact@295_metal-1-polysilicon-1 XOR1_to_NAND1#26nmos@47_poly-right net@566 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@48 net@638 net@564#11nmos@48_poly-right net@576#2contact@295_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@49 gnd Cin#9nmos@49_poly-left net@638 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@50 net@566 net@577#9nmos@50_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@51 net@577#2contact@270_metal-1-metal-2 Cin#5nmos@51_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@52 net@564#2pin@192_metal-1 XOR1_to_NAND1#24nmos@52_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@53 Sum0 net@576#4nmos@53_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@54 net@674 XOR1_to_NAND1#27nmos@54_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@55 NAND1_to_NAND3#4nmos@55_diff-bottom Cin#16nmos@55_poly-right net@674 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@56 net@706 A0#17nmos@56_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@57 NAND2_to_Nand3#4nmos@57_diff-bottom B0#11nmos@57_poly-right net@706 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@58 net@737 NAND2_to_Nand3#11nmos@58_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@59 Cin_to_XOR2___NAND2#1contact@534_metal-1-metal-2 NAND1_to_NAND3#14nmos@59_poly-right net@737 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@60 net@1307#2contact@491_metal-1-polysilicon-1 A1#18nmos@60_poly-right net@1207 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@61 net@1420 net@1209#11nmos@61_poly-right net@1307#2contact@491_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@62 gnd B1#17nmos@62_poly-left net@1420 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@63 net@1207 net@1314#9nmos@63_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@64 net@1314#2contact@466_metal-1-metal-2 B1#12nmos@64_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@65 net@1209#2pin@342_metal-1 A1#17nmos@65_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@66 XOR1_to_NAND2#1contact@544_metal-1-metal-2 net@1307#4nmos@66_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@67 net@1220#2contact@530_metal-1-polysilicon-1 XOR1_to_NAND2#26nmos@67_poly-right net@1212 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@68 net@1271 net@1211#11nmos@68_poly-right net@1220#2contact@530_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@69 gnd Cin_to_XOR2___NAND2#18nmos@69_poly-left net@1271 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@70 net@1212 net@1221#9nmos@70_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@71 net@1221#2contact@505_metal-1-metal-2 Cin_to_XOR2___NAND2#14nmos@71_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@72 net@1211#2pin@367_metal-1 XOR1_to_NAND2#24nmos@72_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@73 Sum1 net@1220#4nmos@73_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@74 net@1305 XOR1_to_NAND2#27nmos@74_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@75 NAND1_to_NAND4#4nmos@75_diff-bottom Cin_to_XOR2___NAND2#25nmos@75_poly-right net@1305 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@76 net@1332 A1#20nmos@76_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@77 NAND2_to_Nand4#4nmos@77_diff-bottom B1#14nmos@77_poly-right net@1332 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@78 net@1356 NAND2_to_Nand4#11nmos@78_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@79 Cin_to_XOR2___NAND3#1contact@646_metal-1-metal-2 NAND1_to_NAND4#14nmos@79_poly-right net@1356 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@80 net@1907#2contact@603_metal-1-polysilicon-1 A2#17nmos@80_poly-right net@1807 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@81 net@2020 net@1809#11nmos@81_poly-right net@1907#2contact@603_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@82 gnd B2#16nmos@82_poly-left net@2020 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@83 net@1807 net@1914#9nmos@83_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@84 net@1914#2contact@579_metal-1-metal-2 B2#11nmos@84_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@85 net@1809#2pin@536_metal-1 A2#16nmos@85_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@86 XOR1_to_NAND3#1contact@656_metal-1-metal-2 net@1907#4nmos@86_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@87 net@1820#2contact@642_metal-1-polysilicon-1 XOR1_to_NAND3#26nmos@87_poly-right net@1812 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@88 net@1871 net@1811#11nmos@88_poly-right net@1820#2contact@642_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@89 gnd Cin_to_XOR2___NAND3#18nmos@89_poly-left net@1871 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@90 net@1812 net@1821#9nmos@90_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@91 net@1821#2contact@617_metal-1-metal-2 Cin_to_XOR2___NAND3#14nmos@91_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@92 net@1811#2pin@561_metal-1 XOR1_to_NAND3#24nmos@92_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@93 Sum2 net@1820#4nmos@93_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@94 net@1905 XOR1_to_NAND3#27nmos@94_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@95 NAND1_to_NAND5#4nmos@95_diff-bottom Cin_to_XOR2___NAND3#25nmos@95_poly-right net@1905 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@96 net@1932 A2#19nmos@96_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@97 NAND2_to_Nand5#4nmos@97_diff-bottom B2#13nmos@97_poly-right net@1932 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@98 net@1956 NAND2_to_Nand5#11nmos@98_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@99 Cin_to_XOR2___NAND4#1contact@756_metal-1-metal-2 NAND1_to_NAND5#14nmos@99_poly-right net@1956 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@100 net@2204#2contact@713_metal-1-polysilicon-1 A3#17nmos@100_poly-right net@2104 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@101 net@2317 net@2106#11nmos@101_poly-right net@2204#2contact@713_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@102 gnd B3#16nmos@102_poly-left net@2317 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@103 net@2104 net@2211#9nmos@103_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@104 net@2211#2contact@689_metal-1-metal-2 B3#11nmos@104_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@105 net@2106#2pin@631_metal-1 A3#16nmos@105_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@106 XOR1_to_NAND4#1contact@766_metal-1-metal-2 net@2204#4nmos@106_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@107 net@2117#2contact@752_metal-1-polysilicon-1 XOR1_to_NAND4#26nmos@107_poly-right net@2109 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@108 net@2168 net@2108#11nmos@108_poly-right net@2117#2contact@752_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@109 gnd Cin_to_XOR2___NAND4#18nmos@109_poly-left net@2168 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@110 net@2109 net@2118#9nmos@110_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@111 net@2118#2contact@727_metal-1-metal-2 Cin_to_XOR2___NAND4#14nmos@111_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@112 net@2108#2pin@656_metal-1 XOR1_to_NAND4#24nmos@112_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@113 Sum3 net@2117#4nmos@113_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@114 net@2202 XOR1_to_NAND4#27nmos@114_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@115 NAND1_to_NAND6#4nmos@115_diff-bottom Cin_to_XOR2___NAND4#25nmos@115_poly-right net@2202 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@116 net@2229 A3#19nmos@116_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@117 NAND2_to_Nand6#4nmos@117_diff-bottom B3#13nmos@117_poly-right net@2229 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@118 net@2253 NAND2_to_Nand6#11nmos@118_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@119 Cin_to_XOR2___NAND5#1contact@865_metal-1-metal-2 NAND1_to_NAND6#14nmos@119_poly-right net@2253 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@120 net@2490#2contact@822_metal-1-polysilicon-1 A4#17nmos@120_poly-right net@2390 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@121 net@2603 net@2392#11nmos@121_poly-right net@2490#2contact@822_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@122 gnd B4#16nmos@122_poly-left net@2603 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@123 net@2390 net@2497#9nmos@123_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@124 net@2497#2contact@798_metal-1-metal-2 B4#11nmos@124_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@125 net@2392#2pin@717_metal-1 A4#16nmos@125_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@126 XOR1_to_NAND5#1contact@875_metal-1-metal-2 net@2490#4nmos@126_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@127 net@2403#2contact@861_metal-1-polysilicon-1 XOR1_to_NAND5#26nmos@127_poly-right net@2395 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@128 net@2454 net@2394#11nmos@128_poly-right net@2403#2contact@861_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@129 gnd Cin_to_XOR2___NAND5#18nmos@129_poly-left net@2454 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@130 net@2395 net@2404#9nmos@130_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@131 net@2404#2contact@836_metal-1-metal-2 Cin_to_XOR2___NAND5#14nmos@131_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@132 net@2394#2pin@742_metal-1 XOR1_to_NAND5#24nmos@132_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@133 Sum4 net@2403#4nmos@133_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@134 net@2488 XOR1_to_NAND5#27nmos@134_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@135 NAND1_to_NAND7#4nmos@135_diff-bottom Cin_to_XOR2___NAND5#25nmos@135_poly-right net@2488 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@136 net@2515 A4#19nmos@136_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@137 NAND2_to_Nand7#4nmos@137_diff-bottom B4#13nmos@137_poly-right net@2515 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@138 net@2539 NAND2_to_Nand7#11nmos@138_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@139 Cin_to_XOR2___NAND6#1contact@974_metal-1-metal-2 NAND1_to_NAND7#14nmos@139_poly-right net@2539 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@140 net@2725#2contact@931_metal-1-polysilicon-1 A5#15nmos@140_poly-right net@2722 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@141 net@2850 net@2742#11nmos@141_poly-right net@2725#2contact@931_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@142 net@2726 B5#15nmos@142_poly-left net@2850 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@143 net@2722 net@2732#9nmos@143_poly-left net@2726 gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@144 net@2732#2contact@907_metal-1-metal-2 B5#10nmos@144_poly-right net@2726 gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@145 net@2742 A5#14nmos@145_poly-right net@2726 gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@146 XOR1_to_NAND6#1contact@984_metal-1-metal-2 net@2725#4nmos@146_poly-right net@2726 gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@147 net@2767#2contact@970_metal-1-polysilicon-1 XOR1_to_NAND6#21nmos@147_poly-right net@2811 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@148 net@3333 net@2789#6nmos@148_poly-right net@2767#2contact@970_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@149 net@2726 Cin_to_XOR2___NAND6#24nmos@149_poly-right net@3333 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@150 net@2811 net@2778#6nmos@150_poly-right net@2726 gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@151 net@2778#2contact@945_metal-1-metal-2 Cin_to_XOR2___NAND6#20nmos@151_poly-right net@2726 gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@152 net@2789 XOR1_to_NAND6#19nmos@152_poly-right net@2726 gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@153 net@2795 net@2767#8nmos@153_poly-right net@2726 gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@154 net@3577 XOR1_to_NAND6#22nmos@154_poly-right net@2726 gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@155 NAND1_to_NAND8#12contact@979_metal-1-n-act Cin_to_XOR2___NAND6#19nmos@155_poly-right net@3577 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@156 net@2752 A5#17nmos@156_poly-right net@2726 gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@157 NAND2_to_Nand8#4nmos@157_diff-bottom B5#12nmos@157_poly-right net@2752 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@158 net@2779 NAND2_to_Nand8#11nmos@158_poly-right net@2726 gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@159 Cin_to_XOR2___NAND7#1contact@1082_metal-1-metal-2 NAND1_to_NAND8#13nmos@159_poly-right net@2779 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@160 net@3038#2contact@1039_metal-1-polysilicon-1 A6#17nmos@160_poly-right net@2927 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@161 net@3163 net@2929#11nmos@161_poly-right net@3038#2contact@1039_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@162 net@2726#17nmos@165_diff-top B6#16nmos@162_poly-left net@3163 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@163 net@2927 net@3046#9nmos@163_poly-left net@2726#17nmos@165_diff-top gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@164 net@3046#2contact@1015_metal-1-metal-2 B6#11nmos@164_poly-right net@2726#17nmos@165_diff-top gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@165 net@2929#2pin@911_metal-1 A6#16nmos@165_poly-right net@2726#17nmos@165_diff-top gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@166 XOR1_to_NAND7#1contact@1092_metal-1-metal-2 net@3038#4nmos@166_poly-right net@2726#17nmos@165_diff-top gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@167 net@2941#2contact@1078_metal-1-polysilicon-1 XOR1_to_NAND7#26nmos@167_poly-right net@2932 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@168 net@2998 net@2931#11nmos@168_poly-right net@2941#2contact@1078_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@169 net@2726#17nmos@165_diff-top Cin_to_XOR2___NAND7#18nmos@169_poly-left net@2998 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@170 net@2932 net@2942#9nmos@170_poly-left net@2726#17nmos@165_diff-top gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@171 net@2942#2contact@1053_metal-1-metal-2 Cin_to_XOR2___NAND7#14nmos@171_poly-right net@2726#17nmos@165_diff-top gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@172 net@2931#2pin@936_metal-1 XOR1_to_NAND7#24nmos@172_poly-right net@2726#17nmos@165_diff-top gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@173 net@2962 net@2941#4nmos@173_poly-right net@2726#17nmos@165_diff-top gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@174 net@3036 XOR1_to_NAND7#27nmos@174_poly-right net@2726#17nmos@165_diff-top gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@175 NAND1_to_NAND9#4nmos@175_diff-bottom Cin_to_XOR2___NAND7#25nmos@175_poly-right net@3036 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@176 net@3066 A6#19nmos@176_poly-right net@2726#17nmos@165_diff-top gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@177 NAND2_to_Nand9#4nmos@177_diff-bottom B6#13nmos@177_poly-right net@3066 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@178 net@3093 NAND2_to_Nand9#11nmos@178_poly-right net@2726#17nmos@165_diff-top gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@179 Cin_to_XOR2___NAND8#1contact@1190_metal-1-metal-2 NAND1_to_NAND9#14nmos@179_poly-right net@3093 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@180 net@3343#2contact@1147_metal-1-polysilicon-1 A7#17nmos@180_poly-right net@3232 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@181 net@3469 net@3235#11nmos@181_poly-right net@3343#2contact@1147_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@182 net@2726#47nmos@185_diff-top B7#16nmos@182_poly-left net@3469 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@183 net@3232 net@3351#9nmos@183_poly-left net@2726#47nmos@185_diff-top gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@184 net@3351#2contact@1123_metal-1-metal-2 B7#11nmos@184_poly-right net@2726#47nmos@185_diff-top gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@185 net@3235#2pin@989_metal-1 A7#16nmos@185_poly-right net@2726#47nmos@185_diff-top gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@186 XOR1_to_NAND8#1contact@1200_metal-1-metal-2 net@3343#4nmos@186_poly-right net@2726#47nmos@185_diff-top gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@187 net@3247#2contact@1186_metal-1-polysilicon-1 XOR1_to_NAND8#26nmos@187_poly-right net@3238 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@188 net@3304 net@3237#11nmos@188_poly-right net@3247#2contact@1186_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@189 net@2726#47nmos@185_diff-top Cin_to_XOR2___NAND8#18nmos@189_poly-left net@3304 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@190 net@3238 net@3248#9nmos@190_poly-left net@2726#47nmos@185_diff-top gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@191 net@3248#2contact@1161_metal-1-metal-2 Cin_to_XOR2___NAND8#14nmos@191_poly-right net@2726#47nmos@185_diff-top gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@192 net@3237#2pin@1014_metal-1 XOR1_to_NAND8#24nmos@192_poly-right net@2726#47nmos@185_diff-top gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@193 Sum7 net@3247#4nmos@193_poly-right net@2726#47nmos@185_diff-top gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@194 net@3341 XOR1_to_NAND8#27nmos@194_poly-right net@2726#47nmos@185_diff-top gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@195 NAND1_to_NAND10#4nmos@195_diff-bottom Cin_to_XOR2___NAND8#25nmos@195_poly-right net@3341 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@196 net@3371 A7#19nmos@196_poly-right net@2726#47nmos@185_diff-top gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@197 NAND2_to_Nand10#4nmos@197_diff-bottom B7#13nmos@197_poly-right net@3371 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@198 net@3398 NAND2_to_Nand10#11nmos@198_poly-right net@2726#47nmos@185_diff-top gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@199 Cout#2nmos@199_diff-bottom NAND1_to_NAND10#14nmos@199_poly-right net@3398 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mpmos@40 vdd A0#10pmos@40_poly-left net@800 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@41 net@800 net@562#7pmos@41_poly-left net@676 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@42 net@676 B0#16pmos@42_poly-right net@800 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@43 net@800 net@684#14pmos@43_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@44 vdd B0#15pmos@44_poly-right net@684 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@45 vdd A0#3pmos@45_poly-right net@562#5pmos@45_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@46 vdd net@676#12pmos@46_poly-right XOR1_to_NAND1#22pmos@46_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@47 vdd XOR1_to_NAND1#9pmos@47_poly-left net@621 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@48 net@621 net@564#7pmos@48_poly-left net@576 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@49 net@576 Cin#18pmos@49_poly-right net@621 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@50 net@621 net@577#14pmos@50_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@51 vdd Cin#17pmos@51_poly-right net@577 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@52 vdd XOR1_to_NAND1#4pmos@52_poly-right net@564#5pmos@52_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@53 vdd net@576#12pmos@53_poly-right Sum0#4pmos@53_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@54 vdd XOR1_to_NAND1#16pmos@54_poly-right NAND1_to_NAND3 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@55 NAND1_to_NAND3 Cin#20pmos@55_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@56 vdd A0#9pmos@56_poly-right NAND2_to_Nand3 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@57 NAND2_to_Nand3 B0#18pmos@57_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@58 vdd NAND2_to_Nand3#10pmos@58_poly-right Cin_to_XOR2___NAND2#1contact@534_metal-1-metal-2 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@59 Cin_to_XOR2___NAND2#1contact@534_metal-1-metal-2 NAND1_to_NAND3#11pmos@59_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@60 vdd A1#13pmos@60_poly-left net@1404 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@61 net@1404 net@1209#7pmos@61_poly-left net@1307 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@62 net@1307 B1#19pmos@62_poly-right net@1404 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@63 net@1404 net@1314#14pmos@63_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@64 vdd B1#18pmos@64_poly-right net@1314 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@65 vdd A1#5pmos@65_poly-right net@1209#5pmos@65_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@66 vdd net@1307#12pmos@66_poly-right XOR1_to_NAND2#22pmos@66_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@67 vdd XOR1_to_NAND2#9pmos@67_poly-left net@1255 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@68 net@1255 net@1211#7pmos@68_poly-left net@1220 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@69 net@1220 Cin_to_XOR2___NAND2#27pmos@69_poly-right net@1255 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@70 net@1255 net@1221#14pmos@70_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@71 vdd Cin_to_XOR2___NAND2#26pmos@71_poly-right net@1221 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@72 vdd XOR1_to_NAND2#4pmos@72_poly-right net@1211#5pmos@72_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@73 vdd net@1220#12pmos@73_poly-right Sum1#4pmos@73_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@74 vdd XOR1_to_NAND2#16pmos@74_poly-right NAND1_to_NAND4 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@75 NAND1_to_NAND4 Cin_to_XOR2___NAND2#29pmos@75_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@76 vdd A1#12pmos@76_poly-right NAND2_to_Nand4 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@77 NAND2_to_Nand4 B1#21pmos@77_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@78 vdd NAND2_to_Nand4#10pmos@78_poly-right Cin_to_XOR2___NAND3#1contact@646_metal-1-metal-2 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@79 Cin_to_XOR2___NAND3#1contact@646_metal-1-metal-2 NAND1_to_NAND4#11pmos@79_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@80 vdd A2#12pmos@80_poly-left net@2004 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@81 net@2004 net@1809#7pmos@81_poly-left net@1907 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@82 net@1907 B2#18pmos@82_poly-right net@2004 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@83 net@2004 net@1914#14pmos@83_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@84 vdd B2#17pmos@84_poly-right net@1914 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@85 vdd A2#4pmos@85_poly-right net@1809#5pmos@85_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@86 vdd net@1907#12pmos@86_poly-right XOR1_to_NAND3#22pmos@86_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@87 vdd XOR1_to_NAND3#9pmos@87_poly-left net@1855 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@88 net@1855 net@1811#7pmos@88_poly-left net@1820 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@89 net@1820 Cin_to_XOR2___NAND3#27pmos@89_poly-right net@1855 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@90 net@1855 net@1821#14pmos@90_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@91 vdd Cin_to_XOR2___NAND3#26pmos@91_poly-right net@1821 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@92 vdd XOR1_to_NAND3#4pmos@92_poly-right net@1811#5pmos@92_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@93 vdd net@1820#12pmos@93_poly-right Sum2#4pmos@93_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@94 vdd XOR1_to_NAND3#16pmos@94_poly-right NAND1_to_NAND5 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@95 NAND1_to_NAND5 Cin_to_XOR2___NAND3#29pmos@95_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@96 vdd A2#11pmos@96_poly-right NAND2_to_Nand5 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@97 NAND2_to_Nand5 B2#20pmos@97_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@98 vdd NAND2_to_Nand5#10pmos@98_poly-right Cin_to_XOR2___NAND4#1contact@756_metal-1-metal-2 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@99 Cin_to_XOR2___NAND4#1contact@756_metal-1-metal-2 NAND1_to_NAND5#11pmos@99_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@100 vdd A3#12pmos@100_poly-left net@2301 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@101 net@2301 net@2106#7pmos@101_poly-left net@2204 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@102 net@2204 B3#18pmos@102_poly-right net@2301 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@103 net@2301 net@2211#14pmos@103_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@104 vdd B3#17pmos@104_poly-right net@2211 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@105 vdd A3#4pmos@105_poly-right net@2106#5pmos@105_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@106 vdd net@2204#12pmos@106_poly-right XOR1_to_NAND4#22pmos@106_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@107 vdd XOR1_to_NAND4#9pmos@107_poly-left net@2152 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@108 net@2152 net@2108#7pmos@108_poly-left net@2117 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@109 net@2117 Cin_to_XOR2___NAND4#27pmos@109_poly-right net@2152 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@110 net@2152 net@2118#14pmos@110_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@111 vdd Cin_to_XOR2___NAND4#26pmos@111_poly-right net@2118 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@112 vdd XOR1_to_NAND4#4pmos@112_poly-right net@2108#5pmos@112_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@113 vdd net@2117#12pmos@113_poly-right Sum3#4pmos@113_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@114 vdd XOR1_to_NAND4#16pmos@114_poly-right NAND1_to_NAND6 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@115 NAND1_to_NAND6 Cin_to_XOR2___NAND4#29pmos@115_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@116 vdd A3#11pmos@116_poly-right NAND2_to_Nand6 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@117 NAND2_to_Nand6 B3#20pmos@117_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@118 vdd NAND2_to_Nand6#10pmos@118_poly-right Cin_to_XOR2___NAND5#1contact@865_metal-1-metal-2 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@119 Cin_to_XOR2___NAND5#1contact@865_metal-1-metal-2 NAND1_to_NAND6#11pmos@119_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@120 vdd A4#12pmos@120_poly-left net@2587 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@121 net@2587 net@2392#7pmos@121_poly-left net@2490 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@122 net@2490 B4#18pmos@122_poly-right net@2587 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@123 net@2587 net@2497#14pmos@123_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@124 vdd B4#17pmos@124_poly-right net@2497 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@125 vdd A4#4pmos@125_poly-right net@2392#5pmos@125_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@126 vdd net@2490#12pmos@126_poly-right XOR1_to_NAND5#22pmos@126_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@127 vdd XOR1_to_NAND5#9pmos@127_poly-left net@2438 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@128 net@2438 net@2394#7pmos@128_poly-left net@2403 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@129 net@2403 Cin_to_XOR2___NAND5#27pmos@129_poly-right net@2438 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@130 net@2438 net@2404#14pmos@130_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@131 vdd Cin_to_XOR2___NAND5#26pmos@131_poly-right net@2404 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@132 vdd XOR1_to_NAND5#4pmos@132_poly-right net@2394#5pmos@132_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@133 vdd net@2403#12pmos@133_poly-right Sum4#4pmos@133_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@134 vdd XOR1_to_NAND5#16pmos@134_poly-right NAND1_to_NAND7 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@135 NAND1_to_NAND7 Cin_to_XOR2___NAND5#29pmos@135_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@136 vdd A4#11pmos@136_poly-right NAND2_to_Nand7 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@137 NAND2_to_Nand7 B4#20pmos@137_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@138 vdd NAND2_to_Nand7#10pmos@138_poly-right Cin_to_XOR2___NAND6#1contact@974_metal-1-metal-2 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@139 Cin_to_XOR2___NAND6#1contact@974_metal-1-metal-2 NAND1_to_NAND7#11pmos@139_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@140 vdd A5#8pmos@140_poly-left net@2831 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@141 net@2831 net@2742#5pmos@141_poly-left net@2725 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@142 net@2725 B5#17pmos@142_poly-right net@2831 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@143 net@2831 net@2732#14pmos@143_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@144 vdd B5#16pmos@144_poly-right net@2732 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@145 vdd A5#18pmos@145_poly-right net@2742#3pmos@145_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@146 vdd net@2725#12pmos@146_poly-right XOR1_to_NAND6#15pmos@146_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@147 vdd XOR1_to_NAND6#20pmos@147_poly-right net@3155 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@148 net@3155 net@2789#5pmos@148_poly-right net@2767 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@149 net@2767 Cin_to_XOR2___NAND6#23pmos@149_poly-right net@3155 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@150 net@3155 net@2778#5pmos@150_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@151 vdd Cin_to_XOR2___NAND6#22pmos@151_poly-right net@2778 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@152 vdd XOR1_to_NAND6#27pmos@152_poly-right net@2789#3contact@960_metal-1-p-act vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@153 vdd net@2767#5pmos@153_poly-right net@2795#3contact@969_metal-1-p-act vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@154 vdd XOR1_to_NAND6#7pmos@154_poly-right NAND1_to_NAND8 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@155 NAND1_to_NAND8 Cin_to_XOR2___NAND6#25pmos@155_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@156 vdd A5#5pmos@156_poly-right NAND2_to_Nand8 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@157 NAND2_to_Nand8 B5#19pmos@157_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@158 vdd NAND2_to_Nand8#10pmos@158_poly-right Cin_to_XOR2___NAND7#1contact@1082_metal-1-metal-2 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@159 Cin_to_XOR2___NAND7#1contact@1082_metal-1-metal-2 NAND1_to_NAND8#8pmos@159_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@160 vdd A6#12pmos@160_poly-left net@3146 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@161 net@3146 net@2929#7pmos@161_poly-left net@3038 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@162 net@3038 B6#18pmos@162_poly-right net@3146 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@163 net@3146 net@3046#14pmos@163_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@164 vdd B6#17pmos@164_poly-right net@3046 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@165 vdd A6#4pmos@165_poly-right net@2929#5pmos@165_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@166 vdd net@3038#12pmos@166_poly-right XOR1_to_NAND7#22pmos@166_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@167 vdd XOR1_to_NAND7#9pmos@167_poly-left net@2981 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@168 net@2981 net@2931#7pmos@168_poly-left net@2941 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@169 net@2941 Cin_to_XOR2___NAND7#27pmos@169_poly-right net@2981 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@170 net@2981 net@2942#14pmos@170_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@171 vdd Cin_to_XOR2___NAND7#26pmos@171_poly-right net@2942 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@172 vdd XOR1_to_NAND7#4pmos@172_poly-right net@2931#5pmos@172_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@173 vdd net@2941#12pmos@173_poly-right net@2962#4pmos@173_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@174 vdd XOR1_to_NAND7#16pmos@174_poly-right NAND1_to_NAND9 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@175 NAND1_to_NAND9 Cin_to_XOR2___NAND7#29pmos@175_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@176 vdd A6#11pmos@176_poly-right NAND2_to_Nand9 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@177 NAND2_to_Nand9 B6#20pmos@177_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@178 vdd NAND2_to_Nand9#10pmos@178_poly-right Cin_to_XOR2___NAND8#1contact@1190_metal-1-metal-2 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@179 Cin_to_XOR2___NAND8#1contact@1190_metal-1-metal-2 NAND1_to_NAND9#11pmos@179_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@180 vdd A7#12pmos@180_poly-left net@3451 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@181 net@3451 net@3235#7pmos@181_poly-left net@3343 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@182 net@3343 B7#18pmos@182_poly-right net@3451 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@183 net@3451 net@3351#14pmos@183_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@184 vdd B7#17pmos@184_poly-right net@3351 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@185 vdd A7#4pmos@185_poly-right net@3235#5pmos@185_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@186 vdd net@3343#12pmos@186_poly-right XOR1_to_NAND8#22pmos@186_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@187 vdd XOR1_to_NAND8#9pmos@187_poly-left net@3286 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@188 net@3286 net@3237#7pmos@188_poly-left net@3247 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@189 net@3247 Cin_to_XOR2___NAND8#27pmos@189_poly-right net@3286 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@190 net@3286 net@3248#14pmos@190_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@191 vdd Cin_to_XOR2___NAND8#26pmos@191_poly-right net@3248 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@192 vdd XOR1_to_NAND8#4pmos@192_poly-right net@3237#5pmos@192_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@193 vdd net@3247#12pmos@193_poly-right Sum7#4pmos@193_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@194 vdd XOR1_to_NAND8#16pmos@194_poly-right NAND1_to_NAND10 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@195 NAND1_to_NAND10 Cin_to_XOR2___NAND8#29pmos@195_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@196 vdd A7#11pmos@196_poly-right NAND2_to_Nand10 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@197 NAND2_to_Nand10 B7#20pmos@197_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@198 vdd NAND2_to_Nand10#10pmos@198_poly-right Cout vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@199 Cout NAND1_to_NAND10#11pmos@199_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
** Extracted Parasitic Capacitors ***
C0 net@560 0 3.833fF
C1 net@676 0 4.502fF
C2 net@800 0 1.741fF
C3 net@676#2contact@256_metal-1-polysilicon-1 0 7.287fF
C4 net@684#2contact@231_metal-1-metal-2 0 8.905fF
C5 net@684 0 4.589fF
C6 B0 0 10.065fF
C7 A0 0 11.542fF
C8 net@562#2pin@166_metal-1 0 5.84fF
C9 net@562#5pmos@45_diff-top 0 4.602fF
C10 XOR1_to_NAND1#1contact@309_metal-1-metal-2 0 22.356fF
C11 XOR1_to_NAND1#22pmos@46_diff-top 0 4.651fF
C12 net@566 0 3.833fF
C13 net@576 0 4.452fF
C14 net@621 0 1.741fF
C15 net@576#2contact@295_metal-1-polysilicon-1 0 7.187fF
C16 net@577#2contact@270_metal-1-metal-2 0 8.905fF
C17 net@577 0 4.589fF
C18 Cin#0pin@206_metal-2 0 11.38fF
C19 net@564#2pin@192_metal-1 0 5.84fF
C20 net@564#5pmos@52_diff-top 0 4.602fF
C21 Sum0 0 12.444fF
C22 Sum0#4pmos@53_diff-top 0 4.614fF
C23 Cin 0 3.389fF
C24 NAND1_to_NAND3 0 9.146fF
C25 NAND1_to_NAND3#4nmos@55_diff-bottom 0 4.614fF
C26 XOR1_to_NAND1 0 3.919fF
C27 Cin#11contact@308_metal-1-metal-2 0 4.06fF
C28 NAND2_to_Nand3 0 6.989fF
C29 NAND2_to_Nand3#4nmos@57_diff-bottom 0 4.229fF
C30 A0#0contact@317_metal-1-metal-2 0 7.684fF
C31 B0#0contact@318_metal-1-metal-2 0 5.6fF
C32 Cin_to_XOR2___NAND2#1contact@534_metal-1-metal-2 0 14.582fF
C33 B1 0 5.383fF
C34 B2 0 16.009fF
C35 B3 0 15.542fF
C36 B4 0 16.971fF
C37 B5 0 18.022fF
C38 B6 0 18.763fF
C39 B7 0 19.351fF
C40 A6 0 18.802fF
C41 A5 0 18.061fF
C42 A4 0 16.995fF
C43 A3 0 15.571fF
C44 A2 0 16.113fF
C45 A1 0 12.184fF
C46 net@1207 0 3.833fF
C47 net@1307 0 4.502fF
C48 net@1404 0 1.741fF
C49 net@1307#2contact@491_metal-1-polysilicon-1 0 7.287fF
C50 net@1314#2contact@466_metal-1-metal-2 0 8.905fF
C51 net@1314 0 4.589fF
C52 B1#0pin@508_metal-2 0 18.272fF
C53 A1#1pin@517_metal-2 0 18.539fF
C54 net@1209#2pin@342_metal-1 0 5.84fF
C55 net@1209#5pmos@65_diff-top 0 4.602fF
C56 XOR1_to_NAND2#1contact@544_metal-1-metal-2 0 22.356fF
C57 XOR1_to_NAND2#22pmos@66_diff-top 0 4.651fF
C58 net@1212 0 3.833fF
C59 net@1220 0 4.452fF
C60 net@1255 0 1.741fF
C61 net@1220#2contact@530_metal-1-polysilicon-1 0 7.187fF
C62 net@1221#2contact@505_metal-1-metal-2 0 8.905fF
C63 net@1221 0 4.589fF
C64 Cin_to_XOR2___NAND2 0 11.38fF
C65 net@1211#2pin@367_metal-1 0 5.84fF
C66 net@1211#5pmos@72_diff-top 0 4.602fF
C67 Sum1 0 12.047fF
C68 Sum1#4pmos@73_diff-top 0 4.614fF
C69 NAND1_to_NAND4 0 9.146fF
C70 NAND1_to_NAND4#4nmos@75_diff-bottom 0 4.614fF
C71 XOR1_to_NAND2 0 3.919fF
C72 Cin_to_XOR2___NAND2#20contact@543_metal-1-metal-2 0 4.06fF
C73 NAND2_to_Nand4 0 6.989fF
C74 NAND2_to_Nand4#4nmos@77_diff-bottom 0 4.229fF
C75 A1#2contact@552_metal-1-metal-2 0 7.684fF
C76 B1#2contact@553_metal-1-metal-2 0 5.6fF
C77 Cin_to_XOR2___NAND3#1contact@646_metal-1-metal-2 0 14.582fF
C78 A7 0 19.391fF
C79 net@1807 0 3.833fF
C80 net@1907 0 4.502fF
C81 net@2004 0 1.741fF
C82 net@1907#2contact@603_metal-1-polysilicon-1 0 7.287fF
C83 net@1914#2contact@579_metal-1-metal-2 0 8.905fF
C84 net@1914 0 4.589fF
C85 B2#1pin@588_metal-2 0 21.389fF
C86 A2#1pin@586_metal-2 0 22.844fF
C87 net@1809#2pin@536_metal-1 0 5.84fF
C88 net@1809#5pmos@85_diff-top 0 4.602fF
C89 XOR1_to_NAND3#1contact@656_metal-1-metal-2 0 22.356fF
C90 XOR1_to_NAND3#22pmos@86_diff-top 0 4.651fF
C91 net@1812 0 3.833fF
C92 net@1820 0 4.452fF
C93 net@1855 0 1.741fF
C94 net@1820#2contact@642_metal-1-polysilicon-1 0 7.187fF
C95 net@1821#2contact@617_metal-1-metal-2 0 8.905fF
C96 net@1821 0 4.589fF
C97 Cin_to_XOR2___NAND3 0 11.38fF
C98 net@1811#2pin@561_metal-1 0 5.84fF
C99 net@1811#5pmos@92_diff-top 0 4.602fF
C100 Sum2 0 12.083fF
C101 Sum2#4pmos@93_diff-top 0 4.614fF
C102 NAND1_to_NAND5 0 9.146fF
C103 NAND1_to_NAND5#4nmos@95_diff-bottom 0 4.614fF
C104 XOR1_to_NAND3 0 3.919fF
C105 Cin_to_XOR2___NAND3#20contact@655_metal-1-metal-2 0 4.06fF
C106 NAND2_to_Nand5 0 6.989fF
C107 NAND2_to_Nand5#4nmos@97_diff-bottom 0 4.229fF
C108 A2#0contact@664_metal-1-metal-2 0 7.684fF
C109 B2#0contact@665_metal-1-metal-2 0 5.6fF
C110 Cin_to_XOR2___NAND4#1contact@756_metal-1-metal-2 0 14.582fF
C111 net@2104 0 3.833fF
C112 net@2204 0 4.502fF
C113 net@2301 0 1.741fF
C114 net@2204#2contact@713_metal-1-polysilicon-1 0 7.287fF
C115 net@2211#2contact@689_metal-1-metal-2 0 8.905fF
C116 net@2211 0 4.589fF
C117 B3#1pin@683_metal-2 0 21.131fF
C118 A3#1pin@681_metal-2 0 22.678fF
C119 net@2106#2pin@631_metal-1 0 5.84fF
C120 net@2106#5pmos@105_diff-top 0 4.602fF
C121 XOR1_to_NAND4#1contact@766_metal-1-metal-2 0 22.356fF
C122 XOR1_to_NAND4#22pmos@106_diff-top 0 4.651fF
C123 net@2109 0 3.833fF
C124 net@2117 0 4.452fF
C125 net@2152 0 1.741fF
C126 net@2117#2contact@752_metal-1-polysilicon-1 0 7.187fF
C127 net@2118#2contact@727_metal-1-metal-2 0 8.905fF
C128 net@2118 0 4.589fF
C129 Cin_to_XOR2___NAND4 0 11.38fF
C130 net@2108#2pin@656_metal-1 0 5.84fF
C131 net@2108#5pmos@112_diff-top 0 4.602fF
C132 Sum3 0 12.047fF
C133 Sum3#4pmos@113_diff-top 0 4.614fF
C134 NAND1_to_NAND6 0 9.146fF
C135 NAND1_to_NAND6#4nmos@115_diff-bottom 0 4.614fF
C136 XOR1_to_NAND4 0 3.919fF
C137 Cin_to_XOR2___NAND4#20contact@765_metal-1-metal-2 0 4.06fF
C138 NAND2_to_Nand6 0 6.989fF
C139 NAND2_to_Nand6#4nmos@117_diff-bottom 0 4.229fF
C140 A3#0contact@774_metal-1-metal-2 0 7.684fF
C141 B3#0contact@775_metal-1-metal-2 0 5.6fF
C142 Cin_to_XOR2___NAND5#1contact@865_metal-1-metal-2 0 14.582fF
C143 net@2390 0 3.833fF
C144 net@2490 0 4.502fF
C145 net@2587 0 1.741fF
C146 net@2490#2contact@822_metal-1-polysilicon-1 0 7.287fF
C147 net@2497#2contact@798_metal-1-metal-2 0 8.905fF
C148 net@2497 0 4.589fF
C149 B4#1pin@769_metal-2 0 22.79fF
C150 A4#1pin@767_metal-2 0 24.333fF
C151 net@2392#2pin@717_metal-1 0 5.84fF
C152 net@2392#5pmos@125_diff-top 0 4.602fF
C153 XOR1_to_NAND5#1contact@875_metal-1-metal-2 0 22.356fF
C154 XOR1_to_NAND5#22pmos@126_diff-top 0 4.651fF
C155 net@2395 0 3.833fF
C156 net@2403 0 4.452fF
C157 net@2438 0 1.741fF
C158 net@2403#2contact@861_metal-1-polysilicon-1 0 7.187fF
C159 net@2404#2contact@836_metal-1-metal-2 0 8.905fF
C160 net@2404 0 4.589fF
C161 Cin_to_XOR2___NAND5 0 11.38fF
C162 net@2394#2pin@742_metal-1 0 5.84fF
C163 net@2394#5pmos@132_diff-top 0 4.602fF
C164 Sum4 0 12.083fF
C165 Sum4#4pmos@133_diff-top 0 4.614fF
C166 NAND1_to_NAND7 0 9.146fF
C167 NAND1_to_NAND7#4nmos@135_diff-bottom 0 4.614fF
C168 XOR1_to_NAND5 0 3.919fF
C169 Cin_to_XOR2___NAND5#20contact@874_metal-1-metal-2 0 4.06fF
C170 NAND2_to_Nand7 0 6.989fF
C171 NAND2_to_Nand7#4nmos@137_diff-bottom 0 4.229fF
C172 A4#0contact@883_metal-1-metal-2 0 7.684fF
C173 B4#0contact@884_metal-1-metal-2 0 5.6fF
C174 Cin_to_XOR2___NAND6#1contact@974_metal-1-metal-2 0 14.88fF
C175 net@2722 0 3.833fF
C176 net@2725 0 4.502fF
C177 net@2831 0 1.741fF
C178 net@2725#2contact@931_metal-1-polysilicon-1 0 7.287fF
C179 net@2726 0 21.474fF
C180 net@2732#2contact@907_metal-1-metal-2 0 8.905fF
C181 net@2732 0 4.589fF
C182 B5#1pin@880_metal-2 0 24.155fF
C183 A5#1pin@878_metal-2 0 25.544fF
C184 net@2742 0 5.84fF
C185 net@2742#3pmos@145_diff-top 0 4.602fF
C186 XOR1_to_NAND6#1contact@984_metal-1-metal-2 0 22.356fF
C187 XOR1_to_NAND6#15pmos@146_diff-top 0 4.651fF
C188 net@2811 0 3.833fF
C189 net@2767 0 4.452fF
C190 net@3155 0 1.741fF
C191 net@2767#2contact@970_metal-1-polysilicon-1 0 7.187fF
C192 net@2778#2contact@945_metal-1-metal-2 0 8.905fF
C193 net@2778 0 4.589fF
C194 Cin_to_XOR2___NAND6 0 11.38fF
C195 net@2789 0 5.84fF
C196 net@2789#3contact@960_metal-1-p-act 0 4.602fF
C197 net@2795 0 12.083fF
C198 net@2795#3contact@969_metal-1-p-act 0 4.614fF
C199 NAND1_to_NAND8 0 9.146fF
C200 NAND1_to_NAND8#12contact@979_metal-1-n-act 0 4.614fF
C201 XOR1_to_NAND6 0 3.919fF
C202 Cin_to_XOR2___NAND6#9contact@983_metal-1-metal-2 0 4.06fF
C203 NAND2_to_Nand8 0 6.989fF
C204 NAND2_to_Nand8#4nmos@157_diff-bottom 0 4.229fF
C205 A5#0contact@992_metal-1-metal-2 0 7.684fF
C206 B5#0contact@993_metal-1-metal-2 0 5.6fF
C207 Cin_to_XOR2___NAND7#1contact@1082_metal-1-metal-2 0 14.582fF
C208 net@2927 0 3.833fF
C209 net@3038 0 4.502fF
C210 net@3146 0 1.741fF
C211 net@3038#2contact@1039_metal-1-polysilicon-1 0 7.287fF
C212 net@2726#17nmos@165_diff-top 0 33.3fF
C213 net@3046#2contact@1015_metal-1-metal-2 0 8.905fF
C214 net@3046 0 4.589fF
C215 B6#1pin@963_metal-2 0 25.251fF
C216 A6#1pin@961_metal-2 0 26.641fF
C217 net@2929#2pin@911_metal-1 0 5.84fF
C218 net@2929#5pmos@165_diff-top 0 4.602fF
C219 XOR1_to_NAND7#1contact@1092_metal-1-metal-2 0 22.356fF
C220 XOR1_to_NAND7#22pmos@166_diff-top 0 4.651fF
C221 net@2932 0 3.833fF
C222 net@2941 0 4.452fF
C223 net@2981 0 1.741fF
C224 net@2941#2contact@1078_metal-1-polysilicon-1 0 7.187fF
C225 net@2942#2contact@1053_metal-1-metal-2 0 8.905fF
C226 net@2942 0 4.589fF
C227 Cin_to_XOR2___NAND7 0 11.38fF
C228 net@2931#2pin@936_metal-1 0 5.84fF
C229 net@2931#5pmos@172_diff-top 0 4.602fF
C230 net@2962 0 12.047fF
C231 net@2962#4pmos@173_diff-top 0 4.614fF
C232 NAND1_to_NAND9 0 9.146fF
C233 NAND1_to_NAND9#4nmos@175_diff-bottom 0 4.614fF
C234 XOR1_to_NAND7 0 3.919fF
C235 Cin_to_XOR2___NAND7#20contact@1091_metal-1-metal-2 0 4.06fF
C236 NAND2_to_Nand9 0 6.989fF
C237 NAND2_to_Nand9#4nmos@177_diff-bottom 0 4.229fF
C238 A6#0contact@1100_metal-1-metal-2 0 7.684fF
C239 B6#0contact@1101_metal-1-metal-2 0 5.6fF
C240 Cin_to_XOR2___NAND8#1contact@1190_metal-1-metal-2 0 14.582fF
C241 net@3232 0 3.833fF
C242 net@3343 0 4.502fF
C243 net@3451 0 1.741fF
C244 net@3343#2contact@1147_metal-1-polysilicon-1 0 7.287fF
C245 net@2726#47nmos@185_diff-top 0 21.474fF
C246 net@3351#2contact@1123_metal-1-metal-2 0 8.905fF
C247 net@3351 0 4.589fF
C248 B7#1pin@1041_metal-2 0 26.132fF
C249 A7#1pin@1039_metal-2 0 27.481fF
C250 net@3235#2pin@989_metal-1 0 5.84fF
C251 net@3235#5pmos@185_diff-top 0 4.602fF
C252 XOR1_to_NAND8#1contact@1200_metal-1-metal-2 0 22.356fF
C253 XOR1_to_NAND8#22pmos@186_diff-top 0 4.651fF
C254 net@3238 0 3.833fF
C255 net@3247 0 4.452fF
C256 net@3286 0 1.741fF
C257 net@3247#2contact@1186_metal-1-polysilicon-1 0 7.187fF
C258 net@3248#2contact@1161_metal-1-metal-2 0 8.905fF
C259 net@3248 0 4.589fF
C260 Cin_to_XOR2___NAND8 0 11.38fF
C261 net@3237#2pin@1014_metal-1 0 5.84fF
C262 net@3237#5pmos@192_diff-top 0 4.602fF
C263 Sum7 0 10.373fF
C264 Sum7#4pmos@193_diff-top 0 4.614fF
C265 NAND1_to_NAND10 0 9.146fF
C266 NAND1_to_NAND10#4nmos@195_diff-bottom 0 4.614fF
C267 XOR1_to_NAND8 0 3.919fF
C268 Cin_to_XOR2___NAND8#20contact@1199_metal-1-metal-2 0 4.06fF
C269 NAND2_to_Nand10 0 6.989fF
C270 NAND2_to_Nand10#4nmos@197_diff-bottom 0 4.229fF
C271 A7#0contact@1208_metal-1-metal-2 0 7.684fF
C272 B7#0contact@1209_metal-1-metal-2 0 5.6fF
C273 Cout 0 6.218fF
C274 Cout#2nmos@199_diff-bottom 0 4.229fF
C275 B0#14nmos@42_poly-left 0 0.135fF
C276 net@684#9nmos@43_poly-left 0 0.178fF
C277 Cin#9nmos@49_poly-left 0 0.135fF
C278 net@577#9nmos@50_poly-left 0 0.178fF
C279 B1#17nmos@62_poly-left 0 0.135fF
C280 net@1314#9nmos@63_poly-left 0 0.178fF
C281 Cin_to_XOR2___NAND2#18nmos@69_poly-left 0 0.135fF
C282 net@1221#9nmos@70_poly-left 0 0.178fF
C283 B2#16nmos@82_poly-left 0 0.135fF
C284 net@1914#9nmos@83_poly-left 0 0.178fF
C285 Cin_to_XOR2___NAND3#18nmos@89_poly-left 0 0.135fF
C286 net@1821#9nmos@90_poly-left 0 0.178fF
C287 B3#16nmos@102_poly-left 0 0.135fF
C288 net@2211#9nmos@103_poly-left 0 0.178fF
C289 Cin_to_XOR2___NAND4#18nmos@109_poly-left 0 0.135fF
C290 net@2118#9nmos@110_poly-left 0 0.178fF
C291 B4#16nmos@122_poly-left 0 0.135fF
C292 net@2497#9nmos@123_poly-left 0 0.178fF
C293 Cin_to_XOR2___NAND5#18nmos@129_poly-left 0 0.135fF
C294 net@2404#9nmos@130_poly-left 0 0.178fF
C295 B5#15nmos@142_poly-left 0 0.135fF
C296 net@2732#9nmos@143_poly-left 0 0.178fF
C297 Cin_to_XOR2___NAND6#24nmos@149_poly-right 0 0.135fF
C298 net@2778#6nmos@150_poly-right 0 0.178fF
C299 B6#16nmos@162_poly-left 0 0.135fF
C300 net@3046#9nmos@163_poly-left 0 0.178fF
C301 Cin_to_XOR2___NAND7#18nmos@169_poly-left 0 0.135fF
C302 net@2942#9nmos@170_poly-left 0 0.178fF
C303 B7#16nmos@182_poly-left 0 0.135fF
C304 net@3351#9nmos@183_poly-left 0 0.178fF
C305 Cin_to_XOR2___NAND8#18nmos@189_poly-left 0 0.135fF
C306 net@3248#9nmos@190_poly-left 0 0.178fF
C307 net@562 0 0.143fF
C308 B0#12pin@157_polysilicon-1 0 0.132fF
C309 A0#11pin@164_polysilicon-1 0 0.12fF
C310 A0#13pin@165_polysilicon-1 0 0.106fF
C311 B0#10pin@167_polysilicon-1 0 0.203fF
C312 net@676#5pin@169_polysilicon-1 0 0.221fF
C313 B0#13pin@174_polysilicon-1 0 0.175fF
C314 net@562#1pin@176_polysilicon-1 0 0.187fF
C315 A0#2pin@177_polysilicon-1 0 0.199fF
C316 net@564 0 0.143fF
C317 Cin#7pin@183_polysilicon-1 0 0.132fF
C318 XOR1_to_NAND1#10pin@190_polysilicon-1 0 0.12fF
C319 XOR1_to_NAND1#12pin@191_polysilicon-1 0 0.106fF
C320 Cin#6pin@193_polysilicon-1 0 0.203fF
C321 net@576#5pin@195_polysilicon-1 0 0.236fF
C322 Cin#8pin@200_polysilicon-1 0 0.175fF
C323 net@564#1pin@202_polysilicon-1 0 0.187fF
C324 XOR1_to_NAND1#3pin@203_polysilicon-1 0 0.199fF
C325 XOR1_to_NAND1#14pin@207_polysilicon-1 0 0.184fF
C326 Cin#14pin@212_polysilicon-1 0 0.244fF
C327 A0#8pin@215_polysilicon-1 0 0.224fF
C328 B0#8pin@220_polysilicon-1 0 0.237fF
C329 NAND2_to_Nand3#9pin@224_polysilicon-1 0 0.224fF
C330 NAND1_to_NAND3#12pin@229_polysilicon-1 0 0.103fF
C331 net@1209 0 0.143fF
C332 B1#15pin@333_polysilicon-1 0 0.132fF
C333 A1#14pin@340_polysilicon-1 0 0.12fF
C334 A1#16pin@341_polysilicon-1 0 0.106fF
C335 B1#13pin@343_polysilicon-1 0 0.203fF
C336 net@1307#5pin@345_polysilicon-1 0 0.221fF
C337 B1#16pin@350_polysilicon-1 0 0.175fF
C338 net@1209#1pin@352_polysilicon-1 0 0.187fF
C339 A1#4pin@353_polysilicon-1 0 0.199fF
C340 net@1211 0 0.143fF
C341 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1 0 0.132fF
C342 XOR1_to_NAND2#10pin@365_polysilicon-1 0 0.12fF
C343 XOR1_to_NAND2#12pin@366_polysilicon-1 0 0.106fF
C344 Cin_to_XOR2___NAND2#15pin@368_polysilicon-1 0 0.203fF
C345 net@1220#5pin@370_polysilicon-1 0 0.236fF
C346 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1 0 0.175fF
C347 net@1211#1pin@377_polysilicon-1 0 0.187fF
C348 XOR1_to_NAND2#3pin@378_polysilicon-1 0 0.199fF
C349 XOR1_to_NAND2#14pin@382_polysilicon-1 0 0.184fF
C350 Cin_to_XOR2___NAND2#23pin@386_polysilicon-1 0 0.244fF
C351 A1#11pin@389_polysilicon-1 0 0.224fF
C352 B1#11pin@393_polysilicon-1 0 0.237fF
C353 NAND2_to_Nand4#9pin@395_polysilicon-1 0 0.224fF
C354 NAND1_to_NAND4#12pin@399_polysilicon-1 0 0.103fF
C355 net@1809 0 0.143fF
C356 B2#14pin@527_polysilicon-1 0 0.132fF
C357 A2#13pin@534_polysilicon-1 0 0.12fF
C358 A2#15pin@535_polysilicon-1 0 0.106fF
C359 B2#12pin@537_polysilicon-1 0 0.203fF
C360 net@1907#5pin@539_polysilicon-1 0 0.221fF
C361 B2#15pin@544_polysilicon-1 0 0.175fF
C362 net@1809#1pin@546_polysilicon-1 0 0.187fF
C363 A2#3pin@547_polysilicon-1 0 0.199fF
C364 net@1811 0 0.143fF
C365 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1 0 0.132fF
C366 XOR1_to_NAND3#10pin@559_polysilicon-1 0 0.12fF
C367 XOR1_to_NAND3#12pin@560_polysilicon-1 0 0.106fF
C368 Cin_to_XOR2___NAND3#15pin@562_polysilicon-1 0 0.203fF
C369 net@1820#5pin@564_polysilicon-1 0 0.236fF
C370 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1 0 0.175fF
C371 net@1811#1pin@571_polysilicon-1 0 0.187fF
C372 XOR1_to_NAND3#3pin@572_polysilicon-1 0 0.199fF
C373 XOR1_to_NAND3#14pin@576_polysilicon-1 0 0.184fF
C374 Cin_to_XOR2___NAND3#23pin@580_polysilicon-1 0 0.244fF
C375 A2#10pin@583_polysilicon-1 0 0.224fF
C376 B2#10pin@587_polysilicon-1 0 0.237fF
C377 NAND2_to_Nand5#9pin@589_polysilicon-1 0 0.224fF
C378 NAND1_to_NAND5#12pin@593_polysilicon-1 0 0.103fF
C379 net@2106 0 0.143fF
C380 B3#14pin@622_polysilicon-1 0 0.132fF
C381 A3#13pin@629_polysilicon-1 0 0.12fF
C382 A3#15pin@630_polysilicon-1 0 0.106fF
C383 B3#12pin@632_polysilicon-1 0 0.203fF
C384 net@2204#5pin@634_polysilicon-1 0 0.221fF
C385 B3#15pin@639_polysilicon-1 0 0.175fF
C386 net@2106#1pin@641_polysilicon-1 0 0.187fF
C387 A3#3pin@642_polysilicon-1 0 0.199fF
C388 net@2108 0 0.143fF
C389 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1 0 0.132fF
C390 XOR1_to_NAND4#10pin@654_polysilicon-1 0 0.12fF
C391 XOR1_to_NAND4#12pin@655_polysilicon-1 0 0.106fF
C392 Cin_to_XOR2___NAND4#15pin@657_polysilicon-1 0 0.203fF
C393 net@2117#5pin@659_polysilicon-1 0 0.236fF
C394 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1 0 0.175fF
C395 net@2108#1pin@666_polysilicon-1 0 0.187fF
C396 XOR1_to_NAND4#3pin@667_polysilicon-1 0 0.199fF
C397 XOR1_to_NAND4#14pin@671_polysilicon-1 0 0.184fF
C398 Cin_to_XOR2___NAND4#23pin@675_polysilicon-1 0 0.244fF
C399 A3#10pin@678_polysilicon-1 0 0.224fF
C400 B3#10pin@682_polysilicon-1 0 0.237fF
C401 NAND2_to_Nand6#9pin@684_polysilicon-1 0 0.224fF
C402 NAND1_to_NAND6#12pin@688_polysilicon-1 0 0.103fF
C403 net@2392 0 0.143fF
C404 B4#14pin@708_polysilicon-1 0 0.132fF
C405 A4#13pin@715_polysilicon-1 0 0.12fF
C406 A4#15pin@716_polysilicon-1 0 0.106fF
C407 B4#12pin@718_polysilicon-1 0 0.203fF
C408 net@2490#5pin@720_polysilicon-1 0 0.221fF
C409 B4#15pin@725_polysilicon-1 0 0.175fF
C410 net@2392#1pin@727_polysilicon-1 0 0.187fF
C411 A4#3pin@728_polysilicon-1 0 0.199fF
C412 net@2394 0 0.143fF
C413 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1 0 0.132fF
C414 XOR1_to_NAND5#10pin@740_polysilicon-1 0 0.12fF
C415 XOR1_to_NAND5#12pin@741_polysilicon-1 0 0.106fF
C416 Cin_to_XOR2___NAND5#15pin@743_polysilicon-1 0 0.203fF
C417 net@2403#5pin@745_polysilicon-1 0 0.236fF
C418 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1 0 0.175fF
C419 net@2394#1pin@752_polysilicon-1 0 0.187fF
C420 XOR1_to_NAND5#3pin@753_polysilicon-1 0 0.199fF
C421 XOR1_to_NAND5#14pin@757_polysilicon-1 0 0.184fF
C422 Cin_to_XOR2___NAND5#23pin@761_polysilicon-1 0 0.244fF
C423 A4#10pin@764_polysilicon-1 0 0.224fF
C424 B4#10pin@768_polysilicon-1 0 0.237fF
C425 NAND2_to_Nand7#9pin@770_polysilicon-1 0 0.224fF
C426 NAND1_to_NAND7#12pin@774_polysilicon-1 0 0.103fF
C427 net@2742#6pin@837_polysilicon-1 0 0.143fF
C428 B5#13pin@819_polysilicon-1 0 0.132fF
C429 A5#9pin@826_polysilicon-1 0 0.12fF
C430 A5#11pin@827_polysilicon-1 0 0.106fF
C431 B5#11pin@829_polysilicon-1 0 0.203fF
C432 net@2725#5pin@831_polysilicon-1 0 0.221fF
C433 B5#14pin@836_polysilicon-1 0 0.175fF
C434 net@2742#9pin@838_polysilicon-1 0 0.187fF
C435 A5#13pin@839_polysilicon-1 0 0.199fF
C436 net@2789#8pin@862_polysilicon-1 0 0.143fF
C437 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1 0 0.132fF
C438 XOR1_to_NAND6#24pin@851_polysilicon-1 0 0.12fF
C439 XOR1_to_NAND6#26pin@852_polysilicon-1 0 0.106fF
C440 Cin_to_XOR2___NAND6#21pin@854_polysilicon-1 0 0.203fF
C441 net@2767#6pin@856_polysilicon-1 0 0.236fF
C442 Cin_to_XOR2___NAND6#27pin@861_polysilicon-1 0 0.175fF
C443 net@2789#4pin@863_polysilicon-1 0 0.187fF
C444 XOR1_to_NAND6#18pin@864_polysilicon-1 0 0.199fF
C445 XOR1_to_NAND6#8pin@868_polysilicon-1 0 0.184fF
C446 Cin_to_XOR2___NAND6#12pin@872_polysilicon-1 0 0.244fF
C447 A5#4pin@875_polysilicon-1 0 0.224fF
C448 B5#9pin@879_polysilicon-1 0 0.237fF
C449 NAND2_to_Nand8#9pin@881_polysilicon-1 0 0.224fF
C450 NAND1_to_NAND8#9pin@885_polysilicon-1 0 0.103fF
C451 net@2929 0 0.143fF
C452 B6#14pin@902_polysilicon-1 0 0.132fF
C453 A6#13pin@909_polysilicon-1 0 0.12fF
C454 A6#15pin@910_polysilicon-1 0 0.106fF
C455 B6#12pin@912_polysilicon-1 0 0.203fF
C456 net@3038#5pin@914_polysilicon-1 0 0.221fF
C457 B6#15pin@919_polysilicon-1 0 0.175fF
C458 net@2929#1pin@921_polysilicon-1 0 0.187fF
C459 A6#3pin@922_polysilicon-1 0 0.199fF
C460 net@2931 0 0.143fF
C461 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1 0 0.132fF
C462 XOR1_to_NAND7#10pin@934_polysilicon-1 0 0.12fF
C463 XOR1_to_NAND7#12pin@935_polysilicon-1 0 0.106fF
C464 Cin_to_XOR2___NAND7#15pin@937_polysilicon-1 0 0.203fF
C465 net@2941#5pin@939_polysilicon-1 0 0.236fF
C466 Cin_to_XOR2___NAND7#17pin@944_polysilicon-1 0 0.175fF
C467 net@2931#1pin@946_polysilicon-1 0 0.187fF
C468 XOR1_to_NAND7#3pin@947_polysilicon-1 0 0.199fF
C469 XOR1_to_NAND7#14pin@951_polysilicon-1 0 0.184fF
C470 Cin_to_XOR2___NAND7#23pin@955_polysilicon-1 0 0.244fF
C471 A6#10pin@958_polysilicon-1 0 0.224fF
C472 B6#10pin@962_polysilicon-1 0 0.237fF
C473 NAND2_to_Nand9#9pin@964_polysilicon-1 0 0.224fF
C474 NAND1_to_NAND9#12pin@968_polysilicon-1 0 0.103fF
C475 net@3235 0 0.143fF
C476 B7#14pin@980_polysilicon-1 0 0.132fF
C477 A7#13pin@987_polysilicon-1 0 0.12fF
C478 A7#15pin@988_polysilicon-1 0 0.106fF
C479 B7#12pin@990_polysilicon-1 0 0.203fF
C480 net@3343#5pin@992_polysilicon-1 0 0.221fF
C481 B7#15pin@997_polysilicon-1 0 0.175fF
C482 net@3235#1pin@999_polysilicon-1 0 0.187fF
C483 A7#3pin@1000_polysilicon-1 0 0.199fF
C484 net@3237 0 0.143fF
C485 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1 0 0.132fF
C486 XOR1_to_NAND8#10pin@1012_polysilicon-1 0 0.12fF
C487 XOR1_to_NAND8#12pin@1013_polysilicon-1 0 0.106fF
C488 Cin_to_XOR2___NAND8#15pin@1015_polysilicon-1 0 0.203fF
C489 net@3247#5pin@1017_polysilicon-1 0 0.236fF
C490 Cin_to_XOR2___NAND8#17pin@1022_polysilicon-1 0 0.175fF
C491 net@3237#1pin@1024_polysilicon-1 0 0.187fF
C492 XOR1_to_NAND8#3pin@1025_polysilicon-1 0 0.199fF
C493 XOR1_to_NAND8#14pin@1029_polysilicon-1 0 0.184fF
C494 Cin_to_XOR2___NAND8#23pin@1033_polysilicon-1 0 0.244fF
C495 A7#10pin@1036_polysilicon-1 0 0.224fF
C496 B7#10pin@1040_polysilicon-1 0 0.237fF
C497 NAND2_to_Nand10#9pin@1042_polysilicon-1 0 0.224fF
C498 NAND1_to_NAND10#12pin@1046_polysilicon-1 0 0.103fF
C499 A0#10pmos@40_poly-left 0 0.158fF
C500 net@562#7pmos@41_poly-left 0 0.145fF
C501 XOR1_to_NAND1#9pmos@47_poly-left 0 0.158fF
C502 net@564#7pmos@48_poly-left 0 0.145fF
C503 NAND1_to_NAND3#11pmos@59_poly-right 0 0.13fF
C504 A1#13pmos@60_poly-left 0 0.158fF
C505 net@1209#7pmos@61_poly-left 0 0.145fF
C506 XOR1_to_NAND2#9pmos@67_poly-left 0 0.158fF
C507 net@1211#7pmos@68_poly-left 0 0.145fF
C508 NAND1_to_NAND4#11pmos@79_poly-right 0 0.13fF
C509 A2#12pmos@80_poly-left 0 0.158fF
C510 net@1809#7pmos@81_poly-left 0 0.145fF
C511 XOR1_to_NAND3#9pmos@87_poly-left 0 0.158fF
C512 net@1811#7pmos@88_poly-left 0 0.145fF
C513 NAND1_to_NAND5#11pmos@99_poly-right 0 0.13fF
C514 A3#12pmos@100_poly-left 0 0.158fF
C515 net@2106#7pmos@101_poly-left 0 0.145fF
C516 XOR1_to_NAND4#9pmos@107_poly-left 0 0.158fF
C517 net@2108#7pmos@108_poly-left 0 0.145fF
C518 NAND1_to_NAND6#11pmos@119_poly-right 0 0.13fF
C519 A4#12pmos@120_poly-left 0 0.158fF
C520 net@2392#7pmos@121_poly-left 0 0.145fF
C521 XOR1_to_NAND5#9pmos@127_poly-left 0 0.158fF
C522 net@2394#7pmos@128_poly-left 0 0.145fF
C523 NAND1_to_NAND7#11pmos@139_poly-right 0 0.13fF
C524 A5#8pmos@140_poly-left 0 0.158fF
C525 net@2742#5pmos@141_poly-left 0 0.145fF
C526 XOR1_to_NAND6#20pmos@147_poly-right 0 0.158fF
C527 net@2789#5pmos@148_poly-right 0 0.145fF
C528 NAND1_to_NAND8#8pmos@159_poly-right 0 0.13fF
C529 A6#12pmos@160_poly-left 0 0.158fF
C530 net@2929#7pmos@161_poly-left 0 0.145fF
C531 XOR1_to_NAND7#9pmos@167_poly-left 0 0.158fF
C532 net@2931#7pmos@168_poly-left 0 0.145fF
C533 NAND1_to_NAND9#11pmos@179_poly-right 0 0.13fF
C534 A7#12pmos@180_poly-left 0 0.158fF
C535 net@3235#7pmos@181_poly-left 0 0.145fF
C536 XOR1_to_NAND8#9pmos@187_poly-left 0 0.158fF
C537 net@3237#7pmos@188_poly-left 0 0.145fF
C538 NAND1_to_NAND10#11pmos@199_poly-right 0 0.13fF
** Extracted Parasitic Resistors ***
R0 A1 A1#1pin@517_metal-2 8.255
R1 A0#0contact@317_metal-1-metal-2 A0 9.49
R2 A1#2contact@552_metal-1-metal-2 A1#1pin@517_metal-2 9.49
R3 A2#0contact@664_metal-1-metal-2 A2#1pin@586_metal-2 9.49
R4 A3#0contact@774_metal-1-metal-2 A3#1pin@681_metal-2 9.49
R5 A4#0contact@883_metal-1-metal-2 A4#1pin@767_metal-2 9.49
R6 A5#0contact@992_metal-1-metal-2 A5#1pin@878_metal-2 9.49
R7 A6#0contact@1100_metal-1-metal-2 A6#1pin@961_metal-2 9.49
R8 A7#0contact@1208_metal-1-metal-2 A7#1pin@1039_metal-2 9.49
R9 B0#0contact@318_metal-1-metal-2 B0#0contact@318_metal-1-metal-2##0 5.161
C539 B0#0contact@318_metal-1-metal-2##0 0 5.536fF
R10 B0#0contact@318_metal-1-metal-2##0 B0 5.161
R11 B1#2contact@553_metal-1-metal-2 B1#2contact@553_metal-1-metal-2##0 5.161
C540 B1#2contact@553_metal-1-metal-2##0 0 5.536fF
R12 B1#2contact@553_metal-1-metal-2##0 B1#0pin@508_metal-2 5.161
R13 B2#0contact@665_metal-1-metal-2 B2#0contact@665_metal-1-metal-2##0 5.161
C541 B2#0contact@665_metal-1-metal-2##0 0 5.536fF
R14 B2#0contact@665_metal-1-metal-2##0 B2#1pin@588_metal-2 5.161
R15 B3#0contact@775_metal-1-metal-2 B3#0contact@775_metal-1-metal-2##0 5.161
C542 B3#0contact@775_metal-1-metal-2##0 0 5.536fF
R16 B3#0contact@775_metal-1-metal-2##0 B3#1pin@683_metal-2 5.161
R17 B4#0contact@884_metal-1-metal-2 B4#0contact@884_metal-1-metal-2##0 5.161
C543 B4#0contact@884_metal-1-metal-2##0 0 5.536fF
R18 B4#0contact@884_metal-1-metal-2##0 B4#1pin@769_metal-2 5.161
R19 B5#0contact@993_metal-1-metal-2 B5#0contact@993_metal-1-metal-2##0 5.161
C544 B5#0contact@993_metal-1-metal-2##0 0 5.536fF
R20 B5#0contact@993_metal-1-metal-2##0 B5#1pin@880_metal-2 5.161
R21 B6#0contact@1101_metal-1-metal-2 B6#0contact@1101_metal-1-metal-2##0 5.161
C545 B6#0contact@1101_metal-1-metal-2##0 0 5.536fF
R22 B6#0contact@1101_metal-1-metal-2##0 B6#1pin@963_metal-2 5.161
R23 B7#0contact@1209_metal-1-metal-2 B7#0contact@1209_metal-1-metal-2##0 5.161
C546 B7#0contact@1209_metal-1-metal-2##0 0 5.536fF
R24 B7#0contact@1209_metal-1-metal-2##0 B7#1pin@1041_metal-2 5.161
R25 Cin#0pin@206_metal-2 Cin 4.212
R26 Cin_to_XOR2___NAND2 Cin_to_XOR2___NAND2#1contact@534_metal-1-metal-2 4.212
R27 Cin_to_XOR2___NAND3 Cin_to_XOR2___NAND3#1contact@646_metal-1-metal-2 4.212
R28 Cin_to_XOR2___NAND4 Cin_to_XOR2___NAND4#1contact@756_metal-1-metal-2 4.212
R29 Cin_to_XOR2___NAND5 Cin_to_XOR2___NAND5#1contact@865_metal-1-metal-2 4.212
R30 Cin_to_XOR2___NAND6 Cin_to_XOR2___NAND6#1contact@974_metal-1-metal-2 4.212
R31 Cin_to_XOR2___NAND7 Cin_to_XOR2___NAND7#1contact@1082_metal-1-metal-2 4.212
R32 Cin_to_XOR2___NAND8 Cin_to_XOR2___NAND8#1contact@1190_metal-1-metal-2 4.212
R33 XOR1_to_NAND1 XOR1_to_NAND1#1contact@309_metal-1-metal-2 4.42
R34 XOR1_to_NAND2 XOR1_to_NAND2#1contact@544_metal-1-metal-2 4.42
R35 XOR1_to_NAND3 XOR1_to_NAND3#1contact@656_metal-1-metal-2 4.42
R36 XOR1_to_NAND4 XOR1_to_NAND4#1contact@766_metal-1-metal-2 4.42
R37 XOR1_to_NAND5 XOR1_to_NAND5#1contact@875_metal-1-metal-2 4.42
R38 XOR1_to_NAND6 XOR1_to_NAND6#1contact@984_metal-1-metal-2 4.42
R39 XOR1_to_NAND7 XOR1_to_NAND7#1contact@1092_metal-1-metal-2 4.42
R40 XOR1_to_NAND8 XOR1_to_NAND8#1contact@1200_metal-1-metal-2 4.42
R41 net@562 net@562##0 9.92
R42 net@562##0 net@562##1 9.92
R43 net@562##1 net@562##2 9.92
R44 net@562##2 net@562##3 9.92
R45 net@562##3 net@562##4 9.92
R46 net@562##4 net@562##5 9.92
R47 net@562##5 net@562##6 9.92
R48 net@562##6 net@562##7 9.92
R49 net@562##7 net@562##8 9.92
R50 net@562##8 net@562##9 9.92
R51 net@562##9 net@562##10 9.92
R52 net@562##10 net@562##11 9.92
R53 net@562##11 net@562##12 9.92
R54 net@562##12 net@562##13 9.92
R55 net@562##13 net@562##14 9.92
R56 net@562##14 net@562##15 9.92
R57 net@562##15 net@562##16 9.92
R58 net@562##16 net@562##17 9.92
R59 net@562##17 net@562##18 9.92
R60 net@562##18 net@562#1pin@176_polysilicon-1 9.92
R61 net@564 net@564##0 9.92
R62 net@564##0 net@564##1 9.92
R63 net@564##1 net@564##2 9.92
R64 net@564##2 net@564##3 9.92
R65 net@564##3 net@564##4 9.92
R66 net@564##4 net@564##5 9.92
R67 net@564##5 net@564##6 9.92
R68 net@564##6 net@564##7 9.92
R69 net@564##7 net@564##8 9.92
R70 net@564##8 net@564##9 9.92
R71 net@564##9 net@564##10 9.92
R72 net@564##10 net@564##11 9.92
R73 net@564##11 net@564##12 9.92
R74 net@564##12 net@564##13 9.92
R75 net@564##13 net@564##14 9.92
R76 net@564##14 net@564##15 9.92
R77 net@564##15 net@564##16 9.92
R78 net@564##16 net@564##17 9.92
R79 net@564##17 net@564##18 9.92
R80 net@564##18 net@564#1pin@202_polysilicon-1 9.92
R81 XOR1_to_NAND1#3pin@203_polysilicon-1 XOR1_to_NAND1#3pin@203_polysilicon-1##0 6.2
R82 XOR1_to_NAND1#3pin@203_polysilicon-1##0 XOR1_to_NAND1#4pmos@52_poly-right 6.2
R83 XOR1_to_NAND1#3pin@203_polysilicon-1 XOR1_to_NAND1#3pin@203_polysilicon-1##0 8.138
R84 XOR1_to_NAND1#3pin@203_polysilicon-1##0 XOR1_to_NAND1#3pin@203_polysilicon-1##1 8.138
R85 XOR1_to_NAND1#3pin@203_polysilicon-1##1 XOR1_to_NAND1#3pin@203_polysilicon-1##2 8.138
R86 XOR1_to_NAND1#3pin@203_polysilicon-1##2 XOR1_to_NAND1#1contact@309_metal-1-metal-2 8.138
R87 Cin#5nmos@51_poly-right Cin#5nmos@51_poly-right##0 5.425
R88 Cin#5nmos@51_poly-right##0 Cin#6pin@193_polysilicon-1 5.425
R89 Cin#0pin@206_metal-2 Cin#0pin@206_metal-2##0 8.99
R90 Cin#0pin@206_metal-2##0 Cin#0pin@206_metal-2##1 8.99
R91 Cin#0pin@206_metal-2##1 Cin#0pin@206_metal-2##2 8.99
R92 Cin#0pin@206_metal-2##2 Cin#0pin@206_metal-2##3 8.99
R93 Cin#0pin@206_metal-2##3 Cin#6pin@193_polysilicon-1 8.99
R94 A0#2pin@177_polysilicon-1 A0#2pin@177_polysilicon-1##0 6.2
R95 A0#2pin@177_polysilicon-1##0 A0#3pmos@45_poly-right 6.2
R96 XOR1_to_NAND1#9pmos@47_poly-left XOR1_to_NAND1#9pmos@47_poly-left##0 8.138
R97 XOR1_to_NAND1#9pmos@47_poly-left##0 XOR1_to_NAND1#9pmos@47_poly-left##1 8.138
R98 XOR1_to_NAND1#9pmos@47_poly-left##1 XOR1_to_NAND1#9pmos@47_poly-left##2 8.138
R99 XOR1_to_NAND1#9pmos@47_poly-left##2 XOR1_to_NAND1#10pin@190_polysilicon-1 8.138
R100 Cin#7pin@183_polysilicon-1 Cin#7pin@183_polysilicon-1##0 9.843
R101 Cin#7pin@183_polysilicon-1##0 Cin#7pin@183_polysilicon-1##1 9.843
R102 Cin#7pin@183_polysilicon-1##1 Cin#7pin@183_polysilicon-1##2 9.843
R103 Cin#7pin@183_polysilicon-1##2 Cin#7pin@183_polysilicon-1##3 9.843
R104 Cin#7pin@183_polysilicon-1##3 Cin#7pin@183_polysilicon-1##4 9.843
R105 Cin#7pin@183_polysilicon-1##4 Cin#7pin@183_polysilicon-1##5 9.843
R106 Cin#7pin@183_polysilicon-1##5 Cin#7pin@183_polysilicon-1##6 9.843
R107 Cin#7pin@183_polysilicon-1##6 Cin#7pin@183_polysilicon-1##7 9.843
R108 Cin#7pin@183_polysilicon-1##7 Cin#7pin@183_polysilicon-1##8 9.843
R109 Cin#7pin@183_polysilicon-1##8 Cin#7pin@183_polysilicon-1##9 9.843
R110 Cin#7pin@183_polysilicon-1##9 Cin#7pin@183_polysilicon-1##10 9.843
R111 Cin#7pin@183_polysilicon-1##10 Cin#7pin@183_polysilicon-1##11 9.843
R112 Cin#7pin@183_polysilicon-1##11 Cin#7pin@183_polysilicon-1##12 9.843
R113 Cin#7pin@183_polysilicon-1##12 Cin#7pin@183_polysilicon-1##13 9.843
R114 Cin#7pin@183_polysilicon-1##13 Cin#7pin@183_polysilicon-1##14 9.843
R115 Cin#7pin@183_polysilicon-1##14 Cin#7pin@183_polysilicon-1##15 9.843
R116 Cin#7pin@183_polysilicon-1##15 Cin#7pin@183_polysilicon-1##16 9.843
R117 Cin#7pin@183_polysilicon-1##16 Cin#7pin@183_polysilicon-1##17 9.843
R118 Cin#7pin@183_polysilicon-1##17 Cin#7pin@183_polysilicon-1##18 9.843
R119 Cin#7pin@183_polysilicon-1##18 Cin#8pin@200_polysilicon-1 9.843
R120 net@576#4nmos@53_poly-right net@576#4nmos@53_poly-right##0 9.3
R121 net@576#4nmos@53_poly-right##0 net@576#4nmos@53_poly-right##1 9.3
R122 net@576#4nmos@53_poly-right##1 net@576#5pin@195_polysilicon-1 9.3
R123 net@576#2contact@295_metal-1-polysilicon-1 net@576#2contact@295_metal-1-polysilicon-1##0 8.99
R124 net@576#2contact@295_metal-1-polysilicon-1##0 net@576#2contact@295_metal-1-polysilicon-1##1 8.99
R125 net@576#2contact@295_metal-1-polysilicon-1##1 net@576#2contact@295_metal-1-polysilicon-1##2 8.99
R126 net@576#2contact@295_metal-1-polysilicon-1##2 net@576#2contact@295_metal-1-polysilicon-1##3 8.99
R127 net@576#2contact@295_metal-1-polysilicon-1##3 net@576#5pin@195_polysilicon-1 8.99
R128 A0#2pin@177_polysilicon-1 A0#2pin@177_polysilicon-1##0 8.138
R129 A0#2pin@177_polysilicon-1##0 A0#2pin@177_polysilicon-1##1 8.138
R130 A0#2pin@177_polysilicon-1##1 A0#2pin@177_polysilicon-1##2 8.138
R131 A0#2pin@177_polysilicon-1##2 A0 8.138
R132 XOR1_to_NAND1#1contact@309_metal-1-metal-2 XOR1_to_NAND1#1contact@309_metal-1-metal-2##0 6.717
R133 XOR1_to_NAND1#1contact@309_metal-1-metal-2##0 XOR1_to_NAND1#1contact@309_metal-1-metal-2##1 6.717
R134 XOR1_to_NAND1#1contact@309_metal-1-metal-2##1 XOR1_to_NAND1#12pin@191_polysilicon-1 6.717
R135 XOR1_to_NAND1#10pin@190_polysilicon-1 XOR1_to_NAND1#10pin@190_polysilicon-1##0 7.75
R136 XOR1_to_NAND1#10pin@190_polysilicon-1##0 XOR1_to_NAND1#10pin@190_polysilicon-1##1 7.75
R137 XOR1_to_NAND1#10pin@190_polysilicon-1##1 XOR1_to_NAND1#12pin@191_polysilicon-1 7.75
R138 Cin#8pin@200_polysilicon-1 Cin#8pin@200_polysilicon-1##0 9.743
R139 Cin#8pin@200_polysilicon-1##0 Cin#8pin@200_polysilicon-1##1 9.743
R140 Cin#8pin@200_polysilicon-1##1 Cin#8pin@200_polysilicon-1##2 9.743
R141 Cin#8pin@200_polysilicon-1##2 Cin#8pin@200_polysilicon-1##3 9.743
R142 Cin#8pin@200_polysilicon-1##3 Cin#8pin@200_polysilicon-1##4 9.743
R143 Cin#8pin@200_polysilicon-1##4 Cin#8pin@200_polysilicon-1##5 9.743
R144 Cin#8pin@200_polysilicon-1##5 Cin#0pin@206_metal-2 9.743
R145 net@564#7pmos@48_poly-left net@564#7pmos@48_poly-left##0 7.75
R146 net@564#7pmos@48_poly-left##0 net@564 7.75
R147 Cin#9nmos@49_poly-left Cin#9nmos@49_poly-left##0 6.2
R148 Cin#9nmos@49_poly-left##0 Cin#7pin@183_polysilicon-1 6.2
R149 net@577#9nmos@50_poly-left net@577#9nmos@50_poly-left##0 8.37
R150 net@577#9nmos@50_poly-left##0 net@577#9nmos@50_poly-left##1 8.37
R151 net@577#9nmos@50_poly-left##1 net@577#9nmos@50_poly-left##2 8.37
R152 net@577#9nmos@50_poly-left##2 net@577#9nmos@50_poly-left##3 8.37
R153 net@577#9nmos@50_poly-left##3 net@577#2contact@270_metal-1-metal-2 8.37
R154 XOR1_to_NAND1 XOR1_to_NAND1##0 6.717
R155 XOR1_to_NAND1##0 XOR1_to_NAND1##1 6.717
R156 XOR1_to_NAND1##1 XOR1_to_NAND1#14pin@207_polysilicon-1 6.717
R157 XOR1_to_NAND1#16pmos@54_poly-right XOR1_to_NAND1#16pmos@54_poly-right##0 6.2
R158 XOR1_to_NAND1#16pmos@54_poly-right##0 XOR1_to_NAND1#14pin@207_polysilicon-1 6.2
R159 Cin#14pin@212_polysilicon-1 Cin#14pin@212_polysilicon-1##0 9.688
R160 Cin#14pin@212_polysilicon-1##0 Cin#14pin@212_polysilicon-1##1 9.688
R161 Cin#14pin@212_polysilicon-1##1 Cin#14pin@212_polysilicon-1##2 9.688
R162 Cin#14pin@212_polysilicon-1##2 Cin#11contact@308_metal-1-metal-2 9.688
R163 Cin#11contact@308_metal-1-metal-2 Cin#0pin@206_metal-2 4.953
R164 A0#0contact@317_metal-1-metal-2 A0#0contact@317_metal-1-metal-2##0 6.717
R165 A0#0contact@317_metal-1-metal-2##0 A0#0contact@317_metal-1-metal-2##1 6.717
R166 A0#0contact@317_metal-1-metal-2##1 A0#8pin@215_polysilicon-1 6.717
R167 A0#9pmos@56_poly-right A0#9pmos@56_poly-right##0 9.558
R168 A0#9pmos@56_poly-right##0 A0#9pmos@56_poly-right##1 9.558
R169 A0#9pmos@56_poly-right##1 A0#9pmos@56_poly-right##2 9.558
R170 A0#9pmos@56_poly-right##2 A0#9pmos@56_poly-right##3 9.558
R171 A0#9pmos@56_poly-right##3 A0#9pmos@56_poly-right##4 9.558
R172 A0#9pmos@56_poly-right##4 A0#8pin@215_polysilicon-1 9.558
R173 B0#8pin@220_polysilicon-1 B0#8pin@220_polysilicon-1##0 8.138
R174 B0#8pin@220_polysilicon-1##0 B0#8pin@220_polysilicon-1##1 8.138
R175 B0#8pin@220_polysilicon-1##1 B0#8pin@220_polysilicon-1##2 8.138
R176 B0#8pin@220_polysilicon-1##2 B0#0contact@318_metal-1-metal-2 8.138
R177 B0#9nmos@44_poly-right B0#9nmos@44_poly-right##0 5.425
R178 B0#9nmos@44_poly-right##0 B0#10pin@167_polysilicon-1 5.425
R179 NAND2_to_Nand3 NAND2_to_Nand3##0 6.717
R180 NAND2_to_Nand3##0 NAND2_to_Nand3##1 6.717
R181 NAND2_to_Nand3##1 NAND2_to_Nand3#9pin@224_polysilicon-1 6.717
R182 NAND2_to_Nand3#10pmos@58_poly-right NAND2_to_Nand3#10pmos@58_poly-right##0 9.558
R183 NAND2_to_Nand3#10pmos@58_poly-right##0 NAND2_to_Nand3#10pmos@58_poly-right##1 9.558
R184 NAND2_to_Nand3#10pmos@58_poly-right##1 NAND2_to_Nand3#10pmos@58_poly-right##2 9.558
R185 NAND2_to_Nand3#10pmos@58_poly-right##2 NAND2_to_Nand3#10pmos@58_poly-right##3 9.558
R186 NAND2_to_Nand3#10pmos@58_poly-right##3 NAND2_to_Nand3#10pmos@58_poly-right##4 9.558
R187 NAND2_to_Nand3#10pmos@58_poly-right##4 NAND2_to_Nand3#9pin@224_polysilicon-1 9.558
R188 B0 B0##0 8.99
R189 B0##0 B0##1 8.99
R190 B0##1 B0##2 8.99
R191 B0##2 B0##3 8.99
R192 B0##3 B0#10pin@167_polysilicon-1 8.99
R193 NAND1_to_NAND3#11pmos@59_poly-right NAND1_to_NAND3#11pmos@59_poly-right##0 5.425
R194 NAND1_to_NAND3#11pmos@59_poly-right##0 NAND1_to_NAND3#12pin@229_polysilicon-1 5.425
R195 NAND1_to_NAND3#12pin@229_polysilicon-1 NAND1_to_NAND3#12pin@229_polysilicon-1##0 9.3
R196 NAND1_to_NAND3#12pin@229_polysilicon-1##0 NAND1_to_NAND3#12pin@229_polysilicon-1##1 9.3
R197 NAND1_to_NAND3#12pin@229_polysilicon-1##1 NAND1_to_NAND3 9.3
R198 Cin#16nmos@55_poly-right Cin#16nmos@55_poly-right##0 8.636
R199 Cin#16nmos@55_poly-right##0 Cin#16nmos@55_poly-right##1 8.636
R200 Cin#16nmos@55_poly-right##1 Cin#16nmos@55_poly-right##2 8.636
R201 Cin#16nmos@55_poly-right##2 Cin#16nmos@55_poly-right##3 8.636
R202 Cin#16nmos@55_poly-right##3 Cin#16nmos@55_poly-right##4 8.636
R203 Cin#16nmos@55_poly-right##4 Cin#16nmos@55_poly-right##5 8.636
R204 Cin#16nmos@55_poly-right##5 Cin#14pin@212_polysilicon-1 8.636
R205 B0#11nmos@57_poly-right B0#11nmos@57_poly-right##0 8.956
R206 B0#11nmos@57_poly-right##0 B0#11nmos@57_poly-right##1 8.956
R207 B0#11nmos@57_poly-right##1 B0#11nmos@57_poly-right##2 8.956
R208 B0#11nmos@57_poly-right##2 B0#11nmos@57_poly-right##3 8.956
R209 B0#11nmos@57_poly-right##3 B0#11nmos@57_poly-right##4 8.956
R210 B0#11nmos@57_poly-right##4 B0#11nmos@57_poly-right##5 8.956
R211 B0#11nmos@57_poly-right##5 B0#11nmos@57_poly-right##6 8.956
R212 B0#11nmos@57_poly-right##6 B0#11nmos@57_poly-right##7 8.956
R213 B0#11nmos@57_poly-right##7 B0#8pin@220_polysilicon-1 8.956
R214 A0#10pmos@40_poly-left A0#10pmos@40_poly-left##0 8.138
R215 A0#10pmos@40_poly-left##0 A0#10pmos@40_poly-left##1 8.138
R216 A0#10pmos@40_poly-left##1 A0#10pmos@40_poly-left##2 8.138
R217 A0#10pmos@40_poly-left##2 A0#11pin@164_polysilicon-1 8.138
R218 B0#12pin@157_polysilicon-1 B0#12pin@157_polysilicon-1##0 9.843
R219 B0#12pin@157_polysilicon-1##0 B0#12pin@157_polysilicon-1##1 9.843
R220 B0#12pin@157_polysilicon-1##1 B0#12pin@157_polysilicon-1##2 9.843
R221 B0#12pin@157_polysilicon-1##2 B0#12pin@157_polysilicon-1##3 9.843
R222 B0#12pin@157_polysilicon-1##3 B0#12pin@157_polysilicon-1##4 9.843
R223 B0#12pin@157_polysilicon-1##4 B0#12pin@157_polysilicon-1##5 9.843
R224 B0#12pin@157_polysilicon-1##5 B0#12pin@157_polysilicon-1##6 9.843
R225 B0#12pin@157_polysilicon-1##6 B0#12pin@157_polysilicon-1##7 9.843
R226 B0#12pin@157_polysilicon-1##7 B0#12pin@157_polysilicon-1##8 9.843
R227 B0#12pin@157_polysilicon-1##8 B0#12pin@157_polysilicon-1##9 9.843
R228 B0#12pin@157_polysilicon-1##9 B0#12pin@157_polysilicon-1##10 9.843
R229 B0#12pin@157_polysilicon-1##10 B0#12pin@157_polysilicon-1##11 9.843
R230 B0#12pin@157_polysilicon-1##11 B0#12pin@157_polysilicon-1##12 9.843
R231 B0#12pin@157_polysilicon-1##12 B0#12pin@157_polysilicon-1##13 9.843
R232 B0#12pin@157_polysilicon-1##13 B0#12pin@157_polysilicon-1##14 9.843
R233 B0#12pin@157_polysilicon-1##14 B0#12pin@157_polysilicon-1##15 9.843
R234 B0#12pin@157_polysilicon-1##15 B0#12pin@157_polysilicon-1##16 9.843
R235 B0#12pin@157_polysilicon-1##16 B0#12pin@157_polysilicon-1##17 9.843
R236 B0#12pin@157_polysilicon-1##17 B0#12pin@157_polysilicon-1##18 9.843
R237 B0#12pin@157_polysilicon-1##18 B0#13pin@174_polysilicon-1 9.843
R238 net@676#4nmos@46_poly-right net@676#4nmos@46_poly-right##0 7.233
R239 net@676#4nmos@46_poly-right##0 net@676#4nmos@46_poly-right##1 7.233
R240 net@676#4nmos@46_poly-right##1 net@676#5pin@169_polysilicon-1 7.233
R241 net@676#2contact@256_metal-1-polysilicon-1 net@676#2contact@256_metal-1-polysilicon-1##0 8.99
R242 net@676#2contact@256_metal-1-polysilicon-1##0 net@676#2contact@256_metal-1-polysilicon-1##1 8.99
R243 net@676#2contact@256_metal-1-polysilicon-1##1 net@676#2contact@256_metal-1-polysilicon-1##2 8.99
R244 net@676#2contact@256_metal-1-polysilicon-1##2 net@676#2contact@256_metal-1-polysilicon-1##3 8.99
R245 net@676#2contact@256_metal-1-polysilicon-1##3 net@676#5pin@169_polysilicon-1 8.99
R246 A0 A0##0 6.717
R247 A0##0 A0##1 6.717
R248 A0##1 A0#13pin@165_polysilicon-1 6.717
R249 A0#11pin@164_polysilicon-1 A0#11pin@164_polysilicon-1##0 7.75
R250 A0#11pin@164_polysilicon-1##0 A0#11pin@164_polysilicon-1##1 7.75
R251 A0#11pin@164_polysilicon-1##1 A0#13pin@165_polysilicon-1 7.75
R252 B0#13pin@174_polysilicon-1 B0#13pin@174_polysilicon-1##0 9.743
R253 B0#13pin@174_polysilicon-1##0 B0#13pin@174_polysilicon-1##1 9.743
R254 B0#13pin@174_polysilicon-1##1 B0#13pin@174_polysilicon-1##2 9.743
R255 B0#13pin@174_polysilicon-1##2 B0#13pin@174_polysilicon-1##3 9.743
R256 B0#13pin@174_polysilicon-1##3 B0#13pin@174_polysilicon-1##4 9.743
R257 B0#13pin@174_polysilicon-1##4 B0#13pin@174_polysilicon-1##5 9.743
R258 B0#13pin@174_polysilicon-1##5 B0 9.743
R259 net@562#7pmos@41_poly-left net@562#7pmos@41_poly-left##0 7.75
R260 net@562#7pmos@41_poly-left##0 net@562 7.75
R261 B0#14nmos@42_poly-left B0#14nmos@42_poly-left##0 6.2
R262 B0#14nmos@42_poly-left##0 B0#12pin@157_polysilicon-1 6.2
R263 net@684#9nmos@43_poly-left net@684#9nmos@43_poly-left##0 8.37
R264 net@684#9nmos@43_poly-left##0 net@684#9nmos@43_poly-left##1 8.37
R265 net@684#9nmos@43_poly-left##1 net@684#9nmos@43_poly-left##2 8.37
R266 net@684#9nmos@43_poly-left##2 net@684#9nmos@43_poly-left##3 8.37
R267 net@684#9nmos@43_poly-left##3 net@684#2contact@231_metal-1-metal-2 8.37
R268 A0#2pin@177_polysilicon-1 A0#2pin@177_polysilicon-1##0 9.881
R269 A0#2pin@177_polysilicon-1##0 A0#2pin@177_polysilicon-1##1 9.881
R270 A0#2pin@177_polysilicon-1##1 A0#2pin@177_polysilicon-1##2 9.881
R271 A0#2pin@177_polysilicon-1##2 A0#2pin@177_polysilicon-1##3 9.881
R272 A0#2pin@177_polysilicon-1##3 A0#2pin@177_polysilicon-1##4 9.881
R273 A0#2pin@177_polysilicon-1##4 A0#2pin@177_polysilicon-1##5 9.881
R274 A0#2pin@177_polysilicon-1##5 A0#2pin@177_polysilicon-1##6 9.881
R275 A0#2pin@177_polysilicon-1##6 A0#2pin@177_polysilicon-1##7 9.881
R276 A0#2pin@177_polysilicon-1##7 A0#2pin@177_polysilicon-1##8 9.881
R277 A0#2pin@177_polysilicon-1##8 A0#2pin@177_polysilicon-1##9 9.881
R278 A0#2pin@177_polysilicon-1##9 A0#2pin@177_polysilicon-1##10 9.881
R279 A0#2pin@177_polysilicon-1##10 A0#2pin@177_polysilicon-1##11 9.881
R280 A0#2pin@177_polysilicon-1##11 A0#2pin@177_polysilicon-1##12 9.881
R281 A0#2pin@177_polysilicon-1##12 A0#2pin@177_polysilicon-1##13 9.881
R282 A0#2pin@177_polysilicon-1##13 A0#2pin@177_polysilicon-1##14 9.881
R283 A0#2pin@177_polysilicon-1##14 A0#2pin@177_polysilicon-1##15 9.881
R284 A0#2pin@177_polysilicon-1##15 A0#2pin@177_polysilicon-1##16 9.881
R285 A0#2pin@177_polysilicon-1##16 A0#2pin@177_polysilicon-1##17 9.881
R286 A0#2pin@177_polysilicon-1##17 A0#2pin@177_polysilicon-1##18 9.881
R287 A0#2pin@177_polysilicon-1##18 A0#2pin@177_polysilicon-1##19 9.881
R288 A0#2pin@177_polysilicon-1##19 A0#2pin@177_polysilicon-1##20 9.881
R289 A0#2pin@177_polysilicon-1##20 A0#2pin@177_polysilicon-1##21 9.881
R290 A0#2pin@177_polysilicon-1##21 A0#2pin@177_polysilicon-1##22 9.881
R291 A0#2pin@177_polysilicon-1##22 A0#2pin@177_polysilicon-1##23 9.881
R292 A0#2pin@177_polysilicon-1##23 A0#2pin@177_polysilicon-1##24 9.881
R293 A0#2pin@177_polysilicon-1##24 A0#2pin@177_polysilicon-1##25 9.881
R294 A0#2pin@177_polysilicon-1##25 A0#2pin@177_polysilicon-1##26 9.881
R295 A0#2pin@177_polysilicon-1##26 A0#2pin@177_polysilicon-1##27 9.881
R296 A0#2pin@177_polysilicon-1##27 A0#2pin@177_polysilicon-1##28 9.881
R297 A0#2pin@177_polysilicon-1##28 A0#2pin@177_polysilicon-1##29 9.881
R298 A0#2pin@177_polysilicon-1##29 A0#2pin@177_polysilicon-1##30 9.881
R299 A0#2pin@177_polysilicon-1##30 A0#2pin@177_polysilicon-1##31 9.881
R300 A0#2pin@177_polysilicon-1##31 A0#2pin@177_polysilicon-1##32 9.881
R301 A0#2pin@177_polysilicon-1##32 A0#2pin@177_polysilicon-1##33 9.881
R302 A0#2pin@177_polysilicon-1##33 A0#2pin@177_polysilicon-1##34 9.881
R303 A0#2pin@177_polysilicon-1##34 A0#2pin@177_polysilicon-1##35 9.881
R304 A0#2pin@177_polysilicon-1##35 A0#2pin@177_polysilicon-1##36 9.881
R305 A0#2pin@177_polysilicon-1##36 A0#2pin@177_polysilicon-1##37 9.881
R306 A0#2pin@177_polysilicon-1##37 A0#2pin@177_polysilicon-1##38 9.881
R307 A0#2pin@177_polysilicon-1##38 A0#2pin@177_polysilicon-1##39 9.881
R308 A0#2pin@177_polysilicon-1##39 A0#2pin@177_polysilicon-1##40 9.881
R309 A0#2pin@177_polysilicon-1##40 A0#2pin@177_polysilicon-1##41 9.881
R310 A0#2pin@177_polysilicon-1##41 A0#2pin@177_polysilicon-1##42 9.881
R311 A0#2pin@177_polysilicon-1##42 A0#2pin@177_polysilicon-1##43 9.881
R312 A0#2pin@177_polysilicon-1##43 A0#2pin@177_polysilicon-1##44 9.881
R313 A0#2pin@177_polysilicon-1##44 A0#2pin@177_polysilicon-1##45 9.881
R314 A0#2pin@177_polysilicon-1##45 A0#2pin@177_polysilicon-1##46 9.881
R315 A0#2pin@177_polysilicon-1##46 A0#2pin@177_polysilicon-1##47 9.881
R316 A0#2pin@177_polysilicon-1##47 A0#2pin@177_polysilicon-1##48 9.881
R317 A0#2pin@177_polysilicon-1##48 A0#2pin@177_polysilicon-1##49 9.881
R318 A0#2pin@177_polysilicon-1##49 A0#2pin@177_polysilicon-1##50 9.881
R319 A0#2pin@177_polysilicon-1##50 A0#2pin@177_polysilicon-1##51 9.881
R320 A0#2pin@177_polysilicon-1##51 A0#2pin@177_polysilicon-1##52 9.881
R321 A0#2pin@177_polysilicon-1##52 A0#2pin@177_polysilicon-1##53 9.881
R322 A0#2pin@177_polysilicon-1##53 A0#2pin@177_polysilicon-1##54 9.881
R323 A0#2pin@177_polysilicon-1##54 A0#14nmos@45_poly-right 9.881
R324 net@562#5pmos@45_diff-top net@562#2pin@166_metal-1 4.81
R325 net@562#1pin@176_polysilicon-1 net@562#1pin@176_polysilicon-1##0 9.85
R326 net@562#1pin@176_polysilicon-1##0 net@562#1pin@176_polysilicon-1##1 9.85
R327 net@562#1pin@176_polysilicon-1##1 net@562#1pin@176_polysilicon-1##2 9.85
R328 net@562#1pin@176_polysilicon-1##2 net@562#1pin@176_polysilicon-1##3 9.85
R329 net@562#1pin@176_polysilicon-1##3 net@562#1pin@176_polysilicon-1##4 9.85
R330 net@562#1pin@176_polysilicon-1##4 net@562#1pin@176_polysilicon-1##5 9.85
R331 net@562#1pin@176_polysilicon-1##5 net@562#1pin@176_polysilicon-1##6 9.85
R332 net@562#1pin@176_polysilicon-1##6 net@562#1pin@176_polysilicon-1##7 9.85
R333 net@562#1pin@176_polysilicon-1##7 net@562#1pin@176_polysilicon-1##8 9.85
R334 net@562#1pin@176_polysilicon-1##8 net@562#1pin@176_polysilicon-1##9 9.85
R335 net@562#1pin@176_polysilicon-1##9 net@562#1pin@176_polysilicon-1##10 9.85
R336 net@562#1pin@176_polysilicon-1##10 net@562#1pin@176_polysilicon-1##11 9.85
R337 net@562#1pin@176_polysilicon-1##11 net@562#1pin@176_polysilicon-1##12 9.85
R338 net@562#1pin@176_polysilicon-1##12 net@562#1pin@176_polysilicon-1##13 9.85
R339 net@562#1pin@176_polysilicon-1##13 net@562#1pin@176_polysilicon-1##14 9.85
R340 net@562#1pin@176_polysilicon-1##14 net@562#1pin@176_polysilicon-1##15 9.85
R341 net@562#1pin@176_polysilicon-1##15 net@562#1pin@176_polysilicon-1##16 9.85
R342 net@562#1pin@176_polysilicon-1##16 net@562#1pin@176_polysilicon-1##17 9.85
R343 net@562#1pin@176_polysilicon-1##17 net@562#1pin@176_polysilicon-1##18 9.85
R344 net@562#1pin@176_polysilicon-1##18 net@562#1pin@176_polysilicon-1##19 9.85
R345 net@562#1pin@176_polysilicon-1##19 net@562#1pin@176_polysilicon-1##20 9.85
R346 net@562#1pin@176_polysilicon-1##20 net@562#1pin@176_polysilicon-1##21 9.85
R347 net@562#1pin@176_polysilicon-1##21 net@562#1pin@176_polysilicon-1##22 9.85
R348 net@562#1pin@176_polysilicon-1##22 net@562#1pin@176_polysilicon-1##23 9.85
R349 net@562#1pin@176_polysilicon-1##23 net@562#1pin@176_polysilicon-1##24 9.85
R350 net@562#1pin@176_polysilicon-1##24 net@562#1pin@176_polysilicon-1##25 9.85
R351 net@562#1pin@176_polysilicon-1##25 net@562#1pin@176_polysilicon-1##26 9.85
R352 net@562#1pin@176_polysilicon-1##26 net@562#1pin@176_polysilicon-1##27 9.85
R353 net@562#1pin@176_polysilicon-1##27 net@562#1pin@176_polysilicon-1##28 9.85
R354 net@562#1pin@176_polysilicon-1##28 net@562#1pin@176_polysilicon-1##29 9.85
R355 net@562#1pin@176_polysilicon-1##29 net@562#1pin@176_polysilicon-1##30 9.85
R356 net@562#1pin@176_polysilicon-1##30 net@562#1pin@176_polysilicon-1##31 9.85
R357 net@562#1pin@176_polysilicon-1##31 net@562#1pin@176_polysilicon-1##32 9.85
R358 net@562#1pin@176_polysilicon-1##32 net@562#1pin@176_polysilicon-1##33 9.85
R359 net@562#1pin@176_polysilicon-1##33 net@562#1pin@176_polysilicon-1##34 9.85
R360 net@562#1pin@176_polysilicon-1##34 net@562#1pin@176_polysilicon-1##35 9.85
R361 net@562#1pin@176_polysilicon-1##35 net@562#1pin@176_polysilicon-1##36 9.85
R362 net@562#1pin@176_polysilicon-1##36 net@562#1pin@176_polysilicon-1##37 9.85
R363 net@562#1pin@176_polysilicon-1##37 net@562#1pin@176_polysilicon-1##38 9.85
R364 net@562#1pin@176_polysilicon-1##38 net@562#1pin@176_polysilicon-1##39 9.85
R365 net@562#1pin@176_polysilicon-1##39 net@562#1pin@176_polysilicon-1##40 9.85
R366 net@562#1pin@176_polysilicon-1##40 net@562#1pin@176_polysilicon-1##41 9.85
R367 net@562#1pin@176_polysilicon-1##41 net@562#1pin@176_polysilicon-1##42 9.85
R368 net@562#1pin@176_polysilicon-1##42 net@562#1pin@176_polysilicon-1##43 9.85
R369 net@562#1pin@176_polysilicon-1##43 net@562#1pin@176_polysilicon-1##44 9.85
R370 net@562#1pin@176_polysilicon-1##44 net@562#1pin@176_polysilicon-1##45 9.85
R371 net@562#1pin@176_polysilicon-1##45 net@562#1pin@176_polysilicon-1##46 9.85
R372 net@562#1pin@176_polysilicon-1##46 net@562#1pin@176_polysilicon-1##47 9.85
R373 net@562#1pin@176_polysilicon-1##47 net@562#1pin@176_polysilicon-1##48 9.85
R374 net@562#1pin@176_polysilicon-1##48 net@562#1pin@176_polysilicon-1##49 9.85
R375 net@562#1pin@176_polysilicon-1##49 net@562#1pin@176_polysilicon-1##50 9.85
R376 net@562#1pin@176_polysilicon-1##50 net@562#1pin@176_polysilicon-1##51 9.85
R377 net@562#1pin@176_polysilicon-1##51 net@562#1pin@176_polysilicon-1##52 9.85
R378 net@562#1pin@176_polysilicon-1##52 net@562#1pin@176_polysilicon-1##53 9.85
R379 net@562#1pin@176_polysilicon-1##53 net@562#1pin@176_polysilicon-1##54 9.85
R380 net@562#1pin@176_polysilicon-1##54 net@562#1pin@176_polysilicon-1##55 9.85
R381 net@562#1pin@176_polysilicon-1##55 net@562#1pin@176_polysilicon-1##56 9.85
R382 net@562#1pin@176_polysilicon-1##56 net@562#1pin@176_polysilicon-1##57 9.85
R383 net@562#1pin@176_polysilicon-1##57 net@562#1pin@176_polysilicon-1##58 9.85
R384 net@562#1pin@176_polysilicon-1##58 net@562#1pin@176_polysilicon-1##59 9.85
R385 net@562#1pin@176_polysilicon-1##59 net@562#1pin@176_polysilicon-1##60 9.85
R386 net@562#1pin@176_polysilicon-1##60 net@562#2pin@166_metal-1 9.85
R387 B0#15pmos@44_poly-right B0#15pmos@44_poly-right##0 9.854
R388 B0#15pmos@44_poly-right##0 B0#15pmos@44_poly-right##1 9.854
R389 B0#15pmos@44_poly-right##1 B0#15pmos@44_poly-right##2 9.854
R390 B0#15pmos@44_poly-right##2 B0#15pmos@44_poly-right##3 9.854
R391 B0#15pmos@44_poly-right##3 B0#15pmos@44_poly-right##4 9.854
R392 B0#15pmos@44_poly-right##4 B0#15pmos@44_poly-right##5 9.854
R393 B0#15pmos@44_poly-right##5 B0#15pmos@44_poly-right##6 9.854
R394 B0#15pmos@44_poly-right##6 B0#15pmos@44_poly-right##7 9.854
R395 B0#15pmos@44_poly-right##7 B0#15pmos@44_poly-right##8 9.854
R396 B0#15pmos@44_poly-right##8 B0#15pmos@44_poly-right##9 9.854
R397 B0#15pmos@44_poly-right##9 B0#15pmos@44_poly-right##10 9.854
R398 B0#15pmos@44_poly-right##10 B0#15pmos@44_poly-right##11 9.854
R399 B0#15pmos@44_poly-right##11 B0#15pmos@44_poly-right##12 9.854
R400 B0#15pmos@44_poly-right##12 B0#15pmos@44_poly-right##13 9.854
R401 B0#15pmos@44_poly-right##13 B0#15pmos@44_poly-right##14 9.854
R402 B0#15pmos@44_poly-right##14 B0#15pmos@44_poly-right##15 9.854
R403 B0#15pmos@44_poly-right##15 B0#15pmos@44_poly-right##16 9.854
R404 B0#15pmos@44_poly-right##16 B0#15pmos@44_poly-right##17 9.854
R405 B0#15pmos@44_poly-right##17 B0#15pmos@44_poly-right##18 9.854
R406 B0#15pmos@44_poly-right##18 B0#15pmos@44_poly-right##19 9.854
R407 B0#15pmos@44_poly-right##19 B0#15pmos@44_poly-right##20 9.854
R408 B0#15pmos@44_poly-right##20 B0#15pmos@44_poly-right##21 9.854
R409 B0#15pmos@44_poly-right##21 B0#15pmos@44_poly-right##22 9.854
R410 B0#15pmos@44_poly-right##22 B0#15pmos@44_poly-right##23 9.854
R411 B0#15pmos@44_poly-right##23 B0#15pmos@44_poly-right##24 9.854
R412 B0#15pmos@44_poly-right##24 B0#15pmos@44_poly-right##25 9.854
R413 B0#15pmos@44_poly-right##25 B0#15pmos@44_poly-right##26 9.854
R414 B0#15pmos@44_poly-right##26 B0#15pmos@44_poly-right##27 9.854
R415 B0#15pmos@44_poly-right##27 B0#15pmos@44_poly-right##28 9.854
R416 B0#15pmos@44_poly-right##28 B0#15pmos@44_poly-right##29 9.854
R417 B0#15pmos@44_poly-right##29 B0#15pmos@44_poly-right##30 9.854
R418 B0#15pmos@44_poly-right##30 B0#15pmos@44_poly-right##31 9.854
R419 B0#15pmos@44_poly-right##31 B0#15pmos@44_poly-right##32 9.854
R420 B0#15pmos@44_poly-right##32 B0#15pmos@44_poly-right##33 9.854
R421 B0#15pmos@44_poly-right##33 B0#15pmos@44_poly-right##34 9.854
R422 B0#15pmos@44_poly-right##34 B0#15pmos@44_poly-right##35 9.854
R423 B0#15pmos@44_poly-right##35 B0#15pmos@44_poly-right##36 9.854
R424 B0#15pmos@44_poly-right##36 B0#15pmos@44_poly-right##37 9.854
R425 B0#15pmos@44_poly-right##37 B0#15pmos@44_poly-right##38 9.854
R426 B0#15pmos@44_poly-right##38 B0#15pmos@44_poly-right##39 9.854
R427 B0#15pmos@44_poly-right##39 B0#15pmos@44_poly-right##40 9.854
R428 B0#15pmos@44_poly-right##40 B0#15pmos@44_poly-right##41 9.854
R429 B0#15pmos@44_poly-right##41 B0#15pmos@44_poly-right##42 9.854
R430 B0#15pmos@44_poly-right##42 B0#15pmos@44_poly-right##43 9.854
R431 B0#15pmos@44_poly-right##43 B0#15pmos@44_poly-right##44 9.854
R432 B0#15pmos@44_poly-right##44 B0#15pmos@44_poly-right##45 9.854
R433 B0#15pmos@44_poly-right##45 B0#15pmos@44_poly-right##46 9.854
R434 B0#15pmos@44_poly-right##46 B0#15pmos@44_poly-right##47 9.854
R435 B0#15pmos@44_poly-right##47 B0#15pmos@44_poly-right##48 9.854
R436 B0#15pmos@44_poly-right##48 B0#15pmos@44_poly-right##49 9.854
R437 B0#15pmos@44_poly-right##49 B0#15pmos@44_poly-right##50 9.854
R438 B0#15pmos@44_poly-right##50 B0#15pmos@44_poly-right##51 9.854
R439 B0#15pmos@44_poly-right##51 B0#15pmos@44_poly-right##52 9.854
R440 B0#15pmos@44_poly-right##52 B0#15pmos@44_poly-right##53 9.854
R441 B0#15pmos@44_poly-right##53 B0#15pmos@44_poly-right##54 9.854
R442 B0#15pmos@44_poly-right##54 B0#10pin@167_polysilicon-1 9.854
R443 net@684 net@684#2contact@231_metal-1-metal-2 4.797
R444 A0#15nmos@40_poly-right A0#15nmos@40_poly-right##0 9.871
R445 A0#15nmos@40_poly-right##0 A0#15nmos@40_poly-right##1 9.871
R446 A0#15nmos@40_poly-right##1 A0#15nmos@40_poly-right##2 9.871
R447 A0#15nmos@40_poly-right##2 A0#15nmos@40_poly-right##3 9.871
R448 A0#15nmos@40_poly-right##3 A0#15nmos@40_poly-right##4 9.871
R449 A0#15nmos@40_poly-right##4 A0#15nmos@40_poly-right##5 9.871
R450 A0#15nmos@40_poly-right##5 A0#15nmos@40_poly-right##6 9.871
R451 A0#15nmos@40_poly-right##6 A0#15nmos@40_poly-right##7 9.871
R452 A0#15nmos@40_poly-right##7 A0#15nmos@40_poly-right##8 9.871
R453 A0#15nmos@40_poly-right##8 A0#15nmos@40_poly-right##9 9.871
R454 A0#15nmos@40_poly-right##9 A0#15nmos@40_poly-right##10 9.871
R455 A0#15nmos@40_poly-right##10 A0#15nmos@40_poly-right##11 9.871
R456 A0#15nmos@40_poly-right##11 A0#15nmos@40_poly-right##12 9.871
R457 A0#15nmos@40_poly-right##12 A0#15nmos@40_poly-right##13 9.871
R458 A0#15nmos@40_poly-right##13 A0#15nmos@40_poly-right##14 9.871
R459 A0#15nmos@40_poly-right##14 A0#15nmos@40_poly-right##15 9.871
R460 A0#15nmos@40_poly-right##15 A0#15nmos@40_poly-right##16 9.871
R461 A0#15nmos@40_poly-right##16 A0#15nmos@40_poly-right##17 9.871
R462 A0#15nmos@40_poly-right##17 A0#15nmos@40_poly-right##18 9.871
R463 A0#15nmos@40_poly-right##18 A0#15nmos@40_poly-right##19 9.871
R464 A0#15nmos@40_poly-right##19 A0#15nmos@40_poly-right##20 9.871
R465 A0#15nmos@40_poly-right##20 A0#15nmos@40_poly-right##21 9.871
R466 A0#15nmos@40_poly-right##21 A0#15nmos@40_poly-right##22 9.871
R467 A0#15nmos@40_poly-right##22 A0#15nmos@40_poly-right##23 9.871
R468 A0#15nmos@40_poly-right##23 A0#15nmos@40_poly-right##24 9.871
R469 A0#15nmos@40_poly-right##24 A0#15nmos@40_poly-right##25 9.871
R470 A0#15nmos@40_poly-right##25 A0#15nmos@40_poly-right##26 9.871
R471 A0#15nmos@40_poly-right##26 A0#15nmos@40_poly-right##27 9.871
R472 A0#15nmos@40_poly-right##27 A0#15nmos@40_poly-right##28 9.871
R473 A0#15nmos@40_poly-right##28 A0#15nmos@40_poly-right##29 9.871
R474 A0#15nmos@40_poly-right##29 A0#15nmos@40_poly-right##30 9.871
R475 A0#15nmos@40_poly-right##30 A0#15nmos@40_poly-right##31 9.871
R476 A0#15nmos@40_poly-right##31 A0#15nmos@40_poly-right##32 9.871
R477 A0#15nmos@40_poly-right##32 A0#15nmos@40_poly-right##33 9.871
R478 A0#15nmos@40_poly-right##33 A0#15nmos@40_poly-right##34 9.871
R479 A0#15nmos@40_poly-right##34 A0#15nmos@40_poly-right##35 9.871
R480 A0#15nmos@40_poly-right##35 A0#15nmos@40_poly-right##36 9.871
R481 A0#15nmos@40_poly-right##36 A0#15nmos@40_poly-right##37 9.871
R482 A0#15nmos@40_poly-right##37 A0#15nmos@40_poly-right##38 9.871
R483 A0#15nmos@40_poly-right##38 A0#15nmos@40_poly-right##39 9.871
R484 A0#15nmos@40_poly-right##39 A0#15nmos@40_poly-right##40 9.871
R485 A0#15nmos@40_poly-right##40 A0#15nmos@40_poly-right##41 9.871
R486 A0#15nmos@40_poly-right##41 A0#15nmos@40_poly-right##42 9.871
R487 A0#15nmos@40_poly-right##42 A0#15nmos@40_poly-right##43 9.871
R488 A0#15nmos@40_poly-right##43 A0#15nmos@40_poly-right##44 9.871
R489 A0#15nmos@40_poly-right##44 A0#15nmos@40_poly-right##45 9.871
R490 A0#15nmos@40_poly-right##45 A0#15nmos@40_poly-right##46 9.871
R491 A0#15nmos@40_poly-right##46 A0#15nmos@40_poly-right##47 9.871
R492 A0#15nmos@40_poly-right##47 A0#15nmos@40_poly-right##48 9.871
R493 A0#15nmos@40_poly-right##48 A0#15nmos@40_poly-right##49 9.871
R494 A0#15nmos@40_poly-right##49 A0#15nmos@40_poly-right##50 9.871
R495 A0#15nmos@40_poly-right##50 A0#15nmos@40_poly-right##51 9.871
R496 A0#15nmos@40_poly-right##51 A0#15nmos@40_poly-right##52 9.871
R497 A0#15nmos@40_poly-right##52 A0#15nmos@40_poly-right##53 9.871
R498 A0#15nmos@40_poly-right##53 A0#15nmos@40_poly-right##54 9.871
R499 A0#15nmos@40_poly-right##54 A0#15nmos@40_poly-right##55 9.871
R500 A0#15nmos@40_poly-right##55 A0#10pmos@40_poly-left 9.871
R501 net@562#7pmos@41_poly-left net@562#7pmos@41_poly-left##0 9.871
R502 net@562#7pmos@41_poly-left##0 net@562#7pmos@41_poly-left##1 9.871
R503 net@562#7pmos@41_poly-left##1 net@562#7pmos@41_poly-left##2 9.871
R504 net@562#7pmos@41_poly-left##2 net@562#7pmos@41_poly-left##3 9.871
R505 net@562#7pmos@41_poly-left##3 net@562#7pmos@41_poly-left##4 9.871
R506 net@562#7pmos@41_poly-left##4 net@562#7pmos@41_poly-left##5 9.871
R507 net@562#7pmos@41_poly-left##5 net@562#7pmos@41_poly-left##6 9.871
R508 net@562#7pmos@41_poly-left##6 net@562#7pmos@41_poly-left##7 9.871
R509 net@562#7pmos@41_poly-left##7 net@562#7pmos@41_poly-left##8 9.871
R510 net@562#7pmos@41_poly-left##8 net@562#7pmos@41_poly-left##9 9.871
R511 net@562#7pmos@41_poly-left##9 net@562#7pmos@41_poly-left##10 9.871
R512 net@562#7pmos@41_poly-left##10 net@562#7pmos@41_poly-left##11 9.871
R513 net@562#7pmos@41_poly-left##11 net@562#7pmos@41_poly-left##12 9.871
R514 net@562#7pmos@41_poly-left##12 net@562#7pmos@41_poly-left##13 9.871
R515 net@562#7pmos@41_poly-left##13 net@562#7pmos@41_poly-left##14 9.871
R516 net@562#7pmos@41_poly-left##14 net@562#7pmos@41_poly-left##15 9.871
R517 net@562#7pmos@41_poly-left##15 net@562#7pmos@41_poly-left##16 9.871
R518 net@562#7pmos@41_poly-left##16 net@562#7pmos@41_poly-left##17 9.871
R519 net@562#7pmos@41_poly-left##17 net@562#7pmos@41_poly-left##18 9.871
R520 net@562#7pmos@41_poly-left##18 net@562#7pmos@41_poly-left##19 9.871
R521 net@562#7pmos@41_poly-left##19 net@562#7pmos@41_poly-left##20 9.871
R522 net@562#7pmos@41_poly-left##20 net@562#7pmos@41_poly-left##21 9.871
R523 net@562#7pmos@41_poly-left##21 net@562#7pmos@41_poly-left##22 9.871
R524 net@562#7pmos@41_poly-left##22 net@562#7pmos@41_poly-left##23 9.871
R525 net@562#7pmos@41_poly-left##23 net@562#7pmos@41_poly-left##24 9.871
R526 net@562#7pmos@41_poly-left##24 net@562#7pmos@41_poly-left##25 9.871
R527 net@562#7pmos@41_poly-left##25 net@562#7pmos@41_poly-left##26 9.871
R528 net@562#7pmos@41_poly-left##26 net@562#7pmos@41_poly-left##27 9.871
R529 net@562#7pmos@41_poly-left##27 net@562#7pmos@41_poly-left##28 9.871
R530 net@562#7pmos@41_poly-left##28 net@562#7pmos@41_poly-left##29 9.871
R531 net@562#7pmos@41_poly-left##29 net@562#7pmos@41_poly-left##30 9.871
R532 net@562#7pmos@41_poly-left##30 net@562#7pmos@41_poly-left##31 9.871
R533 net@562#7pmos@41_poly-left##31 net@562#7pmos@41_poly-left##32 9.871
R534 net@562#7pmos@41_poly-left##32 net@562#7pmos@41_poly-left##33 9.871
R535 net@562#7pmos@41_poly-left##33 net@562#7pmos@41_poly-left##34 9.871
R536 net@562#7pmos@41_poly-left##34 net@562#7pmos@41_poly-left##35 9.871
R537 net@562#7pmos@41_poly-left##35 net@562#7pmos@41_poly-left##36 9.871
R538 net@562#7pmos@41_poly-left##36 net@562#7pmos@41_poly-left##37 9.871
R539 net@562#7pmos@41_poly-left##37 net@562#7pmos@41_poly-left##38 9.871
R540 net@562#7pmos@41_poly-left##38 net@562#7pmos@41_poly-left##39 9.871
R541 net@562#7pmos@41_poly-left##39 net@562#7pmos@41_poly-left##40 9.871
R542 net@562#7pmos@41_poly-left##40 net@562#7pmos@41_poly-left##41 9.871
R543 net@562#7pmos@41_poly-left##41 net@562#7pmos@41_poly-left##42 9.871
R544 net@562#7pmos@41_poly-left##42 net@562#7pmos@41_poly-left##43 9.871
R545 net@562#7pmos@41_poly-left##43 net@562#7pmos@41_poly-left##44 9.871
R546 net@562#7pmos@41_poly-left##44 net@562#7pmos@41_poly-left##45 9.871
R547 net@562#7pmos@41_poly-left##45 net@562#7pmos@41_poly-left##46 9.871
R548 net@562#7pmos@41_poly-left##46 net@562#7pmos@41_poly-left##47 9.871
R549 net@562#7pmos@41_poly-left##47 net@562#7pmos@41_poly-left##48 9.871
R550 net@562#7pmos@41_poly-left##48 net@562#7pmos@41_poly-left##49 9.871
R551 net@562#7pmos@41_poly-left##49 net@562#7pmos@41_poly-left##50 9.871
R552 net@562#7pmos@41_poly-left##50 net@562#7pmos@41_poly-left##51 9.871
R553 net@562#7pmos@41_poly-left##51 net@562#7pmos@41_poly-left##52 9.871
R554 net@562#7pmos@41_poly-left##52 net@562#7pmos@41_poly-left##53 9.871
R555 net@562#7pmos@41_poly-left##53 net@562#7pmos@41_poly-left##54 9.871
R556 net@562#7pmos@41_poly-left##54 net@562#7pmos@41_poly-left##55 9.871
R557 net@562#7pmos@41_poly-left##55 net@562#11nmos@41_poly-right 9.871
R558 B0#16pmos@42_poly-right B0#16pmos@42_poly-right##0 9.871
R559 B0#16pmos@42_poly-right##0 B0#16pmos@42_poly-right##1 9.871
R560 B0#16pmos@42_poly-right##1 B0#16pmos@42_poly-right##2 9.871
R561 B0#16pmos@42_poly-right##2 B0#16pmos@42_poly-right##3 9.871
R562 B0#16pmos@42_poly-right##3 B0#16pmos@42_poly-right##4 9.871
R563 B0#16pmos@42_poly-right##4 B0#16pmos@42_poly-right##5 9.871
R564 B0#16pmos@42_poly-right##5 B0#16pmos@42_poly-right##6 9.871
R565 B0#16pmos@42_poly-right##6 B0#16pmos@42_poly-right##7 9.871
R566 B0#16pmos@42_poly-right##7 B0#16pmos@42_poly-right##8 9.871
R567 B0#16pmos@42_poly-right##8 B0#16pmos@42_poly-right##9 9.871
R568 B0#16pmos@42_poly-right##9 B0#16pmos@42_poly-right##10 9.871
R569 B0#16pmos@42_poly-right##10 B0#16pmos@42_poly-right##11 9.871
R570 B0#16pmos@42_poly-right##11 B0#16pmos@42_poly-right##12 9.871
R571 B0#16pmos@42_poly-right##12 B0#16pmos@42_poly-right##13 9.871
R572 B0#16pmos@42_poly-right##13 B0#16pmos@42_poly-right##14 9.871
R573 B0#16pmos@42_poly-right##14 B0#16pmos@42_poly-right##15 9.871
R574 B0#16pmos@42_poly-right##15 B0#16pmos@42_poly-right##16 9.871
R575 B0#16pmos@42_poly-right##16 B0#16pmos@42_poly-right##17 9.871
R576 B0#16pmos@42_poly-right##17 B0#16pmos@42_poly-right##18 9.871
R577 B0#16pmos@42_poly-right##18 B0#16pmos@42_poly-right##19 9.871
R578 B0#16pmos@42_poly-right##19 B0#16pmos@42_poly-right##20 9.871
R579 B0#16pmos@42_poly-right##20 B0#16pmos@42_poly-right##21 9.871
R580 B0#16pmos@42_poly-right##21 B0#16pmos@42_poly-right##22 9.871
R581 B0#16pmos@42_poly-right##22 B0#16pmos@42_poly-right##23 9.871
R582 B0#16pmos@42_poly-right##23 B0#16pmos@42_poly-right##24 9.871
R583 B0#16pmos@42_poly-right##24 B0#16pmos@42_poly-right##25 9.871
R584 B0#16pmos@42_poly-right##25 B0#16pmos@42_poly-right##26 9.871
R585 B0#16pmos@42_poly-right##26 B0#16pmos@42_poly-right##27 9.871
R586 B0#16pmos@42_poly-right##27 B0#16pmos@42_poly-right##28 9.871
R587 B0#16pmos@42_poly-right##28 B0#16pmos@42_poly-right##29 9.871
R588 B0#16pmos@42_poly-right##29 B0#16pmos@42_poly-right##30 9.871
R589 B0#16pmos@42_poly-right##30 B0#16pmos@42_poly-right##31 9.871
R590 B0#16pmos@42_poly-right##31 B0#16pmos@42_poly-right##32 9.871
R591 B0#16pmos@42_poly-right##32 B0#16pmos@42_poly-right##33 9.871
R592 B0#16pmos@42_poly-right##33 B0#16pmos@42_poly-right##34 9.871
R593 B0#16pmos@42_poly-right##34 B0#16pmos@42_poly-right##35 9.871
R594 B0#16pmos@42_poly-right##35 B0#16pmos@42_poly-right##36 9.871
R595 B0#16pmos@42_poly-right##36 B0#16pmos@42_poly-right##37 9.871
R596 B0#16pmos@42_poly-right##37 B0#16pmos@42_poly-right##38 9.871
R597 B0#16pmos@42_poly-right##38 B0#16pmos@42_poly-right##39 9.871
R598 B0#16pmos@42_poly-right##39 B0#16pmos@42_poly-right##40 9.871
R599 B0#16pmos@42_poly-right##40 B0#16pmos@42_poly-right##41 9.871
R600 B0#16pmos@42_poly-right##41 B0#16pmos@42_poly-right##42 9.871
R601 B0#16pmos@42_poly-right##42 B0#16pmos@42_poly-right##43 9.871
R602 B0#16pmos@42_poly-right##43 B0#16pmos@42_poly-right##44 9.871
R603 B0#16pmos@42_poly-right##44 B0#16pmos@42_poly-right##45 9.871
R604 B0#16pmos@42_poly-right##45 B0#16pmos@42_poly-right##46 9.871
R605 B0#16pmos@42_poly-right##46 B0#16pmos@42_poly-right##47 9.871
R606 B0#16pmos@42_poly-right##47 B0#16pmos@42_poly-right##48 9.871
R607 B0#16pmos@42_poly-right##48 B0#16pmos@42_poly-right##49 9.871
R608 B0#16pmos@42_poly-right##49 B0#16pmos@42_poly-right##50 9.871
R609 B0#16pmos@42_poly-right##50 B0#16pmos@42_poly-right##51 9.871
R610 B0#16pmos@42_poly-right##51 B0#16pmos@42_poly-right##52 9.871
R611 B0#16pmos@42_poly-right##52 B0#16pmos@42_poly-right##53 9.871
R612 B0#16pmos@42_poly-right##53 B0#16pmos@42_poly-right##54 9.871
R613 B0#16pmos@42_poly-right##54 B0#16pmos@42_poly-right##55 9.871
R614 B0#16pmos@42_poly-right##55 B0#14nmos@42_poly-left 9.871
R615 net@684#14pmos@43_poly-right net@684#14pmos@43_poly-right##0 9.871
R616 net@684#14pmos@43_poly-right##0 net@684#14pmos@43_poly-right##1 9.871
R617 net@684#14pmos@43_poly-right##1 net@684#14pmos@43_poly-right##2 9.871
R618 net@684#14pmos@43_poly-right##2 net@684#14pmos@43_poly-right##3 9.871
R619 net@684#14pmos@43_poly-right##3 net@684#14pmos@43_poly-right##4 9.871
R620 net@684#14pmos@43_poly-right##4 net@684#14pmos@43_poly-right##5 9.871
R621 net@684#14pmos@43_poly-right##5 net@684#14pmos@43_poly-right##6 9.871
R622 net@684#14pmos@43_poly-right##6 net@684#14pmos@43_poly-right##7 9.871
R623 net@684#14pmos@43_poly-right##7 net@684#14pmos@43_poly-right##8 9.871
R624 net@684#14pmos@43_poly-right##8 net@684#14pmos@43_poly-right##9 9.871
R625 net@684#14pmos@43_poly-right##9 net@684#14pmos@43_poly-right##10 9.871
R626 net@684#14pmos@43_poly-right##10 net@684#14pmos@43_poly-right##11 9.871
R627 net@684#14pmos@43_poly-right##11 net@684#14pmos@43_poly-right##12 9.871
R628 net@684#14pmos@43_poly-right##12 net@684#14pmos@43_poly-right##13 9.871
R629 net@684#14pmos@43_poly-right##13 net@684#14pmos@43_poly-right##14 9.871
R630 net@684#14pmos@43_poly-right##14 net@684#14pmos@43_poly-right##15 9.871
R631 net@684#14pmos@43_poly-right##15 net@684#14pmos@43_poly-right##16 9.871
R632 net@684#14pmos@43_poly-right##16 net@684#14pmos@43_poly-right##17 9.871
R633 net@684#14pmos@43_poly-right##17 net@684#14pmos@43_poly-right##18 9.871
R634 net@684#14pmos@43_poly-right##18 net@684#14pmos@43_poly-right##19 9.871
R635 net@684#14pmos@43_poly-right##19 net@684#14pmos@43_poly-right##20 9.871
R636 net@684#14pmos@43_poly-right##20 net@684#14pmos@43_poly-right##21 9.871
R637 net@684#14pmos@43_poly-right##21 net@684#14pmos@43_poly-right##22 9.871
R638 net@684#14pmos@43_poly-right##22 net@684#14pmos@43_poly-right##23 9.871
R639 net@684#14pmos@43_poly-right##23 net@684#14pmos@43_poly-right##24 9.871
R640 net@684#14pmos@43_poly-right##24 net@684#14pmos@43_poly-right##25 9.871
R641 net@684#14pmos@43_poly-right##25 net@684#14pmos@43_poly-right##26 9.871
R642 net@684#14pmos@43_poly-right##26 net@684#14pmos@43_poly-right##27 9.871
R643 net@684#14pmos@43_poly-right##27 net@684#14pmos@43_poly-right##28 9.871
R644 net@684#14pmos@43_poly-right##28 net@684#14pmos@43_poly-right##29 9.871
R645 net@684#14pmos@43_poly-right##29 net@684#14pmos@43_poly-right##30 9.871
R646 net@684#14pmos@43_poly-right##30 net@684#14pmos@43_poly-right##31 9.871
R647 net@684#14pmos@43_poly-right##31 net@684#14pmos@43_poly-right##32 9.871
R648 net@684#14pmos@43_poly-right##32 net@684#14pmos@43_poly-right##33 9.871
R649 net@684#14pmos@43_poly-right##33 net@684#14pmos@43_poly-right##34 9.871
R650 net@684#14pmos@43_poly-right##34 net@684#14pmos@43_poly-right##35 9.871
R651 net@684#14pmos@43_poly-right##35 net@684#14pmos@43_poly-right##36 9.871
R652 net@684#14pmos@43_poly-right##36 net@684#14pmos@43_poly-right##37 9.871
R653 net@684#14pmos@43_poly-right##37 net@684#14pmos@43_poly-right##38 9.871
R654 net@684#14pmos@43_poly-right##38 net@684#14pmos@43_poly-right##39 9.871
R655 net@684#14pmos@43_poly-right##39 net@684#14pmos@43_poly-right##40 9.871
R656 net@684#14pmos@43_poly-right##40 net@684#14pmos@43_poly-right##41 9.871
R657 net@684#14pmos@43_poly-right##41 net@684#14pmos@43_poly-right##42 9.871
R658 net@684#14pmos@43_poly-right##42 net@684#14pmos@43_poly-right##43 9.871
R659 net@684#14pmos@43_poly-right##43 net@684#14pmos@43_poly-right##44 9.871
R660 net@684#14pmos@43_poly-right##44 net@684#14pmos@43_poly-right##45 9.871
R661 net@684#14pmos@43_poly-right##45 net@684#14pmos@43_poly-right##46 9.871
R662 net@684#14pmos@43_poly-right##46 net@684#14pmos@43_poly-right##47 9.871
R663 net@684#14pmos@43_poly-right##47 net@684#14pmos@43_poly-right##48 9.871
R664 net@684#14pmos@43_poly-right##48 net@684#14pmos@43_poly-right##49 9.871
R665 net@684#14pmos@43_poly-right##49 net@684#14pmos@43_poly-right##50 9.871
R666 net@684#14pmos@43_poly-right##50 net@684#14pmos@43_poly-right##51 9.871
R667 net@684#14pmos@43_poly-right##51 net@684#14pmos@43_poly-right##52 9.871
R668 net@684#14pmos@43_poly-right##52 net@684#14pmos@43_poly-right##53 9.871
R669 net@684#14pmos@43_poly-right##53 net@684#14pmos@43_poly-right##54 9.871
R670 net@684#14pmos@43_poly-right##54 net@684#14pmos@43_poly-right##55 9.871
R671 net@684#14pmos@43_poly-right##55 net@684#9nmos@43_poly-left 9.871
R672 net@676#2contact@256_metal-1-polysilicon-1 net@676 4.706
R673 net@676#12pmos@46_poly-right net@676#12pmos@46_poly-right##0 9.864
R674 net@676#12pmos@46_poly-right##0 net@676#12pmos@46_poly-right##1 9.864
R675 net@676#12pmos@46_poly-right##1 net@676#12pmos@46_poly-right##2 9.864
R676 net@676#12pmos@46_poly-right##2 net@676#12pmos@46_poly-right##3 9.864
R677 net@676#12pmos@46_poly-right##3 net@676#12pmos@46_poly-right##4 9.864
R678 net@676#12pmos@46_poly-right##4 net@676#12pmos@46_poly-right##5 9.864
R679 net@676#12pmos@46_poly-right##5 net@676#12pmos@46_poly-right##6 9.864
R680 net@676#12pmos@46_poly-right##6 net@676#12pmos@46_poly-right##7 9.864
R681 net@676#12pmos@46_poly-right##7 net@676#12pmos@46_poly-right##8 9.864
R682 net@676#12pmos@46_poly-right##8 net@676#12pmos@46_poly-right##9 9.864
R683 net@676#12pmos@46_poly-right##9 net@676#12pmos@46_poly-right##10 9.864
R684 net@676#12pmos@46_poly-right##10 net@676#12pmos@46_poly-right##11 9.864
R685 net@676#12pmos@46_poly-right##11 net@676#12pmos@46_poly-right##12 9.864
R686 net@676#12pmos@46_poly-right##12 net@676#12pmos@46_poly-right##13 9.864
R687 net@676#12pmos@46_poly-right##13 net@676#12pmos@46_poly-right##14 9.864
R688 net@676#12pmos@46_poly-right##14 net@676#12pmos@46_poly-right##15 9.864
R689 net@676#12pmos@46_poly-right##15 net@676#12pmos@46_poly-right##16 9.864
R690 net@676#12pmos@46_poly-right##16 net@676#12pmos@46_poly-right##17 9.864
R691 net@676#12pmos@46_poly-right##17 net@676#12pmos@46_poly-right##18 9.864
R692 net@676#12pmos@46_poly-right##18 net@676#12pmos@46_poly-right##19 9.864
R693 net@676#12pmos@46_poly-right##19 net@676#12pmos@46_poly-right##20 9.864
R694 net@676#12pmos@46_poly-right##20 net@676#12pmos@46_poly-right##21 9.864
R695 net@676#12pmos@46_poly-right##21 net@676#12pmos@46_poly-right##22 9.864
R696 net@676#12pmos@46_poly-right##22 net@676#12pmos@46_poly-right##23 9.864
R697 net@676#12pmos@46_poly-right##23 net@676#12pmos@46_poly-right##24 9.864
R698 net@676#12pmos@46_poly-right##24 net@676#12pmos@46_poly-right##25 9.864
R699 net@676#12pmos@46_poly-right##25 net@676#12pmos@46_poly-right##26 9.864
R700 net@676#12pmos@46_poly-right##26 net@676#12pmos@46_poly-right##27 9.864
R701 net@676#12pmos@46_poly-right##27 net@676#12pmos@46_poly-right##28 9.864
R702 net@676#12pmos@46_poly-right##28 net@676#12pmos@46_poly-right##29 9.864
R703 net@676#12pmos@46_poly-right##29 net@676#12pmos@46_poly-right##30 9.864
R704 net@676#12pmos@46_poly-right##30 net@676#12pmos@46_poly-right##31 9.864
R705 net@676#12pmos@46_poly-right##31 net@676#12pmos@46_poly-right##32 9.864
R706 net@676#12pmos@46_poly-right##32 net@676#12pmos@46_poly-right##33 9.864
R707 net@676#12pmos@46_poly-right##33 net@676#12pmos@46_poly-right##34 9.864
R708 net@676#12pmos@46_poly-right##34 net@676#12pmos@46_poly-right##35 9.864
R709 net@676#12pmos@46_poly-right##35 net@676#12pmos@46_poly-right##36 9.864
R710 net@676#12pmos@46_poly-right##36 net@676#12pmos@46_poly-right##37 9.864
R711 net@676#12pmos@46_poly-right##37 net@676#12pmos@46_poly-right##38 9.864
R712 net@676#12pmos@46_poly-right##38 net@676#12pmos@46_poly-right##39 9.864
R713 net@676#12pmos@46_poly-right##39 net@676#12pmos@46_poly-right##40 9.864
R714 net@676#12pmos@46_poly-right##40 net@676#12pmos@46_poly-right##41 9.864
R715 net@676#12pmos@46_poly-right##41 net@676#12pmos@46_poly-right##42 9.864
R716 net@676#12pmos@46_poly-right##42 net@676#12pmos@46_poly-right##43 9.864
R717 net@676#12pmos@46_poly-right##43 net@676#12pmos@46_poly-right##44 9.864
R718 net@676#12pmos@46_poly-right##44 net@676#12pmos@46_poly-right##45 9.864
R719 net@676#12pmos@46_poly-right##45 net@676#12pmos@46_poly-right##46 9.864
R720 net@676#12pmos@46_poly-right##46 net@676#12pmos@46_poly-right##47 9.864
R721 net@676#12pmos@46_poly-right##47 net@676#12pmos@46_poly-right##48 9.864
R722 net@676#12pmos@46_poly-right##48 net@676#12pmos@46_poly-right##49 9.864
R723 net@676#12pmos@46_poly-right##49 net@676#12pmos@46_poly-right##50 9.864
R724 net@676#12pmos@46_poly-right##50 net@676#12pmos@46_poly-right##51 9.864
R725 net@676#12pmos@46_poly-right##51 net@676#12pmos@46_poly-right##52 9.864
R726 net@676#12pmos@46_poly-right##52 net@676#12pmos@46_poly-right##53 9.864
R727 net@676#12pmos@46_poly-right##53 net@676#5pin@169_polysilicon-1 9.864
R728 XOR1_to_NAND1#22pmos@46_diff-top XOR1_to_NAND1#1contact@309_metal-1-metal-2 4.862
R729 XOR1_to_NAND1#3pin@203_polysilicon-1 XOR1_to_NAND1#3pin@203_polysilicon-1##0 9.881
R730 XOR1_to_NAND1#3pin@203_polysilicon-1##0 XOR1_to_NAND1#3pin@203_polysilicon-1##1 9.881
R731 XOR1_to_NAND1#3pin@203_polysilicon-1##1 XOR1_to_NAND1#3pin@203_polysilicon-1##2 9.881
R732 XOR1_to_NAND1#3pin@203_polysilicon-1##2 XOR1_to_NAND1#3pin@203_polysilicon-1##3 9.881
R733 XOR1_to_NAND1#3pin@203_polysilicon-1##3 XOR1_to_NAND1#3pin@203_polysilicon-1##4 9.881
R734 XOR1_to_NAND1#3pin@203_polysilicon-1##4 XOR1_to_NAND1#3pin@203_polysilicon-1##5 9.881
R735 XOR1_to_NAND1#3pin@203_polysilicon-1##5 XOR1_to_NAND1#3pin@203_polysilicon-1##6 9.881
R736 XOR1_to_NAND1#3pin@203_polysilicon-1##6 XOR1_to_NAND1#3pin@203_polysilicon-1##7 9.881
R737 XOR1_to_NAND1#3pin@203_polysilicon-1##7 XOR1_to_NAND1#3pin@203_polysilicon-1##8 9.881
R738 XOR1_to_NAND1#3pin@203_polysilicon-1##8 XOR1_to_NAND1#3pin@203_polysilicon-1##9 9.881
R739 XOR1_to_NAND1#3pin@203_polysilicon-1##9 XOR1_to_NAND1#3pin@203_polysilicon-1##10 9.881
R740 XOR1_to_NAND1#3pin@203_polysilicon-1##10 XOR1_to_NAND1#3pin@203_polysilicon-1##11 9.881
R741 XOR1_to_NAND1#3pin@203_polysilicon-1##11 XOR1_to_NAND1#3pin@203_polysilicon-1##12 9.881
R742 XOR1_to_NAND1#3pin@203_polysilicon-1##12 XOR1_to_NAND1#3pin@203_polysilicon-1##13 9.881
R743 XOR1_to_NAND1#3pin@203_polysilicon-1##13 XOR1_to_NAND1#3pin@203_polysilicon-1##14 9.881
R744 XOR1_to_NAND1#3pin@203_polysilicon-1##14 XOR1_to_NAND1#3pin@203_polysilicon-1##15 9.881
R745 XOR1_to_NAND1#3pin@203_polysilicon-1##15 XOR1_to_NAND1#3pin@203_polysilicon-1##16 9.881
R746 XOR1_to_NAND1#3pin@203_polysilicon-1##16 XOR1_to_NAND1#3pin@203_polysilicon-1##17 9.881
R747 XOR1_to_NAND1#3pin@203_polysilicon-1##17 XOR1_to_NAND1#3pin@203_polysilicon-1##18 9.881
R748 XOR1_to_NAND1#3pin@203_polysilicon-1##18 XOR1_to_NAND1#3pin@203_polysilicon-1##19 9.881
R749 XOR1_to_NAND1#3pin@203_polysilicon-1##19 XOR1_to_NAND1#3pin@203_polysilicon-1##20 9.881
R750 XOR1_to_NAND1#3pin@203_polysilicon-1##20 XOR1_to_NAND1#3pin@203_polysilicon-1##21 9.881
R751 XOR1_to_NAND1#3pin@203_polysilicon-1##21 XOR1_to_NAND1#3pin@203_polysilicon-1##22 9.881
R752 XOR1_to_NAND1#3pin@203_polysilicon-1##22 XOR1_to_NAND1#3pin@203_polysilicon-1##23 9.881
R753 XOR1_to_NAND1#3pin@203_polysilicon-1##23 XOR1_to_NAND1#3pin@203_polysilicon-1##24 9.881
R754 XOR1_to_NAND1#3pin@203_polysilicon-1##24 XOR1_to_NAND1#3pin@203_polysilicon-1##25 9.881
R755 XOR1_to_NAND1#3pin@203_polysilicon-1##25 XOR1_to_NAND1#3pin@203_polysilicon-1##26 9.881
R756 XOR1_to_NAND1#3pin@203_polysilicon-1##26 XOR1_to_NAND1#3pin@203_polysilicon-1##27 9.881
R757 XOR1_to_NAND1#3pin@203_polysilicon-1##27 XOR1_to_NAND1#3pin@203_polysilicon-1##28 9.881
R758 XOR1_to_NAND1#3pin@203_polysilicon-1##28 XOR1_to_NAND1#3pin@203_polysilicon-1##29 9.881
R759 XOR1_to_NAND1#3pin@203_polysilicon-1##29 XOR1_to_NAND1#3pin@203_polysilicon-1##30 9.881
R760 XOR1_to_NAND1#3pin@203_polysilicon-1##30 XOR1_to_NAND1#3pin@203_polysilicon-1##31 9.881
R761 XOR1_to_NAND1#3pin@203_polysilicon-1##31 XOR1_to_NAND1#3pin@203_polysilicon-1##32 9.881
R762 XOR1_to_NAND1#3pin@203_polysilicon-1##32 XOR1_to_NAND1#3pin@203_polysilicon-1##33 9.881
R763 XOR1_to_NAND1#3pin@203_polysilicon-1##33 XOR1_to_NAND1#3pin@203_polysilicon-1##34 9.881
R764 XOR1_to_NAND1#3pin@203_polysilicon-1##34 XOR1_to_NAND1#3pin@203_polysilicon-1##35 9.881
R765 XOR1_to_NAND1#3pin@203_polysilicon-1##35 XOR1_to_NAND1#3pin@203_polysilicon-1##36 9.881
R766 XOR1_to_NAND1#3pin@203_polysilicon-1##36 XOR1_to_NAND1#3pin@203_polysilicon-1##37 9.881
R767 XOR1_to_NAND1#3pin@203_polysilicon-1##37 XOR1_to_NAND1#3pin@203_polysilicon-1##38 9.881
R768 XOR1_to_NAND1#3pin@203_polysilicon-1##38 XOR1_to_NAND1#3pin@203_polysilicon-1##39 9.881
R769 XOR1_to_NAND1#3pin@203_polysilicon-1##39 XOR1_to_NAND1#3pin@203_polysilicon-1##40 9.881
R770 XOR1_to_NAND1#3pin@203_polysilicon-1##40 XOR1_to_NAND1#3pin@203_polysilicon-1##41 9.881
R771 XOR1_to_NAND1#3pin@203_polysilicon-1##41 XOR1_to_NAND1#3pin@203_polysilicon-1##42 9.881
R772 XOR1_to_NAND1#3pin@203_polysilicon-1##42 XOR1_to_NAND1#3pin@203_polysilicon-1##43 9.881
R773 XOR1_to_NAND1#3pin@203_polysilicon-1##43 XOR1_to_NAND1#3pin@203_polysilicon-1##44 9.881
R774 XOR1_to_NAND1#3pin@203_polysilicon-1##44 XOR1_to_NAND1#3pin@203_polysilicon-1##45 9.881
R775 XOR1_to_NAND1#3pin@203_polysilicon-1##45 XOR1_to_NAND1#3pin@203_polysilicon-1##46 9.881
R776 XOR1_to_NAND1#3pin@203_polysilicon-1##46 XOR1_to_NAND1#3pin@203_polysilicon-1##47 9.881
R777 XOR1_to_NAND1#3pin@203_polysilicon-1##47 XOR1_to_NAND1#3pin@203_polysilicon-1##48 9.881
R778 XOR1_to_NAND1#3pin@203_polysilicon-1##48 XOR1_to_NAND1#3pin@203_polysilicon-1##49 9.881
R779 XOR1_to_NAND1#3pin@203_polysilicon-1##49 XOR1_to_NAND1#3pin@203_polysilicon-1##50 9.881
R780 XOR1_to_NAND1#3pin@203_polysilicon-1##50 XOR1_to_NAND1#3pin@203_polysilicon-1##51 9.881
R781 XOR1_to_NAND1#3pin@203_polysilicon-1##51 XOR1_to_NAND1#3pin@203_polysilicon-1##52 9.881
R782 XOR1_to_NAND1#3pin@203_polysilicon-1##52 XOR1_to_NAND1#3pin@203_polysilicon-1##53 9.881
R783 XOR1_to_NAND1#3pin@203_polysilicon-1##53 XOR1_to_NAND1#3pin@203_polysilicon-1##54 9.881
R784 XOR1_to_NAND1#3pin@203_polysilicon-1##54 XOR1_to_NAND1#24nmos@52_poly-right 9.881
R785 net@564#5pmos@52_diff-top net@564#2pin@192_metal-1 4.81
R786 net@564#1pin@202_polysilicon-1 net@564#1pin@202_polysilicon-1##0 9.85
R787 net@564#1pin@202_polysilicon-1##0 net@564#1pin@202_polysilicon-1##1 9.85
R788 net@564#1pin@202_polysilicon-1##1 net@564#1pin@202_polysilicon-1##2 9.85
R789 net@564#1pin@202_polysilicon-1##2 net@564#1pin@202_polysilicon-1##3 9.85
R790 net@564#1pin@202_polysilicon-1##3 net@564#1pin@202_polysilicon-1##4 9.85
R791 net@564#1pin@202_polysilicon-1##4 net@564#1pin@202_polysilicon-1##5 9.85
R792 net@564#1pin@202_polysilicon-1##5 net@564#1pin@202_polysilicon-1##6 9.85
R793 net@564#1pin@202_polysilicon-1##6 net@564#1pin@202_polysilicon-1##7 9.85
R794 net@564#1pin@202_polysilicon-1##7 net@564#1pin@202_polysilicon-1##8 9.85
R795 net@564#1pin@202_polysilicon-1##8 net@564#1pin@202_polysilicon-1##9 9.85
R796 net@564#1pin@202_polysilicon-1##9 net@564#1pin@202_polysilicon-1##10 9.85
R797 net@564#1pin@202_polysilicon-1##10 net@564#1pin@202_polysilicon-1##11 9.85
R798 net@564#1pin@202_polysilicon-1##11 net@564#1pin@202_polysilicon-1##12 9.85
R799 net@564#1pin@202_polysilicon-1##12 net@564#1pin@202_polysilicon-1##13 9.85
R800 net@564#1pin@202_polysilicon-1##13 net@564#1pin@202_polysilicon-1##14 9.85
R801 net@564#1pin@202_polysilicon-1##14 net@564#1pin@202_polysilicon-1##15 9.85
R802 net@564#1pin@202_polysilicon-1##15 net@564#1pin@202_polysilicon-1##16 9.85
R803 net@564#1pin@202_polysilicon-1##16 net@564#1pin@202_polysilicon-1##17 9.85
R804 net@564#1pin@202_polysilicon-1##17 net@564#1pin@202_polysilicon-1##18 9.85
R805 net@564#1pin@202_polysilicon-1##18 net@564#1pin@202_polysilicon-1##19 9.85
R806 net@564#1pin@202_polysilicon-1##19 net@564#1pin@202_polysilicon-1##20 9.85
R807 net@564#1pin@202_polysilicon-1##20 net@564#1pin@202_polysilicon-1##21 9.85
R808 net@564#1pin@202_polysilicon-1##21 net@564#1pin@202_polysilicon-1##22 9.85
R809 net@564#1pin@202_polysilicon-1##22 net@564#1pin@202_polysilicon-1##23 9.85
R810 net@564#1pin@202_polysilicon-1##23 net@564#1pin@202_polysilicon-1##24 9.85
R811 net@564#1pin@202_polysilicon-1##24 net@564#1pin@202_polysilicon-1##25 9.85
R812 net@564#1pin@202_polysilicon-1##25 net@564#1pin@202_polysilicon-1##26 9.85
R813 net@564#1pin@202_polysilicon-1##26 net@564#1pin@202_polysilicon-1##27 9.85
R814 net@564#1pin@202_polysilicon-1##27 net@564#1pin@202_polysilicon-1##28 9.85
R815 net@564#1pin@202_polysilicon-1##28 net@564#1pin@202_polysilicon-1##29 9.85
R816 net@564#1pin@202_polysilicon-1##29 net@564#1pin@202_polysilicon-1##30 9.85
R817 net@564#1pin@202_polysilicon-1##30 net@564#1pin@202_polysilicon-1##31 9.85
R818 net@564#1pin@202_polysilicon-1##31 net@564#1pin@202_polysilicon-1##32 9.85
R819 net@564#1pin@202_polysilicon-1##32 net@564#1pin@202_polysilicon-1##33 9.85
R820 net@564#1pin@202_polysilicon-1##33 net@564#1pin@202_polysilicon-1##34 9.85
R821 net@564#1pin@202_polysilicon-1##34 net@564#1pin@202_polysilicon-1##35 9.85
R822 net@564#1pin@202_polysilicon-1##35 net@564#1pin@202_polysilicon-1##36 9.85
R823 net@564#1pin@202_polysilicon-1##36 net@564#1pin@202_polysilicon-1##37 9.85
R824 net@564#1pin@202_polysilicon-1##37 net@564#1pin@202_polysilicon-1##38 9.85
R825 net@564#1pin@202_polysilicon-1##38 net@564#1pin@202_polysilicon-1##39 9.85
R826 net@564#1pin@202_polysilicon-1##39 net@564#1pin@202_polysilicon-1##40 9.85
R827 net@564#1pin@202_polysilicon-1##40 net@564#1pin@202_polysilicon-1##41 9.85
R828 net@564#1pin@202_polysilicon-1##41 net@564#1pin@202_polysilicon-1##42 9.85
R829 net@564#1pin@202_polysilicon-1##42 net@564#1pin@202_polysilicon-1##43 9.85
R830 net@564#1pin@202_polysilicon-1##43 net@564#1pin@202_polysilicon-1##44 9.85
R831 net@564#1pin@202_polysilicon-1##44 net@564#1pin@202_polysilicon-1##45 9.85
R832 net@564#1pin@202_polysilicon-1##45 net@564#1pin@202_polysilicon-1##46 9.85
R833 net@564#1pin@202_polysilicon-1##46 net@564#1pin@202_polysilicon-1##47 9.85
R834 net@564#1pin@202_polysilicon-1##47 net@564#1pin@202_polysilicon-1##48 9.85
R835 net@564#1pin@202_polysilicon-1##48 net@564#1pin@202_polysilicon-1##49 9.85
R836 net@564#1pin@202_polysilicon-1##49 net@564#1pin@202_polysilicon-1##50 9.85
R837 net@564#1pin@202_polysilicon-1##50 net@564#1pin@202_polysilicon-1##51 9.85
R838 net@564#1pin@202_polysilicon-1##51 net@564#1pin@202_polysilicon-1##52 9.85
R839 net@564#1pin@202_polysilicon-1##52 net@564#1pin@202_polysilicon-1##53 9.85
R840 net@564#1pin@202_polysilicon-1##53 net@564#1pin@202_polysilicon-1##54 9.85
R841 net@564#1pin@202_polysilicon-1##54 net@564#1pin@202_polysilicon-1##55 9.85
R842 net@564#1pin@202_polysilicon-1##55 net@564#1pin@202_polysilicon-1##56 9.85
R843 net@564#1pin@202_polysilicon-1##56 net@564#1pin@202_polysilicon-1##57 9.85
R844 net@564#1pin@202_polysilicon-1##57 net@564#1pin@202_polysilicon-1##58 9.85
R845 net@564#1pin@202_polysilicon-1##58 net@564#1pin@202_polysilicon-1##59 9.85
R846 net@564#1pin@202_polysilicon-1##59 net@564#1pin@202_polysilicon-1##60 9.85
R847 net@564#1pin@202_polysilicon-1##60 net@564#2pin@192_metal-1 9.85
R848 Cin#17pmos@51_poly-right Cin#17pmos@51_poly-right##0 9.854
R849 Cin#17pmos@51_poly-right##0 Cin#17pmos@51_poly-right##1 9.854
R850 Cin#17pmos@51_poly-right##1 Cin#17pmos@51_poly-right##2 9.854
R851 Cin#17pmos@51_poly-right##2 Cin#17pmos@51_poly-right##3 9.854
R852 Cin#17pmos@51_poly-right##3 Cin#17pmos@51_poly-right##4 9.854
R853 Cin#17pmos@51_poly-right##4 Cin#17pmos@51_poly-right##5 9.854
R854 Cin#17pmos@51_poly-right##5 Cin#17pmos@51_poly-right##6 9.854
R855 Cin#17pmos@51_poly-right##6 Cin#17pmos@51_poly-right##7 9.854
R856 Cin#17pmos@51_poly-right##7 Cin#17pmos@51_poly-right##8 9.854
R857 Cin#17pmos@51_poly-right##8 Cin#17pmos@51_poly-right##9 9.854
R858 Cin#17pmos@51_poly-right##9 Cin#17pmos@51_poly-right##10 9.854
R859 Cin#17pmos@51_poly-right##10 Cin#17pmos@51_poly-right##11 9.854
R860 Cin#17pmos@51_poly-right##11 Cin#17pmos@51_poly-right##12 9.854
R861 Cin#17pmos@51_poly-right##12 Cin#17pmos@51_poly-right##13 9.854
R862 Cin#17pmos@51_poly-right##13 Cin#17pmos@51_poly-right##14 9.854
R863 Cin#17pmos@51_poly-right##14 Cin#17pmos@51_poly-right##15 9.854
R864 Cin#17pmos@51_poly-right##15 Cin#17pmos@51_poly-right##16 9.854
R865 Cin#17pmos@51_poly-right##16 Cin#17pmos@51_poly-right##17 9.854
R866 Cin#17pmos@51_poly-right##17 Cin#17pmos@51_poly-right##18 9.854
R867 Cin#17pmos@51_poly-right##18 Cin#17pmos@51_poly-right##19 9.854
R868 Cin#17pmos@51_poly-right##19 Cin#17pmos@51_poly-right##20 9.854
R869 Cin#17pmos@51_poly-right##20 Cin#17pmos@51_poly-right##21 9.854
R870 Cin#17pmos@51_poly-right##21 Cin#17pmos@51_poly-right##22 9.854
R871 Cin#17pmos@51_poly-right##22 Cin#17pmos@51_poly-right##23 9.854
R872 Cin#17pmos@51_poly-right##23 Cin#17pmos@51_poly-right##24 9.854
R873 Cin#17pmos@51_poly-right##24 Cin#17pmos@51_poly-right##25 9.854
R874 Cin#17pmos@51_poly-right##25 Cin#17pmos@51_poly-right##26 9.854
R875 Cin#17pmos@51_poly-right##26 Cin#17pmos@51_poly-right##27 9.854
R876 Cin#17pmos@51_poly-right##27 Cin#17pmos@51_poly-right##28 9.854
R877 Cin#17pmos@51_poly-right##28 Cin#17pmos@51_poly-right##29 9.854
R878 Cin#17pmos@51_poly-right##29 Cin#17pmos@51_poly-right##30 9.854
R879 Cin#17pmos@51_poly-right##30 Cin#17pmos@51_poly-right##31 9.854
R880 Cin#17pmos@51_poly-right##31 Cin#17pmos@51_poly-right##32 9.854
R881 Cin#17pmos@51_poly-right##32 Cin#17pmos@51_poly-right##33 9.854
R882 Cin#17pmos@51_poly-right##33 Cin#17pmos@51_poly-right##34 9.854
R883 Cin#17pmos@51_poly-right##34 Cin#17pmos@51_poly-right##35 9.854
R884 Cin#17pmos@51_poly-right##35 Cin#17pmos@51_poly-right##36 9.854
R885 Cin#17pmos@51_poly-right##36 Cin#17pmos@51_poly-right##37 9.854
R886 Cin#17pmos@51_poly-right##37 Cin#17pmos@51_poly-right##38 9.854
R887 Cin#17pmos@51_poly-right##38 Cin#17pmos@51_poly-right##39 9.854
R888 Cin#17pmos@51_poly-right##39 Cin#17pmos@51_poly-right##40 9.854
R889 Cin#17pmos@51_poly-right##40 Cin#17pmos@51_poly-right##41 9.854
R890 Cin#17pmos@51_poly-right##41 Cin#17pmos@51_poly-right##42 9.854
R891 Cin#17pmos@51_poly-right##42 Cin#17pmos@51_poly-right##43 9.854
R892 Cin#17pmos@51_poly-right##43 Cin#17pmos@51_poly-right##44 9.854
R893 Cin#17pmos@51_poly-right##44 Cin#17pmos@51_poly-right##45 9.854
R894 Cin#17pmos@51_poly-right##45 Cin#17pmos@51_poly-right##46 9.854
R895 Cin#17pmos@51_poly-right##46 Cin#17pmos@51_poly-right##47 9.854
R896 Cin#17pmos@51_poly-right##47 Cin#17pmos@51_poly-right##48 9.854
R897 Cin#17pmos@51_poly-right##48 Cin#17pmos@51_poly-right##49 9.854
R898 Cin#17pmos@51_poly-right##49 Cin#17pmos@51_poly-right##50 9.854
R899 Cin#17pmos@51_poly-right##50 Cin#17pmos@51_poly-right##51 9.854
R900 Cin#17pmos@51_poly-right##51 Cin#17pmos@51_poly-right##52 9.854
R901 Cin#17pmos@51_poly-right##52 Cin#17pmos@51_poly-right##53 9.854
R902 Cin#17pmos@51_poly-right##53 Cin#17pmos@51_poly-right##54 9.854
R903 Cin#17pmos@51_poly-right##54 Cin#6pin@193_polysilicon-1 9.854
R904 net@577 net@577#2contact@270_metal-1-metal-2 4.797
R905 XOR1_to_NAND1#9pmos@47_poly-left XOR1_to_NAND1#9pmos@47_poly-left##0 9.871
R906 XOR1_to_NAND1#9pmos@47_poly-left##0 XOR1_to_NAND1#9pmos@47_poly-left##1 9.871
R907 XOR1_to_NAND1#9pmos@47_poly-left##1 XOR1_to_NAND1#9pmos@47_poly-left##2 9.871
R908 XOR1_to_NAND1#9pmos@47_poly-left##2 XOR1_to_NAND1#9pmos@47_poly-left##3 9.871
R909 XOR1_to_NAND1#9pmos@47_poly-left##3 XOR1_to_NAND1#9pmos@47_poly-left##4 9.871
R910 XOR1_to_NAND1#9pmos@47_poly-left##4 XOR1_to_NAND1#9pmos@47_poly-left##5 9.871
R911 XOR1_to_NAND1#9pmos@47_poly-left##5 XOR1_to_NAND1#9pmos@47_poly-left##6 9.871
R912 XOR1_to_NAND1#9pmos@47_poly-left##6 XOR1_to_NAND1#9pmos@47_poly-left##7 9.871
R913 XOR1_to_NAND1#9pmos@47_poly-left##7 XOR1_to_NAND1#9pmos@47_poly-left##8 9.871
R914 XOR1_to_NAND1#9pmos@47_poly-left##8 XOR1_to_NAND1#9pmos@47_poly-left##9 9.871
R915 XOR1_to_NAND1#9pmos@47_poly-left##9 XOR1_to_NAND1#9pmos@47_poly-left##10 9.871
R916 XOR1_to_NAND1#9pmos@47_poly-left##10 XOR1_to_NAND1#9pmos@47_poly-left##11 9.871
R917 XOR1_to_NAND1#9pmos@47_poly-left##11 XOR1_to_NAND1#9pmos@47_poly-left##12 9.871
R918 XOR1_to_NAND1#9pmos@47_poly-left##12 XOR1_to_NAND1#9pmos@47_poly-left##13 9.871
R919 XOR1_to_NAND1#9pmos@47_poly-left##13 XOR1_to_NAND1#9pmos@47_poly-left##14 9.871
R920 XOR1_to_NAND1#9pmos@47_poly-left##14 XOR1_to_NAND1#9pmos@47_poly-left##15 9.871
R921 XOR1_to_NAND1#9pmos@47_poly-left##15 XOR1_to_NAND1#9pmos@47_poly-left##16 9.871
R922 XOR1_to_NAND1#9pmos@47_poly-left##16 XOR1_to_NAND1#9pmos@47_poly-left##17 9.871
R923 XOR1_to_NAND1#9pmos@47_poly-left##17 XOR1_to_NAND1#9pmos@47_poly-left##18 9.871
R924 XOR1_to_NAND1#9pmos@47_poly-left##18 XOR1_to_NAND1#9pmos@47_poly-left##19 9.871
R925 XOR1_to_NAND1#9pmos@47_poly-left##19 XOR1_to_NAND1#9pmos@47_poly-left##20 9.871
R926 XOR1_to_NAND1#9pmos@47_poly-left##20 XOR1_to_NAND1#9pmos@47_poly-left##21 9.871
R927 XOR1_to_NAND1#9pmos@47_poly-left##21 XOR1_to_NAND1#9pmos@47_poly-left##22 9.871
R928 XOR1_to_NAND1#9pmos@47_poly-left##22 XOR1_to_NAND1#9pmos@47_poly-left##23 9.871
R929 XOR1_to_NAND1#9pmos@47_poly-left##23 XOR1_to_NAND1#9pmos@47_poly-left##24 9.871
R930 XOR1_to_NAND1#9pmos@47_poly-left##24 XOR1_to_NAND1#9pmos@47_poly-left##25 9.871
R931 XOR1_to_NAND1#9pmos@47_poly-left##25 XOR1_to_NAND1#9pmos@47_poly-left##26 9.871
R932 XOR1_to_NAND1#9pmos@47_poly-left##26 XOR1_to_NAND1#9pmos@47_poly-left##27 9.871
R933 XOR1_to_NAND1#9pmos@47_poly-left##27 XOR1_to_NAND1#9pmos@47_poly-left##28 9.871
R934 XOR1_to_NAND1#9pmos@47_poly-left##28 XOR1_to_NAND1#9pmos@47_poly-left##29 9.871
R935 XOR1_to_NAND1#9pmos@47_poly-left##29 XOR1_to_NAND1#9pmos@47_poly-left##30 9.871
R936 XOR1_to_NAND1#9pmos@47_poly-left##30 XOR1_to_NAND1#9pmos@47_poly-left##31 9.871
R937 XOR1_to_NAND1#9pmos@47_poly-left##31 XOR1_to_NAND1#9pmos@47_poly-left##32 9.871
R938 XOR1_to_NAND1#9pmos@47_poly-left##32 XOR1_to_NAND1#9pmos@47_poly-left##33 9.871
R939 XOR1_to_NAND1#9pmos@47_poly-left##33 XOR1_to_NAND1#9pmos@47_poly-left##34 9.871
R940 XOR1_to_NAND1#9pmos@47_poly-left##34 XOR1_to_NAND1#9pmos@47_poly-left##35 9.871
R941 XOR1_to_NAND1#9pmos@47_poly-left##35 XOR1_to_NAND1#9pmos@47_poly-left##36 9.871
R942 XOR1_to_NAND1#9pmos@47_poly-left##36 XOR1_to_NAND1#9pmos@47_poly-left##37 9.871
R943 XOR1_to_NAND1#9pmos@47_poly-left##37 XOR1_to_NAND1#9pmos@47_poly-left##38 9.871
R944 XOR1_to_NAND1#9pmos@47_poly-left##38 XOR1_to_NAND1#9pmos@47_poly-left##39 9.871
R945 XOR1_to_NAND1#9pmos@47_poly-left##39 XOR1_to_NAND1#9pmos@47_poly-left##40 9.871
R946 XOR1_to_NAND1#9pmos@47_poly-left##40 XOR1_to_NAND1#9pmos@47_poly-left##41 9.871
R947 XOR1_to_NAND1#9pmos@47_poly-left##41 XOR1_to_NAND1#9pmos@47_poly-left##42 9.871
R948 XOR1_to_NAND1#9pmos@47_poly-left##42 XOR1_to_NAND1#9pmos@47_poly-left##43 9.871
R949 XOR1_to_NAND1#9pmos@47_poly-left##43 XOR1_to_NAND1#9pmos@47_poly-left##44 9.871
R950 XOR1_to_NAND1#9pmos@47_poly-left##44 XOR1_to_NAND1#9pmos@47_poly-left##45 9.871
R951 XOR1_to_NAND1#9pmos@47_poly-left##45 XOR1_to_NAND1#9pmos@47_poly-left##46 9.871
R952 XOR1_to_NAND1#9pmos@47_poly-left##46 XOR1_to_NAND1#9pmos@47_poly-left##47 9.871
R953 XOR1_to_NAND1#9pmos@47_poly-left##47 XOR1_to_NAND1#9pmos@47_poly-left##48 9.871
R954 XOR1_to_NAND1#9pmos@47_poly-left##48 XOR1_to_NAND1#9pmos@47_poly-left##49 9.871
R955 XOR1_to_NAND1#9pmos@47_poly-left##49 XOR1_to_NAND1#9pmos@47_poly-left##50 9.871
R956 XOR1_to_NAND1#9pmos@47_poly-left##50 XOR1_to_NAND1#9pmos@47_poly-left##51 9.871
R957 XOR1_to_NAND1#9pmos@47_poly-left##51 XOR1_to_NAND1#9pmos@47_poly-left##52 9.871
R958 XOR1_to_NAND1#9pmos@47_poly-left##52 XOR1_to_NAND1#9pmos@47_poly-left##53 9.871
R959 XOR1_to_NAND1#9pmos@47_poly-left##53 XOR1_to_NAND1#9pmos@47_poly-left##54 9.871
R960 XOR1_to_NAND1#9pmos@47_poly-left##54 XOR1_to_NAND1#9pmos@47_poly-left##55 9.871
R961 XOR1_to_NAND1#9pmos@47_poly-left##55 XOR1_to_NAND1#26nmos@47_poly-right 9.871
R962 net@564#7pmos@48_poly-left net@564#7pmos@48_poly-left##0 9.871
R963 net@564#7pmos@48_poly-left##0 net@564#7pmos@48_poly-left##1 9.871
R964 net@564#7pmos@48_poly-left##1 net@564#7pmos@48_poly-left##2 9.871
R965 net@564#7pmos@48_poly-left##2 net@564#7pmos@48_poly-left##3 9.871
R966 net@564#7pmos@48_poly-left##3 net@564#7pmos@48_poly-left##4 9.871
R967 net@564#7pmos@48_poly-left##4 net@564#7pmos@48_poly-left##5 9.871
R968 net@564#7pmos@48_poly-left##5 net@564#7pmos@48_poly-left##6 9.871
R969 net@564#7pmos@48_poly-left##6 net@564#7pmos@48_poly-left##7 9.871
R970 net@564#7pmos@48_poly-left##7 net@564#7pmos@48_poly-left##8 9.871
R971 net@564#7pmos@48_poly-left##8 net@564#7pmos@48_poly-left##9 9.871
R972 net@564#7pmos@48_poly-left##9 net@564#7pmos@48_poly-left##10 9.871
R973 net@564#7pmos@48_poly-left##10 net@564#7pmos@48_poly-left##11 9.871
R974 net@564#7pmos@48_poly-left##11 net@564#7pmos@48_poly-left##12 9.871
R975 net@564#7pmos@48_poly-left##12 net@564#7pmos@48_poly-left##13 9.871
R976 net@564#7pmos@48_poly-left##13 net@564#7pmos@48_poly-left##14 9.871
R977 net@564#7pmos@48_poly-left##14 net@564#7pmos@48_poly-left##15 9.871
R978 net@564#7pmos@48_poly-left##15 net@564#7pmos@48_poly-left##16 9.871
R979 net@564#7pmos@48_poly-left##16 net@564#7pmos@48_poly-left##17 9.871
R980 net@564#7pmos@48_poly-left##17 net@564#7pmos@48_poly-left##18 9.871
R981 net@564#7pmos@48_poly-left##18 net@564#7pmos@48_poly-left##19 9.871
R982 net@564#7pmos@48_poly-left##19 net@564#7pmos@48_poly-left##20 9.871
R983 net@564#7pmos@48_poly-left##20 net@564#7pmos@48_poly-left##21 9.871
R984 net@564#7pmos@48_poly-left##21 net@564#7pmos@48_poly-left##22 9.871
R985 net@564#7pmos@48_poly-left##22 net@564#7pmos@48_poly-left##23 9.871
R986 net@564#7pmos@48_poly-left##23 net@564#7pmos@48_poly-left##24 9.871
R987 net@564#7pmos@48_poly-left##24 net@564#7pmos@48_poly-left##25 9.871
R988 net@564#7pmos@48_poly-left##25 net@564#7pmos@48_poly-left##26 9.871
R989 net@564#7pmos@48_poly-left##26 net@564#7pmos@48_poly-left##27 9.871
R990 net@564#7pmos@48_poly-left##27 net@564#7pmos@48_poly-left##28 9.871
R991 net@564#7pmos@48_poly-left##28 net@564#7pmos@48_poly-left##29 9.871
R992 net@564#7pmos@48_poly-left##29 net@564#7pmos@48_poly-left##30 9.871
R993 net@564#7pmos@48_poly-left##30 net@564#7pmos@48_poly-left##31 9.871
R994 net@564#7pmos@48_poly-left##31 net@564#7pmos@48_poly-left##32 9.871
R995 net@564#7pmos@48_poly-left##32 net@564#7pmos@48_poly-left##33 9.871
R996 net@564#7pmos@48_poly-left##33 net@564#7pmos@48_poly-left##34 9.871
R997 net@564#7pmos@48_poly-left##34 net@564#7pmos@48_poly-left##35 9.871
R998 net@564#7pmos@48_poly-left##35 net@564#7pmos@48_poly-left##36 9.871
R999 net@564#7pmos@48_poly-left##36 net@564#7pmos@48_poly-left##37 9.871
R1000 net@564#7pmos@48_poly-left##37 net@564#7pmos@48_poly-left##38 9.871
R1001 net@564#7pmos@48_poly-left##38 net@564#7pmos@48_poly-left##39 9.871
R1002 net@564#7pmos@48_poly-left##39 net@564#7pmos@48_poly-left##40 9.871
R1003 net@564#7pmos@48_poly-left##40 net@564#7pmos@48_poly-left##41 9.871
R1004 net@564#7pmos@48_poly-left##41 net@564#7pmos@48_poly-left##42 9.871
R1005 net@564#7pmos@48_poly-left##42 net@564#7pmos@48_poly-left##43 9.871
R1006 net@564#7pmos@48_poly-left##43 net@564#7pmos@48_poly-left##44 9.871
R1007 net@564#7pmos@48_poly-left##44 net@564#7pmos@48_poly-left##45 9.871
R1008 net@564#7pmos@48_poly-left##45 net@564#7pmos@48_poly-left##46 9.871
R1009 net@564#7pmos@48_poly-left##46 net@564#7pmos@48_poly-left##47 9.871
R1010 net@564#7pmos@48_poly-left##47 net@564#7pmos@48_poly-left##48 9.871
R1011 net@564#7pmos@48_poly-left##48 net@564#7pmos@48_poly-left##49 9.871
R1012 net@564#7pmos@48_poly-left##49 net@564#7pmos@48_poly-left##50 9.871
R1013 net@564#7pmos@48_poly-left##50 net@564#7pmos@48_poly-left##51 9.871
R1014 net@564#7pmos@48_poly-left##51 net@564#7pmos@48_poly-left##52 9.871
R1015 net@564#7pmos@48_poly-left##52 net@564#7pmos@48_poly-left##53 9.871
R1016 net@564#7pmos@48_poly-left##53 net@564#7pmos@48_poly-left##54 9.871
R1017 net@564#7pmos@48_poly-left##54 net@564#7pmos@48_poly-left##55 9.871
R1018 net@564#7pmos@48_poly-left##55 net@564#11nmos@48_poly-right 9.871
R1019 Cin#18pmos@49_poly-right Cin#18pmos@49_poly-right##0 9.871
R1020 Cin#18pmos@49_poly-right##0 Cin#18pmos@49_poly-right##1 9.871
R1021 Cin#18pmos@49_poly-right##1 Cin#18pmos@49_poly-right##2 9.871
R1022 Cin#18pmos@49_poly-right##2 Cin#18pmos@49_poly-right##3 9.871
R1023 Cin#18pmos@49_poly-right##3 Cin#18pmos@49_poly-right##4 9.871
R1024 Cin#18pmos@49_poly-right##4 Cin#18pmos@49_poly-right##5 9.871
R1025 Cin#18pmos@49_poly-right##5 Cin#18pmos@49_poly-right##6 9.871
R1026 Cin#18pmos@49_poly-right##6 Cin#18pmos@49_poly-right##7 9.871
R1027 Cin#18pmos@49_poly-right##7 Cin#18pmos@49_poly-right##8 9.871
R1028 Cin#18pmos@49_poly-right##8 Cin#18pmos@49_poly-right##9 9.871
R1029 Cin#18pmos@49_poly-right##9 Cin#18pmos@49_poly-right##10 9.871
R1030 Cin#18pmos@49_poly-right##10 Cin#18pmos@49_poly-right##11 9.871
R1031 Cin#18pmos@49_poly-right##11 Cin#18pmos@49_poly-right##12 9.871
R1032 Cin#18pmos@49_poly-right##12 Cin#18pmos@49_poly-right##13 9.871
R1033 Cin#18pmos@49_poly-right##13 Cin#18pmos@49_poly-right##14 9.871
R1034 Cin#18pmos@49_poly-right##14 Cin#18pmos@49_poly-right##15 9.871
R1035 Cin#18pmos@49_poly-right##15 Cin#18pmos@49_poly-right##16 9.871
R1036 Cin#18pmos@49_poly-right##16 Cin#18pmos@49_poly-right##17 9.871
R1037 Cin#18pmos@49_poly-right##17 Cin#18pmos@49_poly-right##18 9.871
R1038 Cin#18pmos@49_poly-right##18 Cin#18pmos@49_poly-right##19 9.871
R1039 Cin#18pmos@49_poly-right##19 Cin#18pmos@49_poly-right##20 9.871
R1040 Cin#18pmos@49_poly-right##20 Cin#18pmos@49_poly-right##21 9.871
R1041 Cin#18pmos@49_poly-right##21 Cin#18pmos@49_poly-right##22 9.871
R1042 Cin#18pmos@49_poly-right##22 Cin#18pmos@49_poly-right##23 9.871
R1043 Cin#18pmos@49_poly-right##23 Cin#18pmos@49_poly-right##24 9.871
R1044 Cin#18pmos@49_poly-right##24 Cin#18pmos@49_poly-right##25 9.871
R1045 Cin#18pmos@49_poly-right##25 Cin#18pmos@49_poly-right##26 9.871
R1046 Cin#18pmos@49_poly-right##26 Cin#18pmos@49_poly-right##27 9.871
R1047 Cin#18pmos@49_poly-right##27 Cin#18pmos@49_poly-right##28 9.871
R1048 Cin#18pmos@49_poly-right##28 Cin#18pmos@49_poly-right##29 9.871
R1049 Cin#18pmos@49_poly-right##29 Cin#18pmos@49_poly-right##30 9.871
R1050 Cin#18pmos@49_poly-right##30 Cin#18pmos@49_poly-right##31 9.871
R1051 Cin#18pmos@49_poly-right##31 Cin#18pmos@49_poly-right##32 9.871
R1052 Cin#18pmos@49_poly-right##32 Cin#18pmos@49_poly-right##33 9.871
R1053 Cin#18pmos@49_poly-right##33 Cin#18pmos@49_poly-right##34 9.871
R1054 Cin#18pmos@49_poly-right##34 Cin#18pmos@49_poly-right##35 9.871
R1055 Cin#18pmos@49_poly-right##35 Cin#18pmos@49_poly-right##36 9.871
R1056 Cin#18pmos@49_poly-right##36 Cin#18pmos@49_poly-right##37 9.871
R1057 Cin#18pmos@49_poly-right##37 Cin#18pmos@49_poly-right##38 9.871
R1058 Cin#18pmos@49_poly-right##38 Cin#18pmos@49_poly-right##39 9.871
R1059 Cin#18pmos@49_poly-right##39 Cin#18pmos@49_poly-right##40 9.871
R1060 Cin#18pmos@49_poly-right##40 Cin#18pmos@49_poly-right##41 9.871
R1061 Cin#18pmos@49_poly-right##41 Cin#18pmos@49_poly-right##42 9.871
R1062 Cin#18pmos@49_poly-right##42 Cin#18pmos@49_poly-right##43 9.871
R1063 Cin#18pmos@49_poly-right##43 Cin#18pmos@49_poly-right##44 9.871
R1064 Cin#18pmos@49_poly-right##44 Cin#18pmos@49_poly-right##45 9.871
R1065 Cin#18pmos@49_poly-right##45 Cin#18pmos@49_poly-right##46 9.871
R1066 Cin#18pmos@49_poly-right##46 Cin#18pmos@49_poly-right##47 9.871
R1067 Cin#18pmos@49_poly-right##47 Cin#18pmos@49_poly-right##48 9.871
R1068 Cin#18pmos@49_poly-right##48 Cin#18pmos@49_poly-right##49 9.871
R1069 Cin#18pmos@49_poly-right##49 Cin#18pmos@49_poly-right##50 9.871
R1070 Cin#18pmos@49_poly-right##50 Cin#18pmos@49_poly-right##51 9.871
R1071 Cin#18pmos@49_poly-right##51 Cin#18pmos@49_poly-right##52 9.871
R1072 Cin#18pmos@49_poly-right##52 Cin#18pmos@49_poly-right##53 9.871
R1073 Cin#18pmos@49_poly-right##53 Cin#18pmos@49_poly-right##54 9.871
R1074 Cin#18pmos@49_poly-right##54 Cin#18pmos@49_poly-right##55 9.871
R1075 Cin#18pmos@49_poly-right##55 Cin#9nmos@49_poly-left 9.871
R1076 net@577#14pmos@50_poly-right net@577#14pmos@50_poly-right##0 9.871
R1077 net@577#14pmos@50_poly-right##0 net@577#14pmos@50_poly-right##1 9.871
R1078 net@577#14pmos@50_poly-right##1 net@577#14pmos@50_poly-right##2 9.871
R1079 net@577#14pmos@50_poly-right##2 net@577#14pmos@50_poly-right##3 9.871
R1080 net@577#14pmos@50_poly-right##3 net@577#14pmos@50_poly-right##4 9.871
R1081 net@577#14pmos@50_poly-right##4 net@577#14pmos@50_poly-right##5 9.871
R1082 net@577#14pmos@50_poly-right##5 net@577#14pmos@50_poly-right##6 9.871
R1083 net@577#14pmos@50_poly-right##6 net@577#14pmos@50_poly-right##7 9.871
R1084 net@577#14pmos@50_poly-right##7 net@577#14pmos@50_poly-right##8 9.871
R1085 net@577#14pmos@50_poly-right##8 net@577#14pmos@50_poly-right##9 9.871
R1086 net@577#14pmos@50_poly-right##9 net@577#14pmos@50_poly-right##10 9.871
R1087 net@577#14pmos@50_poly-right##10 net@577#14pmos@50_poly-right##11 9.871
R1088 net@577#14pmos@50_poly-right##11 net@577#14pmos@50_poly-right##12 9.871
R1089 net@577#14pmos@50_poly-right##12 net@577#14pmos@50_poly-right##13 9.871
R1090 net@577#14pmos@50_poly-right##13 net@577#14pmos@50_poly-right##14 9.871
R1091 net@577#14pmos@50_poly-right##14 net@577#14pmos@50_poly-right##15 9.871
R1092 net@577#14pmos@50_poly-right##15 net@577#14pmos@50_poly-right##16 9.871
R1093 net@577#14pmos@50_poly-right##16 net@577#14pmos@50_poly-right##17 9.871
R1094 net@577#14pmos@50_poly-right##17 net@577#14pmos@50_poly-right##18 9.871
R1095 net@577#14pmos@50_poly-right##18 net@577#14pmos@50_poly-right##19 9.871
R1096 net@577#14pmos@50_poly-right##19 net@577#14pmos@50_poly-right##20 9.871
R1097 net@577#14pmos@50_poly-right##20 net@577#14pmos@50_poly-right##21 9.871
R1098 net@577#14pmos@50_poly-right##21 net@577#14pmos@50_poly-right##22 9.871
R1099 net@577#14pmos@50_poly-right##22 net@577#14pmos@50_poly-right##23 9.871
R1100 net@577#14pmos@50_poly-right##23 net@577#14pmos@50_poly-right##24 9.871
R1101 net@577#14pmos@50_poly-right##24 net@577#14pmos@50_poly-right##25 9.871
R1102 net@577#14pmos@50_poly-right##25 net@577#14pmos@50_poly-right##26 9.871
R1103 net@577#14pmos@50_poly-right##26 net@577#14pmos@50_poly-right##27 9.871
R1104 net@577#14pmos@50_poly-right##27 net@577#14pmos@50_poly-right##28 9.871
R1105 net@577#14pmos@50_poly-right##28 net@577#14pmos@50_poly-right##29 9.871
R1106 net@577#14pmos@50_poly-right##29 net@577#14pmos@50_poly-right##30 9.871
R1107 net@577#14pmos@50_poly-right##30 net@577#14pmos@50_poly-right##31 9.871
R1108 net@577#14pmos@50_poly-right##31 net@577#14pmos@50_poly-right##32 9.871
R1109 net@577#14pmos@50_poly-right##32 net@577#14pmos@50_poly-right##33 9.871
R1110 net@577#14pmos@50_poly-right##33 net@577#14pmos@50_poly-right##34 9.871
R1111 net@577#14pmos@50_poly-right##34 net@577#14pmos@50_poly-right##35 9.871
R1112 net@577#14pmos@50_poly-right##35 net@577#14pmos@50_poly-right##36 9.871
R1113 net@577#14pmos@50_poly-right##36 net@577#14pmos@50_poly-right##37 9.871
R1114 net@577#14pmos@50_poly-right##37 net@577#14pmos@50_poly-right##38 9.871
R1115 net@577#14pmos@50_poly-right##38 net@577#14pmos@50_poly-right##39 9.871
R1116 net@577#14pmos@50_poly-right##39 net@577#14pmos@50_poly-right##40 9.871
R1117 net@577#14pmos@50_poly-right##40 net@577#14pmos@50_poly-right##41 9.871
R1118 net@577#14pmos@50_poly-right##41 net@577#14pmos@50_poly-right##42 9.871
R1119 net@577#14pmos@50_poly-right##42 net@577#14pmos@50_poly-right##43 9.871
R1120 net@577#14pmos@50_poly-right##43 net@577#14pmos@50_poly-right##44 9.871
R1121 net@577#14pmos@50_poly-right##44 net@577#14pmos@50_poly-right##45 9.871
R1122 net@577#14pmos@50_poly-right##45 net@577#14pmos@50_poly-right##46 9.871
R1123 net@577#14pmos@50_poly-right##46 net@577#14pmos@50_poly-right##47 9.871
R1124 net@577#14pmos@50_poly-right##47 net@577#14pmos@50_poly-right##48 9.871
R1125 net@577#14pmos@50_poly-right##48 net@577#14pmos@50_poly-right##49 9.871
R1126 net@577#14pmos@50_poly-right##49 net@577#14pmos@50_poly-right##50 9.871
R1127 net@577#14pmos@50_poly-right##50 net@577#14pmos@50_poly-right##51 9.871
R1128 net@577#14pmos@50_poly-right##51 net@577#14pmos@50_poly-right##52 9.871
R1129 net@577#14pmos@50_poly-right##52 net@577#14pmos@50_poly-right##53 9.871
R1130 net@577#14pmos@50_poly-right##53 net@577#14pmos@50_poly-right##54 9.871
R1131 net@577#14pmos@50_poly-right##54 net@577#14pmos@50_poly-right##55 9.871
R1132 net@577#14pmos@50_poly-right##55 net@577#9nmos@50_poly-left 9.871
R1133 net@576#2contact@295_metal-1-polysilicon-1 net@576 4.654
R1134 net@576#12pmos@53_poly-right net@576#12pmos@53_poly-right##0 9.931
R1135 net@576#12pmos@53_poly-right##0 net@576#12pmos@53_poly-right##1 9.931
R1136 net@576#12pmos@53_poly-right##1 net@576#12pmos@53_poly-right##2 9.931
R1137 net@576#12pmos@53_poly-right##2 net@576#12pmos@53_poly-right##3 9.931
R1138 net@576#12pmos@53_poly-right##3 net@576#12pmos@53_poly-right##4 9.931
R1139 net@576#12pmos@53_poly-right##4 net@576#12pmos@53_poly-right##5 9.931
R1140 net@576#12pmos@53_poly-right##5 net@576#12pmos@53_poly-right##6 9.931
R1141 net@576#12pmos@53_poly-right##6 net@576#12pmos@53_poly-right##7 9.931
R1142 net@576#12pmos@53_poly-right##7 net@576#12pmos@53_poly-right##8 9.931
R1143 net@576#12pmos@53_poly-right##8 net@576#12pmos@53_poly-right##9 9.931
R1144 net@576#12pmos@53_poly-right##9 net@576#12pmos@53_poly-right##10 9.931
R1145 net@576#12pmos@53_poly-right##10 net@576#12pmos@53_poly-right##11 9.931
R1146 net@576#12pmos@53_poly-right##11 net@576#12pmos@53_poly-right##12 9.931
R1147 net@576#12pmos@53_poly-right##12 net@576#12pmos@53_poly-right##13 9.931
R1148 net@576#12pmos@53_poly-right##13 net@576#12pmos@53_poly-right##14 9.931
R1149 net@576#12pmos@53_poly-right##14 net@576#12pmos@53_poly-right##15 9.931
R1150 net@576#12pmos@53_poly-right##15 net@576#12pmos@53_poly-right##16 9.931
R1151 net@576#12pmos@53_poly-right##16 net@576#12pmos@53_poly-right##17 9.931
R1152 net@576#12pmos@53_poly-right##17 net@576#12pmos@53_poly-right##18 9.931
R1153 net@576#12pmos@53_poly-right##18 net@576#12pmos@53_poly-right##19 9.931
R1154 net@576#12pmos@53_poly-right##19 net@576#12pmos@53_poly-right##20 9.931
R1155 net@576#12pmos@53_poly-right##20 net@576#12pmos@53_poly-right##21 9.931
R1156 net@576#12pmos@53_poly-right##21 net@576#12pmos@53_poly-right##22 9.931
R1157 net@576#12pmos@53_poly-right##22 net@576#12pmos@53_poly-right##23 9.931
R1158 net@576#12pmos@53_poly-right##23 net@576#12pmos@53_poly-right##24 9.931
R1159 net@576#12pmos@53_poly-right##24 net@576#12pmos@53_poly-right##25 9.931
R1160 net@576#12pmos@53_poly-right##25 net@576#12pmos@53_poly-right##26 9.931
R1161 net@576#12pmos@53_poly-right##26 net@576#12pmos@53_poly-right##27 9.931
R1162 net@576#12pmos@53_poly-right##27 net@576#12pmos@53_poly-right##28 9.931
R1163 net@576#12pmos@53_poly-right##28 net@576#12pmos@53_poly-right##29 9.931
R1164 net@576#12pmos@53_poly-right##29 net@576#12pmos@53_poly-right##30 9.931
R1165 net@576#12pmos@53_poly-right##30 net@576#12pmos@53_poly-right##31 9.931
R1166 net@576#12pmos@53_poly-right##31 net@576#12pmos@53_poly-right##32 9.931
R1167 net@576#12pmos@53_poly-right##32 net@576#12pmos@53_poly-right##33 9.931
R1168 net@576#12pmos@53_poly-right##33 net@576#12pmos@53_poly-right##34 9.931
R1169 net@576#12pmos@53_poly-right##34 net@576#12pmos@53_poly-right##35 9.931
R1170 net@576#12pmos@53_poly-right##35 net@576#12pmos@53_poly-right##36 9.931
R1171 net@576#12pmos@53_poly-right##36 net@576#12pmos@53_poly-right##37 9.931
R1172 net@576#12pmos@53_poly-right##37 net@576#12pmos@53_poly-right##38 9.931
R1173 net@576#12pmos@53_poly-right##38 net@576#12pmos@53_poly-right##39 9.931
R1174 net@576#12pmos@53_poly-right##39 net@576#12pmos@53_poly-right##40 9.931
R1175 net@576#12pmos@53_poly-right##40 net@576#12pmos@53_poly-right##41 9.931
R1176 net@576#12pmos@53_poly-right##41 net@576#12pmos@53_poly-right##42 9.931
R1177 net@576#12pmos@53_poly-right##42 net@576#12pmos@53_poly-right##43 9.931
R1178 net@576#12pmos@53_poly-right##43 net@576#12pmos@53_poly-right##44 9.931
R1179 net@576#12pmos@53_poly-right##44 net@576#12pmos@53_poly-right##45 9.931
R1180 net@576#12pmos@53_poly-right##45 net@576#12pmos@53_poly-right##46 9.931
R1181 net@576#12pmos@53_poly-right##46 net@576#12pmos@53_poly-right##47 9.931
R1182 net@576#12pmos@53_poly-right##47 net@576#12pmos@53_poly-right##48 9.931
R1183 net@576#12pmos@53_poly-right##48 net@576#12pmos@53_poly-right##49 9.931
R1184 net@576#12pmos@53_poly-right##49 net@576#12pmos@53_poly-right##50 9.931
R1185 net@576#12pmos@53_poly-right##50 net@576#12pmos@53_poly-right##51 9.931
R1186 net@576#12pmos@53_poly-right##51 net@576#12pmos@53_poly-right##52 9.931
R1187 net@576#12pmos@53_poly-right##52 net@576#5pin@195_polysilicon-1 9.931
R1188 Sum0#4pmos@53_diff-top Sum0 4.823
R1189 XOR1_to_NAND1#14pin@207_polysilicon-1 XOR1_to_NAND1#14pin@207_polysilicon-1##0 9.854
R1190 XOR1_to_NAND1#14pin@207_polysilicon-1##0 XOR1_to_NAND1#14pin@207_polysilicon-1##1 9.854
R1191 XOR1_to_NAND1#14pin@207_polysilicon-1##1 XOR1_to_NAND1#14pin@207_polysilicon-1##2 9.854
R1192 XOR1_to_NAND1#14pin@207_polysilicon-1##2 XOR1_to_NAND1#14pin@207_polysilicon-1##3 9.854
R1193 XOR1_to_NAND1#14pin@207_polysilicon-1##3 XOR1_to_NAND1#14pin@207_polysilicon-1##4 9.854
R1194 XOR1_to_NAND1#14pin@207_polysilicon-1##4 XOR1_to_NAND1#14pin@207_polysilicon-1##5 9.854
R1195 XOR1_to_NAND1#14pin@207_polysilicon-1##5 XOR1_to_NAND1#14pin@207_polysilicon-1##6 9.854
R1196 XOR1_to_NAND1#14pin@207_polysilicon-1##6 XOR1_to_NAND1#14pin@207_polysilicon-1##7 9.854
R1197 XOR1_to_NAND1#14pin@207_polysilicon-1##7 XOR1_to_NAND1#14pin@207_polysilicon-1##8 9.854
R1198 XOR1_to_NAND1#14pin@207_polysilicon-1##8 XOR1_to_NAND1#14pin@207_polysilicon-1##9 9.854
R1199 XOR1_to_NAND1#14pin@207_polysilicon-1##9 XOR1_to_NAND1#14pin@207_polysilicon-1##10 9.854
R1200 XOR1_to_NAND1#14pin@207_polysilicon-1##10 XOR1_to_NAND1#14pin@207_polysilicon-1##11 9.854
R1201 XOR1_to_NAND1#14pin@207_polysilicon-1##11 XOR1_to_NAND1#14pin@207_polysilicon-1##12 9.854
R1202 XOR1_to_NAND1#14pin@207_polysilicon-1##12 XOR1_to_NAND1#14pin@207_polysilicon-1##13 9.854
R1203 XOR1_to_NAND1#14pin@207_polysilicon-1##13 XOR1_to_NAND1#14pin@207_polysilicon-1##14 9.854
R1204 XOR1_to_NAND1#14pin@207_polysilicon-1##14 XOR1_to_NAND1#14pin@207_polysilicon-1##15 9.854
R1205 XOR1_to_NAND1#14pin@207_polysilicon-1##15 XOR1_to_NAND1#14pin@207_polysilicon-1##16 9.854
R1206 XOR1_to_NAND1#14pin@207_polysilicon-1##16 XOR1_to_NAND1#14pin@207_polysilicon-1##17 9.854
R1207 XOR1_to_NAND1#14pin@207_polysilicon-1##17 XOR1_to_NAND1#14pin@207_polysilicon-1##18 9.854
R1208 XOR1_to_NAND1#14pin@207_polysilicon-1##18 XOR1_to_NAND1#14pin@207_polysilicon-1##19 9.854
R1209 XOR1_to_NAND1#14pin@207_polysilicon-1##19 XOR1_to_NAND1#14pin@207_polysilicon-1##20 9.854
R1210 XOR1_to_NAND1#14pin@207_polysilicon-1##20 XOR1_to_NAND1#14pin@207_polysilicon-1##21 9.854
R1211 XOR1_to_NAND1#14pin@207_polysilicon-1##21 XOR1_to_NAND1#14pin@207_polysilicon-1##22 9.854
R1212 XOR1_to_NAND1#14pin@207_polysilicon-1##22 XOR1_to_NAND1#14pin@207_polysilicon-1##23 9.854
R1213 XOR1_to_NAND1#14pin@207_polysilicon-1##23 XOR1_to_NAND1#14pin@207_polysilicon-1##24 9.854
R1214 XOR1_to_NAND1#14pin@207_polysilicon-1##24 XOR1_to_NAND1#14pin@207_polysilicon-1##25 9.854
R1215 XOR1_to_NAND1#14pin@207_polysilicon-1##25 XOR1_to_NAND1#14pin@207_polysilicon-1##26 9.854
R1216 XOR1_to_NAND1#14pin@207_polysilicon-1##26 XOR1_to_NAND1#14pin@207_polysilicon-1##27 9.854
R1217 XOR1_to_NAND1#14pin@207_polysilicon-1##27 XOR1_to_NAND1#14pin@207_polysilicon-1##28 9.854
R1218 XOR1_to_NAND1#14pin@207_polysilicon-1##28 XOR1_to_NAND1#14pin@207_polysilicon-1##29 9.854
R1219 XOR1_to_NAND1#14pin@207_polysilicon-1##29 XOR1_to_NAND1#14pin@207_polysilicon-1##30 9.854
R1220 XOR1_to_NAND1#14pin@207_polysilicon-1##30 XOR1_to_NAND1#14pin@207_polysilicon-1##31 9.854
R1221 XOR1_to_NAND1#14pin@207_polysilicon-1##31 XOR1_to_NAND1#14pin@207_polysilicon-1##32 9.854
R1222 XOR1_to_NAND1#14pin@207_polysilicon-1##32 XOR1_to_NAND1#14pin@207_polysilicon-1##33 9.854
R1223 XOR1_to_NAND1#14pin@207_polysilicon-1##33 XOR1_to_NAND1#14pin@207_polysilicon-1##34 9.854
R1224 XOR1_to_NAND1#14pin@207_polysilicon-1##34 XOR1_to_NAND1#14pin@207_polysilicon-1##35 9.854
R1225 XOR1_to_NAND1#14pin@207_polysilicon-1##35 XOR1_to_NAND1#14pin@207_polysilicon-1##36 9.854
R1226 XOR1_to_NAND1#14pin@207_polysilicon-1##36 XOR1_to_NAND1#14pin@207_polysilicon-1##37 9.854
R1227 XOR1_to_NAND1#14pin@207_polysilicon-1##37 XOR1_to_NAND1#14pin@207_polysilicon-1##38 9.854
R1228 XOR1_to_NAND1#14pin@207_polysilicon-1##38 XOR1_to_NAND1#14pin@207_polysilicon-1##39 9.854
R1229 XOR1_to_NAND1#14pin@207_polysilicon-1##39 XOR1_to_NAND1#14pin@207_polysilicon-1##40 9.854
R1230 XOR1_to_NAND1#14pin@207_polysilicon-1##40 XOR1_to_NAND1#14pin@207_polysilicon-1##41 9.854
R1231 XOR1_to_NAND1#14pin@207_polysilicon-1##41 XOR1_to_NAND1#14pin@207_polysilicon-1##42 9.854
R1232 XOR1_to_NAND1#14pin@207_polysilicon-1##42 XOR1_to_NAND1#14pin@207_polysilicon-1##43 9.854
R1233 XOR1_to_NAND1#14pin@207_polysilicon-1##43 XOR1_to_NAND1#14pin@207_polysilicon-1##44 9.854
R1234 XOR1_to_NAND1#14pin@207_polysilicon-1##44 XOR1_to_NAND1#14pin@207_polysilicon-1##45 9.854
R1235 XOR1_to_NAND1#14pin@207_polysilicon-1##45 XOR1_to_NAND1#14pin@207_polysilicon-1##46 9.854
R1236 XOR1_to_NAND1#14pin@207_polysilicon-1##46 XOR1_to_NAND1#14pin@207_polysilicon-1##47 9.854
R1237 XOR1_to_NAND1#14pin@207_polysilicon-1##47 XOR1_to_NAND1#14pin@207_polysilicon-1##48 9.854
R1238 XOR1_to_NAND1#14pin@207_polysilicon-1##48 XOR1_to_NAND1#14pin@207_polysilicon-1##49 9.854
R1239 XOR1_to_NAND1#14pin@207_polysilicon-1##49 XOR1_to_NAND1#14pin@207_polysilicon-1##50 9.854
R1240 XOR1_to_NAND1#14pin@207_polysilicon-1##50 XOR1_to_NAND1#14pin@207_polysilicon-1##51 9.854
R1241 XOR1_to_NAND1#14pin@207_polysilicon-1##51 XOR1_to_NAND1#14pin@207_polysilicon-1##52 9.854
R1242 XOR1_to_NAND1#14pin@207_polysilicon-1##52 XOR1_to_NAND1#14pin@207_polysilicon-1##53 9.854
R1243 XOR1_to_NAND1#14pin@207_polysilicon-1##53 XOR1_to_NAND1#14pin@207_polysilicon-1##54 9.854
R1244 XOR1_to_NAND1#14pin@207_polysilicon-1##54 XOR1_to_NAND1#27nmos@54_poly-right 9.854
R1245 Cin#20pmos@55_poly-right Cin#20pmos@55_poly-right##0 9.877
R1246 Cin#20pmos@55_poly-right##0 Cin#20pmos@55_poly-right##1 9.877
R1247 Cin#20pmos@55_poly-right##1 Cin#20pmos@55_poly-right##2 9.877
R1248 Cin#20pmos@55_poly-right##2 Cin#20pmos@55_poly-right##3 9.877
R1249 Cin#20pmos@55_poly-right##3 Cin#20pmos@55_poly-right##4 9.877
R1250 Cin#20pmos@55_poly-right##4 Cin#20pmos@55_poly-right##5 9.877
R1251 Cin#20pmos@55_poly-right##5 Cin#20pmos@55_poly-right##6 9.877
R1252 Cin#20pmos@55_poly-right##6 Cin#20pmos@55_poly-right##7 9.877
R1253 Cin#20pmos@55_poly-right##7 Cin#20pmos@55_poly-right##8 9.877
R1254 Cin#20pmos@55_poly-right##8 Cin#20pmos@55_poly-right##9 9.877
R1255 Cin#20pmos@55_poly-right##9 Cin#20pmos@55_poly-right##10 9.877
R1256 Cin#20pmos@55_poly-right##10 Cin#20pmos@55_poly-right##11 9.877
R1257 Cin#20pmos@55_poly-right##11 Cin#20pmos@55_poly-right##12 9.877
R1258 Cin#20pmos@55_poly-right##12 Cin#20pmos@55_poly-right##13 9.877
R1259 Cin#20pmos@55_poly-right##13 Cin#20pmos@55_poly-right##14 9.877
R1260 Cin#20pmos@55_poly-right##14 Cin#20pmos@55_poly-right##15 9.877
R1261 Cin#20pmos@55_poly-right##15 Cin#20pmos@55_poly-right##16 9.877
R1262 Cin#20pmos@55_poly-right##16 Cin#20pmos@55_poly-right##17 9.877
R1263 Cin#20pmos@55_poly-right##17 Cin#20pmos@55_poly-right##18 9.877
R1264 Cin#20pmos@55_poly-right##18 Cin#20pmos@55_poly-right##19 9.877
R1265 Cin#20pmos@55_poly-right##19 Cin#20pmos@55_poly-right##20 9.877
R1266 Cin#20pmos@55_poly-right##20 Cin#20pmos@55_poly-right##21 9.877
R1267 Cin#20pmos@55_poly-right##21 Cin#20pmos@55_poly-right##22 9.877
R1268 Cin#20pmos@55_poly-right##22 Cin#20pmos@55_poly-right##23 9.877
R1269 Cin#20pmos@55_poly-right##23 Cin#20pmos@55_poly-right##24 9.877
R1270 Cin#20pmos@55_poly-right##24 Cin#20pmos@55_poly-right##25 9.877
R1271 Cin#20pmos@55_poly-right##25 Cin#20pmos@55_poly-right##26 9.877
R1272 Cin#20pmos@55_poly-right##26 Cin#20pmos@55_poly-right##27 9.877
R1273 Cin#20pmos@55_poly-right##27 Cin#20pmos@55_poly-right##28 9.877
R1274 Cin#20pmos@55_poly-right##28 Cin#20pmos@55_poly-right##29 9.877
R1275 Cin#20pmos@55_poly-right##29 Cin#20pmos@55_poly-right##30 9.877
R1276 Cin#20pmos@55_poly-right##30 Cin#20pmos@55_poly-right##31 9.877
R1277 Cin#20pmos@55_poly-right##31 Cin#20pmos@55_poly-right##32 9.877
R1278 Cin#20pmos@55_poly-right##32 Cin#20pmos@55_poly-right##33 9.877
R1279 Cin#20pmos@55_poly-right##33 Cin#20pmos@55_poly-right##34 9.877
R1280 Cin#20pmos@55_poly-right##34 Cin#20pmos@55_poly-right##35 9.877
R1281 Cin#20pmos@55_poly-right##35 Cin#20pmos@55_poly-right##36 9.877
R1282 Cin#20pmos@55_poly-right##36 Cin#20pmos@55_poly-right##37 9.877
R1283 Cin#20pmos@55_poly-right##37 Cin#20pmos@55_poly-right##38 9.877
R1284 Cin#20pmos@55_poly-right##38 Cin#20pmos@55_poly-right##39 9.877
R1285 Cin#20pmos@55_poly-right##39 Cin#20pmos@55_poly-right##40 9.877
R1286 Cin#20pmos@55_poly-right##40 Cin#20pmos@55_poly-right##41 9.877
R1287 Cin#20pmos@55_poly-right##41 Cin#20pmos@55_poly-right##42 9.877
R1288 Cin#20pmos@55_poly-right##42 Cin#20pmos@55_poly-right##43 9.877
R1289 Cin#20pmos@55_poly-right##43 Cin#20pmos@55_poly-right##44 9.877
R1290 Cin#20pmos@55_poly-right##44 Cin#20pmos@55_poly-right##45 9.877
R1291 Cin#20pmos@55_poly-right##45 Cin#20pmos@55_poly-right##46 9.877
R1292 Cin#20pmos@55_poly-right##46 Cin#20pmos@55_poly-right##47 9.877
R1293 Cin#20pmos@55_poly-right##47 Cin#20pmos@55_poly-right##48 9.877
R1294 Cin#20pmos@55_poly-right##48 Cin#20pmos@55_poly-right##49 9.877
R1295 Cin#20pmos@55_poly-right##49 Cin#14pin@212_polysilicon-1 9.877
R1296 NAND1_to_NAND3 NAND1_to_NAND3#4nmos@55_diff-bottom 4.823
R1297 A0#8pin@215_polysilicon-1 A0#8pin@215_polysilicon-1##0 9.938
R1298 A0#8pin@215_polysilicon-1##0 A0#8pin@215_polysilicon-1##1 9.938
R1299 A0#8pin@215_polysilicon-1##1 A0#8pin@215_polysilicon-1##2 9.938
R1300 A0#8pin@215_polysilicon-1##2 A0#8pin@215_polysilicon-1##3 9.938
R1301 A0#8pin@215_polysilicon-1##3 A0#8pin@215_polysilicon-1##4 9.938
R1302 A0#8pin@215_polysilicon-1##4 A0#8pin@215_polysilicon-1##5 9.938
R1303 A0#8pin@215_polysilicon-1##5 A0#8pin@215_polysilicon-1##6 9.938
R1304 A0#8pin@215_polysilicon-1##6 A0#8pin@215_polysilicon-1##7 9.938
R1305 A0#8pin@215_polysilicon-1##7 A0#8pin@215_polysilicon-1##8 9.938
R1306 A0#8pin@215_polysilicon-1##8 A0#8pin@215_polysilicon-1##9 9.938
R1307 A0#8pin@215_polysilicon-1##9 A0#8pin@215_polysilicon-1##10 9.938
R1308 A0#8pin@215_polysilicon-1##10 A0#8pin@215_polysilicon-1##11 9.938
R1309 A0#8pin@215_polysilicon-1##11 A0#8pin@215_polysilicon-1##12 9.938
R1310 A0#8pin@215_polysilicon-1##12 A0#8pin@215_polysilicon-1##13 9.938
R1311 A0#8pin@215_polysilicon-1##13 A0#8pin@215_polysilicon-1##14 9.938
R1312 A0#8pin@215_polysilicon-1##14 A0#8pin@215_polysilicon-1##15 9.938
R1313 A0#8pin@215_polysilicon-1##15 A0#8pin@215_polysilicon-1##16 9.938
R1314 A0#8pin@215_polysilicon-1##16 A0#8pin@215_polysilicon-1##17 9.938
R1315 A0#8pin@215_polysilicon-1##17 A0#8pin@215_polysilicon-1##18 9.938
R1316 A0#8pin@215_polysilicon-1##18 A0#8pin@215_polysilicon-1##19 9.938
R1317 A0#8pin@215_polysilicon-1##19 A0#8pin@215_polysilicon-1##20 9.938
R1318 A0#8pin@215_polysilicon-1##20 A0#8pin@215_polysilicon-1##21 9.938
R1319 A0#8pin@215_polysilicon-1##21 A0#8pin@215_polysilicon-1##22 9.938
R1320 A0#8pin@215_polysilicon-1##22 A0#8pin@215_polysilicon-1##23 9.938
R1321 A0#8pin@215_polysilicon-1##23 A0#8pin@215_polysilicon-1##24 9.938
R1322 A0#8pin@215_polysilicon-1##24 A0#8pin@215_polysilicon-1##25 9.938
R1323 A0#8pin@215_polysilicon-1##25 A0#8pin@215_polysilicon-1##26 9.938
R1324 A0#8pin@215_polysilicon-1##26 A0#8pin@215_polysilicon-1##27 9.938
R1325 A0#8pin@215_polysilicon-1##27 A0#8pin@215_polysilicon-1##28 9.938
R1326 A0#8pin@215_polysilicon-1##28 A0#8pin@215_polysilicon-1##29 9.938
R1327 A0#8pin@215_polysilicon-1##29 A0#8pin@215_polysilicon-1##30 9.938
R1328 A0#8pin@215_polysilicon-1##30 A0#8pin@215_polysilicon-1##31 9.938
R1329 A0#8pin@215_polysilicon-1##31 A0#8pin@215_polysilicon-1##32 9.938
R1330 A0#8pin@215_polysilicon-1##32 A0#8pin@215_polysilicon-1##33 9.938
R1331 A0#8pin@215_polysilicon-1##33 A0#8pin@215_polysilicon-1##34 9.938
R1332 A0#8pin@215_polysilicon-1##34 A0#8pin@215_polysilicon-1##35 9.938
R1333 A0#8pin@215_polysilicon-1##35 A0#8pin@215_polysilicon-1##36 9.938
R1334 A0#8pin@215_polysilicon-1##36 A0#8pin@215_polysilicon-1##37 9.938
R1335 A0#8pin@215_polysilicon-1##37 A0#8pin@215_polysilicon-1##38 9.938
R1336 A0#8pin@215_polysilicon-1##38 A0#8pin@215_polysilicon-1##39 9.938
R1337 A0#8pin@215_polysilicon-1##39 A0#8pin@215_polysilicon-1##40 9.938
R1338 A0#8pin@215_polysilicon-1##40 A0#8pin@215_polysilicon-1##41 9.938
R1339 A0#8pin@215_polysilicon-1##41 A0#8pin@215_polysilicon-1##42 9.938
R1340 A0#8pin@215_polysilicon-1##42 A0#8pin@215_polysilicon-1##43 9.938
R1341 A0#8pin@215_polysilicon-1##43 A0#8pin@215_polysilicon-1##44 9.938
R1342 A0#8pin@215_polysilicon-1##44 A0#8pin@215_polysilicon-1##45 9.938
R1343 A0#8pin@215_polysilicon-1##45 A0#8pin@215_polysilicon-1##46 9.938
R1344 A0#8pin@215_polysilicon-1##46 A0#8pin@215_polysilicon-1##47 9.938
R1345 A0#8pin@215_polysilicon-1##47 A0#8pin@215_polysilicon-1##48 9.938
R1346 A0#8pin@215_polysilicon-1##48 A0#8pin@215_polysilicon-1##49 9.938
R1347 A0#8pin@215_polysilicon-1##49 A0#17nmos@56_poly-right 9.938
R1348 B0#18pmos@57_poly-right B0#18pmos@57_poly-right##0 9.869
R1349 B0#18pmos@57_poly-right##0 B0#18pmos@57_poly-right##1 9.869
R1350 B0#18pmos@57_poly-right##1 B0#18pmos@57_poly-right##2 9.869
R1351 B0#18pmos@57_poly-right##2 B0#18pmos@57_poly-right##3 9.869
R1352 B0#18pmos@57_poly-right##3 B0#18pmos@57_poly-right##4 9.869
R1353 B0#18pmos@57_poly-right##4 B0#18pmos@57_poly-right##5 9.869
R1354 B0#18pmos@57_poly-right##5 B0#18pmos@57_poly-right##6 9.869
R1355 B0#18pmos@57_poly-right##6 B0#18pmos@57_poly-right##7 9.869
R1356 B0#18pmos@57_poly-right##7 B0#18pmos@57_poly-right##8 9.869
R1357 B0#18pmos@57_poly-right##8 B0#18pmos@57_poly-right##9 9.869
R1358 B0#18pmos@57_poly-right##9 B0#18pmos@57_poly-right##10 9.869
R1359 B0#18pmos@57_poly-right##10 B0#18pmos@57_poly-right##11 9.869
R1360 B0#18pmos@57_poly-right##11 B0#18pmos@57_poly-right##12 9.869
R1361 B0#18pmos@57_poly-right##12 B0#18pmos@57_poly-right##13 9.869
R1362 B0#18pmos@57_poly-right##13 B0#18pmos@57_poly-right##14 9.869
R1363 B0#18pmos@57_poly-right##14 B0#18pmos@57_poly-right##15 9.869
R1364 B0#18pmos@57_poly-right##15 B0#18pmos@57_poly-right##16 9.869
R1365 B0#18pmos@57_poly-right##16 B0#18pmos@57_poly-right##17 9.869
R1366 B0#18pmos@57_poly-right##17 B0#18pmos@57_poly-right##18 9.869
R1367 B0#18pmos@57_poly-right##18 B0#18pmos@57_poly-right##19 9.869
R1368 B0#18pmos@57_poly-right##19 B0#18pmos@57_poly-right##20 9.869
R1369 B0#18pmos@57_poly-right##20 B0#18pmos@57_poly-right##21 9.869
R1370 B0#18pmos@57_poly-right##21 B0#18pmos@57_poly-right##22 9.869
R1371 B0#18pmos@57_poly-right##22 B0#18pmos@57_poly-right##23 9.869
R1372 B0#18pmos@57_poly-right##23 B0#18pmos@57_poly-right##24 9.869
R1373 B0#18pmos@57_poly-right##24 B0#18pmos@57_poly-right##25 9.869
R1374 B0#18pmos@57_poly-right##25 B0#18pmos@57_poly-right##26 9.869
R1375 B0#18pmos@57_poly-right##26 B0#18pmos@57_poly-right##27 9.869
R1376 B0#18pmos@57_poly-right##27 B0#18pmos@57_poly-right##28 9.869
R1377 B0#18pmos@57_poly-right##28 B0#18pmos@57_poly-right##29 9.869
R1378 B0#18pmos@57_poly-right##29 B0#18pmos@57_poly-right##30 9.869
R1379 B0#18pmos@57_poly-right##30 B0#18pmos@57_poly-right##31 9.869
R1380 B0#18pmos@57_poly-right##31 B0#18pmos@57_poly-right##32 9.869
R1381 B0#18pmos@57_poly-right##32 B0#18pmos@57_poly-right##33 9.869
R1382 B0#18pmos@57_poly-right##33 B0#18pmos@57_poly-right##34 9.869
R1383 B0#18pmos@57_poly-right##34 B0#18pmos@57_poly-right##35 9.869
R1384 B0#18pmos@57_poly-right##35 B0#18pmos@57_poly-right##36 9.869
R1385 B0#18pmos@57_poly-right##36 B0#18pmos@57_poly-right##37 9.869
R1386 B0#18pmos@57_poly-right##37 B0#18pmos@57_poly-right##38 9.869
R1387 B0#18pmos@57_poly-right##38 B0#18pmos@57_poly-right##39 9.869
R1388 B0#18pmos@57_poly-right##39 B0#18pmos@57_poly-right##40 9.869
R1389 B0#18pmos@57_poly-right##40 B0#18pmos@57_poly-right##41 9.869
R1390 B0#18pmos@57_poly-right##41 B0#18pmos@57_poly-right##42 9.869
R1391 B0#18pmos@57_poly-right##42 B0#18pmos@57_poly-right##43 9.869
R1392 B0#18pmos@57_poly-right##43 B0#18pmos@57_poly-right##44 9.869
R1393 B0#18pmos@57_poly-right##44 B0#18pmos@57_poly-right##45 9.869
R1394 B0#18pmos@57_poly-right##45 B0#18pmos@57_poly-right##46 9.869
R1395 B0#18pmos@57_poly-right##46 B0#18pmos@57_poly-right##47 9.869
R1396 B0#18pmos@57_poly-right##47 B0#8pin@220_polysilicon-1 9.869
R1397 NAND2_to_Nand3#9pin@224_polysilicon-1 NAND2_to_Nand3#9pin@224_polysilicon-1##0 9.938
R1398 NAND2_to_Nand3#9pin@224_polysilicon-1##0 NAND2_to_Nand3#9pin@224_polysilicon-1##1 9.938
R1399 NAND2_to_Nand3#9pin@224_polysilicon-1##1 NAND2_to_Nand3#9pin@224_polysilicon-1##2 9.938
R1400 NAND2_to_Nand3#9pin@224_polysilicon-1##2 NAND2_to_Nand3#9pin@224_polysilicon-1##3 9.938
R1401 NAND2_to_Nand3#9pin@224_polysilicon-1##3 NAND2_to_Nand3#9pin@224_polysilicon-1##4 9.938
R1402 NAND2_to_Nand3#9pin@224_polysilicon-1##4 NAND2_to_Nand3#9pin@224_polysilicon-1##5 9.938
R1403 NAND2_to_Nand3#9pin@224_polysilicon-1##5 NAND2_to_Nand3#9pin@224_polysilicon-1##6 9.938
R1404 NAND2_to_Nand3#9pin@224_polysilicon-1##6 NAND2_to_Nand3#9pin@224_polysilicon-1##7 9.938
R1405 NAND2_to_Nand3#9pin@224_polysilicon-1##7 NAND2_to_Nand3#9pin@224_polysilicon-1##8 9.938
R1406 NAND2_to_Nand3#9pin@224_polysilicon-1##8 NAND2_to_Nand3#9pin@224_polysilicon-1##9 9.938
R1407 NAND2_to_Nand3#9pin@224_polysilicon-1##9 NAND2_to_Nand3#9pin@224_polysilicon-1##10 9.938
R1408 NAND2_to_Nand3#9pin@224_polysilicon-1##10 NAND2_to_Nand3#9pin@224_polysilicon-1##11 9.938
R1409 NAND2_to_Nand3#9pin@224_polysilicon-1##11 NAND2_to_Nand3#9pin@224_polysilicon-1##12 9.938
R1410 NAND2_to_Nand3#9pin@224_polysilicon-1##12 NAND2_to_Nand3#9pin@224_polysilicon-1##13 9.938
R1411 NAND2_to_Nand3#9pin@224_polysilicon-1##13 NAND2_to_Nand3#9pin@224_polysilicon-1##14 9.938
R1412 NAND2_to_Nand3#9pin@224_polysilicon-1##14 NAND2_to_Nand3#9pin@224_polysilicon-1##15 9.938
R1413 NAND2_to_Nand3#9pin@224_polysilicon-1##15 NAND2_to_Nand3#9pin@224_polysilicon-1##16 9.938
R1414 NAND2_to_Nand3#9pin@224_polysilicon-1##16 NAND2_to_Nand3#9pin@224_polysilicon-1##17 9.938
R1415 NAND2_to_Nand3#9pin@224_polysilicon-1##17 NAND2_to_Nand3#9pin@224_polysilicon-1##18 9.938
R1416 NAND2_to_Nand3#9pin@224_polysilicon-1##18 NAND2_to_Nand3#9pin@224_polysilicon-1##19 9.938
R1417 NAND2_to_Nand3#9pin@224_polysilicon-1##19 NAND2_to_Nand3#9pin@224_polysilicon-1##20 9.938
R1418 NAND2_to_Nand3#9pin@224_polysilicon-1##20 NAND2_to_Nand3#9pin@224_polysilicon-1##21 9.938
R1419 NAND2_to_Nand3#9pin@224_polysilicon-1##21 NAND2_to_Nand3#9pin@224_polysilicon-1##22 9.938
R1420 NAND2_to_Nand3#9pin@224_polysilicon-1##22 NAND2_to_Nand3#9pin@224_polysilicon-1##23 9.938
R1421 NAND2_to_Nand3#9pin@224_polysilicon-1##23 NAND2_to_Nand3#9pin@224_polysilicon-1##24 9.938
R1422 NAND2_to_Nand3#9pin@224_polysilicon-1##24 NAND2_to_Nand3#9pin@224_polysilicon-1##25 9.938
R1423 NAND2_to_Nand3#9pin@224_polysilicon-1##25 NAND2_to_Nand3#9pin@224_polysilicon-1##26 9.938
R1424 NAND2_to_Nand3#9pin@224_polysilicon-1##26 NAND2_to_Nand3#9pin@224_polysilicon-1##27 9.938
R1425 NAND2_to_Nand3#9pin@224_polysilicon-1##27 NAND2_to_Nand3#9pin@224_polysilicon-1##28 9.938
R1426 NAND2_to_Nand3#9pin@224_polysilicon-1##28 NAND2_to_Nand3#9pin@224_polysilicon-1##29 9.938
R1427 NAND2_to_Nand3#9pin@224_polysilicon-1##29 NAND2_to_Nand3#9pin@224_polysilicon-1##30 9.938
R1428 NAND2_to_Nand3#9pin@224_polysilicon-1##30 NAND2_to_Nand3#9pin@224_polysilicon-1##31 9.938
R1429 NAND2_to_Nand3#9pin@224_polysilicon-1##31 NAND2_to_Nand3#9pin@224_polysilicon-1##32 9.938
R1430 NAND2_to_Nand3#9pin@224_polysilicon-1##32 NAND2_to_Nand3#9pin@224_polysilicon-1##33 9.938
R1431 NAND2_to_Nand3#9pin@224_polysilicon-1##33 NAND2_to_Nand3#9pin@224_polysilicon-1##34 9.938
R1432 NAND2_to_Nand3#9pin@224_polysilicon-1##34 NAND2_to_Nand3#9pin@224_polysilicon-1##35 9.938
R1433 NAND2_to_Nand3#9pin@224_polysilicon-1##35 NAND2_to_Nand3#9pin@224_polysilicon-1##36 9.938
R1434 NAND2_to_Nand3#9pin@224_polysilicon-1##36 NAND2_to_Nand3#9pin@224_polysilicon-1##37 9.938
R1435 NAND2_to_Nand3#9pin@224_polysilicon-1##37 NAND2_to_Nand3#9pin@224_polysilicon-1##38 9.938
R1436 NAND2_to_Nand3#9pin@224_polysilicon-1##38 NAND2_to_Nand3#9pin@224_polysilicon-1##39 9.938
R1437 NAND2_to_Nand3#9pin@224_polysilicon-1##39 NAND2_to_Nand3#9pin@224_polysilicon-1##40 9.938
R1438 NAND2_to_Nand3#9pin@224_polysilicon-1##40 NAND2_to_Nand3#9pin@224_polysilicon-1##41 9.938
R1439 NAND2_to_Nand3#9pin@224_polysilicon-1##41 NAND2_to_Nand3#9pin@224_polysilicon-1##42 9.938
R1440 NAND2_to_Nand3#9pin@224_polysilicon-1##42 NAND2_to_Nand3#9pin@224_polysilicon-1##43 9.938
R1441 NAND2_to_Nand3#9pin@224_polysilicon-1##43 NAND2_to_Nand3#9pin@224_polysilicon-1##44 9.938
R1442 NAND2_to_Nand3#9pin@224_polysilicon-1##44 NAND2_to_Nand3#9pin@224_polysilicon-1##45 9.938
R1443 NAND2_to_Nand3#9pin@224_polysilicon-1##45 NAND2_to_Nand3#9pin@224_polysilicon-1##46 9.938
R1444 NAND2_to_Nand3#9pin@224_polysilicon-1##46 NAND2_to_Nand3#9pin@224_polysilicon-1##47 9.938
R1445 NAND2_to_Nand3#9pin@224_polysilicon-1##47 NAND2_to_Nand3#9pin@224_polysilicon-1##48 9.938
R1446 NAND2_to_Nand3#9pin@224_polysilicon-1##48 NAND2_to_Nand3#9pin@224_polysilicon-1##49 9.938
R1447 NAND2_to_Nand3#9pin@224_polysilicon-1##49 NAND2_to_Nand3#11nmos@58_poly-right 9.938
R1448 NAND1_to_NAND3#14nmos@59_poly-right NAND1_to_NAND3#14nmos@59_poly-right##0 9.898
R1449 NAND1_to_NAND3#14nmos@59_poly-right##0 NAND1_to_NAND3#14nmos@59_poly-right##1 9.898
R1450 NAND1_to_NAND3#14nmos@59_poly-right##1 NAND1_to_NAND3#14nmos@59_poly-right##2 9.898
R1451 NAND1_to_NAND3#14nmos@59_poly-right##2 NAND1_to_NAND3#14nmos@59_poly-right##3 9.898
R1452 NAND1_to_NAND3#14nmos@59_poly-right##3 NAND1_to_NAND3#14nmos@59_poly-right##4 9.898
R1453 NAND1_to_NAND3#14nmos@59_poly-right##4 NAND1_to_NAND3#14nmos@59_poly-right##5 9.898
R1454 NAND1_to_NAND3#14nmos@59_poly-right##5 NAND1_to_NAND3#14nmos@59_poly-right##6 9.898
R1455 NAND1_to_NAND3#14nmos@59_poly-right##6 NAND1_to_NAND3#14nmos@59_poly-right##7 9.898
R1456 NAND1_to_NAND3#14nmos@59_poly-right##7 NAND1_to_NAND3#14nmos@59_poly-right##8 9.898
R1457 NAND1_to_NAND3#14nmos@59_poly-right##8 NAND1_to_NAND3#14nmos@59_poly-right##9 9.898
R1458 NAND1_to_NAND3#14nmos@59_poly-right##9 NAND1_to_NAND3#14nmos@59_poly-right##10 9.898
R1459 NAND1_to_NAND3#14nmos@59_poly-right##10 NAND1_to_NAND3#14nmos@59_poly-right##11 9.898
R1460 NAND1_to_NAND3#14nmos@59_poly-right##11 NAND1_to_NAND3#14nmos@59_poly-right##12 9.898
R1461 NAND1_to_NAND3#14nmos@59_poly-right##12 NAND1_to_NAND3#14nmos@59_poly-right##13 9.898
R1462 NAND1_to_NAND3#14nmos@59_poly-right##13 NAND1_to_NAND3#14nmos@59_poly-right##14 9.898
R1463 NAND1_to_NAND3#14nmos@59_poly-right##14 NAND1_to_NAND3#14nmos@59_poly-right##15 9.898
R1464 NAND1_to_NAND3#14nmos@59_poly-right##15 NAND1_to_NAND3#14nmos@59_poly-right##16 9.898
R1465 NAND1_to_NAND3#14nmos@59_poly-right##16 NAND1_to_NAND3#14nmos@59_poly-right##17 9.898
R1466 NAND1_to_NAND3#14nmos@59_poly-right##17 NAND1_to_NAND3#14nmos@59_poly-right##18 9.898
R1467 NAND1_to_NAND3#14nmos@59_poly-right##18 NAND1_to_NAND3#14nmos@59_poly-right##19 9.898
R1468 NAND1_to_NAND3#14nmos@59_poly-right##19 NAND1_to_NAND3#14nmos@59_poly-right##20 9.898
R1469 NAND1_to_NAND3#14nmos@59_poly-right##20 NAND1_to_NAND3#14nmos@59_poly-right##21 9.898
R1470 NAND1_to_NAND3#14nmos@59_poly-right##21 NAND1_to_NAND3#14nmos@59_poly-right##22 9.898
R1471 NAND1_to_NAND3#14nmos@59_poly-right##22 NAND1_to_NAND3#14nmos@59_poly-right##23 9.898
R1472 NAND1_to_NAND3#14nmos@59_poly-right##23 NAND1_to_NAND3#14nmos@59_poly-right##24 9.898
R1473 NAND1_to_NAND3#14nmos@59_poly-right##24 NAND1_to_NAND3#14nmos@59_poly-right##25 9.898
R1474 NAND1_to_NAND3#14nmos@59_poly-right##25 NAND1_to_NAND3#14nmos@59_poly-right##26 9.898
R1475 NAND1_to_NAND3#14nmos@59_poly-right##26 NAND1_to_NAND3#14nmos@59_poly-right##27 9.898
R1476 NAND1_to_NAND3#14nmos@59_poly-right##27 NAND1_to_NAND3#14nmos@59_poly-right##28 9.898
R1477 NAND1_to_NAND3#14nmos@59_poly-right##28 NAND1_to_NAND3#14nmos@59_poly-right##29 9.898
R1478 NAND1_to_NAND3#14nmos@59_poly-right##29 NAND1_to_NAND3#14nmos@59_poly-right##30 9.898
R1479 NAND1_to_NAND3#14nmos@59_poly-right##30 NAND1_to_NAND3#14nmos@59_poly-right##31 9.898
R1480 NAND1_to_NAND3#14nmos@59_poly-right##31 NAND1_to_NAND3#14nmos@59_poly-right##32 9.898
R1481 NAND1_to_NAND3#14nmos@59_poly-right##32 NAND1_to_NAND3#14nmos@59_poly-right##33 9.898
R1482 NAND1_to_NAND3#14nmos@59_poly-right##33 NAND1_to_NAND3#14nmos@59_poly-right##34 9.898
R1483 NAND1_to_NAND3#14nmos@59_poly-right##34 NAND1_to_NAND3#14nmos@59_poly-right##35 9.898
R1484 NAND1_to_NAND3#14nmos@59_poly-right##35 NAND1_to_NAND3#14nmos@59_poly-right##36 9.898
R1485 NAND1_to_NAND3#14nmos@59_poly-right##36 NAND1_to_NAND3#14nmos@59_poly-right##37 9.898
R1486 NAND1_to_NAND3#14nmos@59_poly-right##37 NAND1_to_NAND3#14nmos@59_poly-right##38 9.898
R1487 NAND1_to_NAND3#14nmos@59_poly-right##38 NAND1_to_NAND3#14nmos@59_poly-right##39 9.898
R1488 NAND1_to_NAND3#14nmos@59_poly-right##39 NAND1_to_NAND3#14nmos@59_poly-right##40 9.898
R1489 NAND1_to_NAND3#14nmos@59_poly-right##40 NAND1_to_NAND3#14nmos@59_poly-right##41 9.898
R1490 NAND1_to_NAND3#14nmos@59_poly-right##41 NAND1_to_NAND3#14nmos@59_poly-right##42 9.898
R1491 NAND1_to_NAND3#14nmos@59_poly-right##42 NAND1_to_NAND3#14nmos@59_poly-right##43 9.898
R1492 NAND1_to_NAND3#14nmos@59_poly-right##43 NAND1_to_NAND3#14nmos@59_poly-right##44 9.898
R1493 NAND1_to_NAND3#14nmos@59_poly-right##44 NAND1_to_NAND3#14nmos@59_poly-right##45 9.898
R1494 NAND1_to_NAND3#14nmos@59_poly-right##45 NAND1_to_NAND3#14nmos@59_poly-right##46 9.898
R1495 NAND1_to_NAND3#14nmos@59_poly-right##46 NAND1_to_NAND3#14nmos@59_poly-right##47 9.898
R1496 NAND1_to_NAND3#14nmos@59_poly-right##47 NAND1_to_NAND3#14nmos@59_poly-right##48 9.898
R1497 NAND1_to_NAND3#14nmos@59_poly-right##48 NAND1_to_NAND3#14nmos@59_poly-right##49 9.898
R1498 NAND1_to_NAND3#14nmos@59_poly-right##49 NAND1_to_NAND3#14nmos@59_poly-right##50 9.898
R1499 NAND1_to_NAND3#14nmos@59_poly-right##50 NAND1_to_NAND3#14nmos@59_poly-right##51 9.898
R1500 NAND1_to_NAND3#14nmos@59_poly-right##51 NAND1_to_NAND3#14nmos@59_poly-right##52 9.898
R1501 NAND1_to_NAND3#14nmos@59_poly-right##52 NAND1_to_NAND3#14nmos@59_poly-right##53 9.898
R1502 NAND1_to_NAND3#14nmos@59_poly-right##53 NAND1_to_NAND3#14nmos@59_poly-right##54 9.898
R1503 NAND1_to_NAND3#14nmos@59_poly-right##54 NAND1_to_NAND3#14nmos@59_poly-right##55 9.898
R1504 NAND1_to_NAND3#14nmos@59_poly-right##55 NAND1_to_NAND3#11pmos@59_poly-right 9.898
R1505 NAND2_to_Nand3 NAND2_to_Nand3#4nmos@57_diff-bottom 4.42
R1506 net@1209 net@1209##0 9.92
R1507 net@1209##0 net@1209##1 9.92
R1508 net@1209##1 net@1209##2 9.92
R1509 net@1209##2 net@1209##3 9.92
R1510 net@1209##3 net@1209##4 9.92
R1511 net@1209##4 net@1209##5 9.92
R1512 net@1209##5 net@1209##6 9.92
R1513 net@1209##6 net@1209##7 9.92
R1514 net@1209##7 net@1209##8 9.92
R1515 net@1209##8 net@1209##9 9.92
R1516 net@1209##9 net@1209##10 9.92
R1517 net@1209##10 net@1209##11 9.92
R1518 net@1209##11 net@1209##12 9.92
R1519 net@1209##12 net@1209##13 9.92
R1520 net@1209##13 net@1209##14 9.92
R1521 net@1209##14 net@1209##15 9.92
R1522 net@1209##15 net@1209##16 9.92
R1523 net@1209##16 net@1209##17 9.92
R1524 net@1209##17 net@1209##18 9.92
R1525 net@1209##18 net@1209#1pin@352_polysilicon-1 9.92
R1526 net@1211 net@1211##0 9.92
R1527 net@1211##0 net@1211##1 9.92
R1528 net@1211##1 net@1211##2 9.92
R1529 net@1211##2 net@1211##3 9.92
R1530 net@1211##3 net@1211##4 9.92
R1531 net@1211##4 net@1211##5 9.92
R1532 net@1211##5 net@1211##6 9.92
R1533 net@1211##6 net@1211##7 9.92
R1534 net@1211##7 net@1211##8 9.92
R1535 net@1211##8 net@1211##9 9.92
R1536 net@1211##9 net@1211##10 9.92
R1537 net@1211##10 net@1211##11 9.92
R1538 net@1211##11 net@1211##12 9.92
R1539 net@1211##12 net@1211##13 9.92
R1540 net@1211##13 net@1211##14 9.92
R1541 net@1211##14 net@1211##15 9.92
R1542 net@1211##15 net@1211##16 9.92
R1543 net@1211##16 net@1211##17 9.92
R1544 net@1211##17 net@1211##18 9.92
R1545 net@1211##18 net@1211#1pin@377_polysilicon-1 9.92
R1546 XOR1_to_NAND2#3pin@378_polysilicon-1 XOR1_to_NAND2#3pin@378_polysilicon-1##0 6.2
R1547 XOR1_to_NAND2#3pin@378_polysilicon-1##0 XOR1_to_NAND2#4pmos@72_poly-right 6.2
R1548 XOR1_to_NAND2#3pin@378_polysilicon-1 XOR1_to_NAND2#3pin@378_polysilicon-1##0 8.138
R1549 XOR1_to_NAND2#3pin@378_polysilicon-1##0 XOR1_to_NAND2#3pin@378_polysilicon-1##1 8.138
R1550 XOR1_to_NAND2#3pin@378_polysilicon-1##1 XOR1_to_NAND2#3pin@378_polysilicon-1##2 8.138
R1551 XOR1_to_NAND2#3pin@378_polysilicon-1##2 XOR1_to_NAND2#1contact@544_metal-1-metal-2 8.138
R1552 Cin_to_XOR2___NAND2#14nmos@71_poly-right Cin_to_XOR2___NAND2#14nmos@71_poly-right##0 5.425
R1553 Cin_to_XOR2___NAND2#14nmos@71_poly-right##0 Cin_to_XOR2___NAND2#15pin@368_polysilicon-1 5.425
R1554 Cin_to_XOR2___NAND2 Cin_to_XOR2___NAND2##0 8.99
R1555 Cin_to_XOR2___NAND2##0 Cin_to_XOR2___NAND2##1 8.99
R1556 Cin_to_XOR2___NAND2##1 Cin_to_XOR2___NAND2##2 8.99
R1557 Cin_to_XOR2___NAND2##2 Cin_to_XOR2___NAND2##3 8.99
R1558 Cin_to_XOR2___NAND2##3 Cin_to_XOR2___NAND2#15pin@368_polysilicon-1 8.99
R1559 A1#4pin@353_polysilicon-1 A1#4pin@353_polysilicon-1##0 6.2
R1560 A1#4pin@353_polysilicon-1##0 A1#5pmos@65_poly-right 6.2
R1561 XOR1_to_NAND2#9pmos@67_poly-left XOR1_to_NAND2#9pmos@67_poly-left##0 8.138
R1562 XOR1_to_NAND2#9pmos@67_poly-left##0 XOR1_to_NAND2#9pmos@67_poly-left##1 8.138
R1563 XOR1_to_NAND2#9pmos@67_poly-left##1 XOR1_to_NAND2#9pmos@67_poly-left##2 8.138
R1564 XOR1_to_NAND2#9pmos@67_poly-left##2 XOR1_to_NAND2#10pin@365_polysilicon-1 8.138
R1565 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##0 9.843
R1566 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##0 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##1 9.843
R1567 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##1 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##2 9.843
R1568 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##2 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##3 9.843
R1569 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##3 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##4 9.843
R1570 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##4 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##5 9.843
R1571 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##5 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##6 9.843
R1572 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##6 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##7 9.843
R1573 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##7 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##8 9.843
R1574 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##8 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##9 9.843
R1575 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##9 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##10 9.843
R1576 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##10 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##11 9.843
R1577 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##11 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##12 9.843
R1578 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##12 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##13 9.843
R1579 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##13 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##14 9.843
R1580 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##14 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##15 9.843
R1581 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##15 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##16 9.843
R1582 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##16 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##17 9.843
R1583 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##17 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##18 9.843
R1584 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1##18 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1 9.843
R1585 net@1220#4nmos@73_poly-right net@1220#4nmos@73_poly-right##0 9.3
R1586 net@1220#4nmos@73_poly-right##0 net@1220#4nmos@73_poly-right##1 9.3
R1587 net@1220#4nmos@73_poly-right##1 net@1220#5pin@370_polysilicon-1 9.3
R1588 net@1220#2contact@530_metal-1-polysilicon-1 net@1220#2contact@530_metal-1-polysilicon-1##0 8.99
R1589 net@1220#2contact@530_metal-1-polysilicon-1##0 net@1220#2contact@530_metal-1-polysilicon-1##1 8.99
R1590 net@1220#2contact@530_metal-1-polysilicon-1##1 net@1220#2contact@530_metal-1-polysilicon-1##2 8.99
R1591 net@1220#2contact@530_metal-1-polysilicon-1##2 net@1220#2contact@530_metal-1-polysilicon-1##3 8.99
R1592 net@1220#2contact@530_metal-1-polysilicon-1##3 net@1220#5pin@370_polysilicon-1 8.99
R1593 A1#4pin@353_polysilicon-1 A1#4pin@353_polysilicon-1##0 8.138
R1594 A1#4pin@353_polysilicon-1##0 A1#4pin@353_polysilicon-1##1 8.138
R1595 A1#4pin@353_polysilicon-1##1 A1#4pin@353_polysilicon-1##2 8.138
R1596 A1#4pin@353_polysilicon-1##2 A1#1pin@517_metal-2 8.138
R1597 XOR1_to_NAND2#1contact@544_metal-1-metal-2 XOR1_to_NAND2#1contact@544_metal-1-metal-2##0 6.717
R1598 XOR1_to_NAND2#1contact@544_metal-1-metal-2##0 XOR1_to_NAND2#1contact@544_metal-1-metal-2##1 6.717
R1599 XOR1_to_NAND2#1contact@544_metal-1-metal-2##1 XOR1_to_NAND2#12pin@366_polysilicon-1 6.717
R1600 XOR1_to_NAND2#10pin@365_polysilicon-1 XOR1_to_NAND2#10pin@365_polysilicon-1##0 7.75
R1601 XOR1_to_NAND2#10pin@365_polysilicon-1##0 XOR1_to_NAND2#10pin@365_polysilicon-1##1 7.75
R1602 XOR1_to_NAND2#10pin@365_polysilicon-1##1 XOR1_to_NAND2#12pin@366_polysilicon-1 7.75
R1603 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1##0 9.743
R1604 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1##0 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1##1 9.743
R1605 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1##1 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1##2 9.743
R1606 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1##2 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1##3 9.743
R1607 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1##3 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1##4 9.743
R1608 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1##4 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1##5 9.743
R1609 Cin_to_XOR2___NAND2#17pin@375_polysilicon-1##5 Cin_to_XOR2___NAND2 9.743
R1610 net@1211#7pmos@68_poly-left net@1211#7pmos@68_poly-left##0 7.75
R1611 net@1211#7pmos@68_poly-left##0 net@1211 7.75
R1612 Cin_to_XOR2___NAND2#18nmos@69_poly-left Cin_to_XOR2___NAND2#18nmos@69_poly-left##0 6.2
R1613 Cin_to_XOR2___NAND2#18nmos@69_poly-left##0 Cin_to_XOR2___NAND2#16pin@358_polysilicon-1 6.2
R1614 net@1221#9nmos@70_poly-left net@1221#9nmos@70_poly-left##0 8.37
R1615 net@1221#9nmos@70_poly-left##0 net@1221#9nmos@70_poly-left##1 8.37
R1616 net@1221#9nmos@70_poly-left##1 net@1221#9nmos@70_poly-left##2 8.37
R1617 net@1221#9nmos@70_poly-left##2 net@1221#9nmos@70_poly-left##3 8.37
R1618 net@1221#9nmos@70_poly-left##3 net@1221#2contact@505_metal-1-metal-2 8.37
R1619 XOR1_to_NAND2 XOR1_to_NAND2##0 6.717
R1620 XOR1_to_NAND2##0 XOR1_to_NAND2##1 6.717
R1621 XOR1_to_NAND2##1 XOR1_to_NAND2#14pin@382_polysilicon-1 6.717
R1622 XOR1_to_NAND2#16pmos@74_poly-right XOR1_to_NAND2#16pmos@74_poly-right##0 6.2
R1623 XOR1_to_NAND2#16pmos@74_poly-right##0 XOR1_to_NAND2#14pin@382_polysilicon-1 6.2
R1624 Cin_to_XOR2___NAND2#23pin@386_polysilicon-1 Cin_to_XOR2___NAND2#23pin@386_polysilicon-1##0 9.688
R1625 Cin_to_XOR2___NAND2#23pin@386_polysilicon-1##0 Cin_to_XOR2___NAND2#23pin@386_polysilicon-1##1 9.688
R1626 Cin_to_XOR2___NAND2#23pin@386_polysilicon-1##1 Cin_to_XOR2___NAND2#23pin@386_polysilicon-1##2 9.688
R1627 Cin_to_XOR2___NAND2#23pin@386_polysilicon-1##2 Cin_to_XOR2___NAND2#20contact@543_metal-1-metal-2 9.688
R1628 Cin_to_XOR2___NAND2#20contact@543_metal-1-metal-2 Cin_to_XOR2___NAND2 4.953
R1629 A1#2contact@552_metal-1-metal-2 A1#2contact@552_metal-1-metal-2##0 6.717
R1630 A1#2contact@552_metal-1-metal-2##0 A1#2contact@552_metal-1-metal-2##1 6.717
R1631 A1#2contact@552_metal-1-metal-2##1 A1#11pin@389_polysilicon-1 6.717
R1632 A1#12pmos@76_poly-right A1#12pmos@76_poly-right##0 9.558
R1633 A1#12pmos@76_poly-right##0 A1#12pmos@76_poly-right##1 9.558
R1634 A1#12pmos@76_poly-right##1 A1#12pmos@76_poly-right##2 9.558
R1635 A1#12pmos@76_poly-right##2 A1#12pmos@76_poly-right##3 9.558
R1636 A1#12pmos@76_poly-right##3 A1#12pmos@76_poly-right##4 9.558
R1637 A1#12pmos@76_poly-right##4 A1#11pin@389_polysilicon-1 9.558
R1638 B1#11pin@393_polysilicon-1 B1#11pin@393_polysilicon-1##0 8.138
R1639 B1#11pin@393_polysilicon-1##0 B1#11pin@393_polysilicon-1##1 8.138
R1640 B1#11pin@393_polysilicon-1##1 B1#11pin@393_polysilicon-1##2 8.138
R1641 B1#11pin@393_polysilicon-1##2 B1#2contact@553_metal-1-metal-2 8.138
R1642 B1#12nmos@64_poly-right B1#12nmos@64_poly-right##0 5.425
R1643 B1#12nmos@64_poly-right##0 B1#13pin@343_polysilicon-1 5.425
R1644 NAND2_to_Nand4 NAND2_to_Nand4##0 6.717
R1645 NAND2_to_Nand4##0 NAND2_to_Nand4##1 6.717
R1646 NAND2_to_Nand4##1 NAND2_to_Nand4#9pin@395_polysilicon-1 6.717
R1647 NAND2_to_Nand4#10pmos@78_poly-right NAND2_to_Nand4#10pmos@78_poly-right##0 9.558
R1648 NAND2_to_Nand4#10pmos@78_poly-right##0 NAND2_to_Nand4#10pmos@78_poly-right##1 9.558
R1649 NAND2_to_Nand4#10pmos@78_poly-right##1 NAND2_to_Nand4#10pmos@78_poly-right##2 9.558
R1650 NAND2_to_Nand4#10pmos@78_poly-right##2 NAND2_to_Nand4#10pmos@78_poly-right##3 9.558
R1651 NAND2_to_Nand4#10pmos@78_poly-right##3 NAND2_to_Nand4#10pmos@78_poly-right##4 9.558
R1652 NAND2_to_Nand4#10pmos@78_poly-right##4 NAND2_to_Nand4#9pin@395_polysilicon-1 9.558
R1653 B1#0pin@508_metal-2 B1#0pin@508_metal-2##0 8.99
R1654 B1#0pin@508_metal-2##0 B1#0pin@508_metal-2##1 8.99
R1655 B1#0pin@508_metal-2##1 B1#0pin@508_metal-2##2 8.99
R1656 B1#0pin@508_metal-2##2 B1#0pin@508_metal-2##3 8.99
R1657 B1#0pin@508_metal-2##3 B1#13pin@343_polysilicon-1 8.99
R1658 NAND1_to_NAND4#11pmos@79_poly-right NAND1_to_NAND4#11pmos@79_poly-right##0 5.425
R1659 NAND1_to_NAND4#11pmos@79_poly-right##0 NAND1_to_NAND4#12pin@399_polysilicon-1 5.425
R1660 NAND1_to_NAND4#12pin@399_polysilicon-1 NAND1_to_NAND4#12pin@399_polysilicon-1##0 9.3
R1661 NAND1_to_NAND4#12pin@399_polysilicon-1##0 NAND1_to_NAND4#12pin@399_polysilicon-1##1 9.3
R1662 NAND1_to_NAND4#12pin@399_polysilicon-1##1 NAND1_to_NAND4 9.3
R1663 Cin_to_XOR2___NAND2#25nmos@75_poly-right Cin_to_XOR2___NAND2#25nmos@75_poly-right##0 8.636
R1664 Cin_to_XOR2___NAND2#25nmos@75_poly-right##0 Cin_to_XOR2___NAND2#25nmos@75_poly-right##1 8.636
R1665 Cin_to_XOR2___NAND2#25nmos@75_poly-right##1 Cin_to_XOR2___NAND2#25nmos@75_poly-right##2 8.636
R1666 Cin_to_XOR2___NAND2#25nmos@75_poly-right##2 Cin_to_XOR2___NAND2#25nmos@75_poly-right##3 8.636
R1667 Cin_to_XOR2___NAND2#25nmos@75_poly-right##3 Cin_to_XOR2___NAND2#25nmos@75_poly-right##4 8.636
R1668 Cin_to_XOR2___NAND2#25nmos@75_poly-right##4 Cin_to_XOR2___NAND2#25nmos@75_poly-right##5 8.636
R1669 Cin_to_XOR2___NAND2#25nmos@75_poly-right##5 Cin_to_XOR2___NAND2#23pin@386_polysilicon-1 8.636
R1670 B1#14nmos@77_poly-right B1#14nmos@77_poly-right##0 8.956
R1671 B1#14nmos@77_poly-right##0 B1#14nmos@77_poly-right##1 8.956
R1672 B1#14nmos@77_poly-right##1 B1#14nmos@77_poly-right##2 8.956
R1673 B1#14nmos@77_poly-right##2 B1#14nmos@77_poly-right##3 8.956
R1674 B1#14nmos@77_poly-right##3 B1#14nmos@77_poly-right##4 8.956
R1675 B1#14nmos@77_poly-right##4 B1#14nmos@77_poly-right##5 8.956
R1676 B1#14nmos@77_poly-right##5 B1#14nmos@77_poly-right##6 8.956
R1677 B1#14nmos@77_poly-right##6 B1#14nmos@77_poly-right##7 8.956
R1678 B1#14nmos@77_poly-right##7 B1#11pin@393_polysilicon-1 8.956
R1679 A1#13pmos@60_poly-left A1#13pmos@60_poly-left##0 8.138
R1680 A1#13pmos@60_poly-left##0 A1#13pmos@60_poly-left##1 8.138
R1681 A1#13pmos@60_poly-left##1 A1#13pmos@60_poly-left##2 8.138
R1682 A1#13pmos@60_poly-left##2 A1#14pin@340_polysilicon-1 8.138
R1683 B1#15pin@333_polysilicon-1 B1#15pin@333_polysilicon-1##0 9.843
R1684 B1#15pin@333_polysilicon-1##0 B1#15pin@333_polysilicon-1##1 9.843
R1685 B1#15pin@333_polysilicon-1##1 B1#15pin@333_polysilicon-1##2 9.843
R1686 B1#15pin@333_polysilicon-1##2 B1#15pin@333_polysilicon-1##3 9.843
R1687 B1#15pin@333_polysilicon-1##3 B1#15pin@333_polysilicon-1##4 9.843
R1688 B1#15pin@333_polysilicon-1##4 B1#15pin@333_polysilicon-1##5 9.843
R1689 B1#15pin@333_polysilicon-1##5 B1#15pin@333_polysilicon-1##6 9.843
R1690 B1#15pin@333_polysilicon-1##6 B1#15pin@333_polysilicon-1##7 9.843
R1691 B1#15pin@333_polysilicon-1##7 B1#15pin@333_polysilicon-1##8 9.843
R1692 B1#15pin@333_polysilicon-1##8 B1#15pin@333_polysilicon-1##9 9.843
R1693 B1#15pin@333_polysilicon-1##9 B1#15pin@333_polysilicon-1##10 9.843
R1694 B1#15pin@333_polysilicon-1##10 B1#15pin@333_polysilicon-1##11 9.843
R1695 B1#15pin@333_polysilicon-1##11 B1#15pin@333_polysilicon-1##12 9.843
R1696 B1#15pin@333_polysilicon-1##12 B1#15pin@333_polysilicon-1##13 9.843
R1697 B1#15pin@333_polysilicon-1##13 B1#15pin@333_polysilicon-1##14 9.843
R1698 B1#15pin@333_polysilicon-1##14 B1#15pin@333_polysilicon-1##15 9.843
R1699 B1#15pin@333_polysilicon-1##15 B1#15pin@333_polysilicon-1##16 9.843
R1700 B1#15pin@333_polysilicon-1##16 B1#15pin@333_polysilicon-1##17 9.843
R1701 B1#15pin@333_polysilicon-1##17 B1#15pin@333_polysilicon-1##18 9.843
R1702 B1#15pin@333_polysilicon-1##18 B1#16pin@350_polysilicon-1 9.843
R1703 net@1307#4nmos@66_poly-right net@1307#4nmos@66_poly-right##0 7.233
R1704 net@1307#4nmos@66_poly-right##0 net@1307#4nmos@66_poly-right##1 7.233
R1705 net@1307#4nmos@66_poly-right##1 net@1307#5pin@345_polysilicon-1 7.233
R1706 net@1307#2contact@491_metal-1-polysilicon-1 net@1307#2contact@491_metal-1-polysilicon-1##0 8.99
R1707 net@1307#2contact@491_metal-1-polysilicon-1##0 net@1307#2contact@491_metal-1-polysilicon-1##1 8.99
R1708 net@1307#2contact@491_metal-1-polysilicon-1##1 net@1307#2contact@491_metal-1-polysilicon-1##2 8.99
R1709 net@1307#2contact@491_metal-1-polysilicon-1##2 net@1307#2contact@491_metal-1-polysilicon-1##3 8.99
R1710 net@1307#2contact@491_metal-1-polysilicon-1##3 net@1307#5pin@345_polysilicon-1 8.99
R1711 A1#1pin@517_metal-2 A1#1pin@517_metal-2##0 6.717
R1712 A1#1pin@517_metal-2##0 A1#1pin@517_metal-2##1 6.717
R1713 A1#1pin@517_metal-2##1 A1#16pin@341_polysilicon-1 6.717
R1714 A1#14pin@340_polysilicon-1 A1#14pin@340_polysilicon-1##0 7.75
R1715 A1#14pin@340_polysilicon-1##0 A1#14pin@340_polysilicon-1##1 7.75
R1716 A1#14pin@340_polysilicon-1##1 A1#16pin@341_polysilicon-1 7.75
R1717 B1#16pin@350_polysilicon-1 B1#16pin@350_polysilicon-1##0 9.743
R1718 B1#16pin@350_polysilicon-1##0 B1#16pin@350_polysilicon-1##1 9.743
R1719 B1#16pin@350_polysilicon-1##1 B1#16pin@350_polysilicon-1##2 9.743
R1720 B1#16pin@350_polysilicon-1##2 B1#16pin@350_polysilicon-1##3 9.743
R1721 B1#16pin@350_polysilicon-1##3 B1#16pin@350_polysilicon-1##4 9.743
R1722 B1#16pin@350_polysilicon-1##4 B1#16pin@350_polysilicon-1##5 9.743
R1723 B1#16pin@350_polysilicon-1##5 B1#0pin@508_metal-2 9.743
R1724 net@1209#7pmos@61_poly-left net@1209#7pmos@61_poly-left##0 7.75
R1725 net@1209#7pmos@61_poly-left##0 net@1209 7.75
R1726 B1#17nmos@62_poly-left B1#17nmos@62_poly-left##0 6.2
R1727 B1#17nmos@62_poly-left##0 B1#15pin@333_polysilicon-1 6.2
R1728 net@1314#9nmos@63_poly-left net@1314#9nmos@63_poly-left##0 8.37
R1729 net@1314#9nmos@63_poly-left##0 net@1314#9nmos@63_poly-left##1 8.37
R1730 net@1314#9nmos@63_poly-left##1 net@1314#9nmos@63_poly-left##2 8.37
R1731 net@1314#9nmos@63_poly-left##2 net@1314#9nmos@63_poly-left##3 8.37
R1732 net@1314#9nmos@63_poly-left##3 net@1314#2contact@466_metal-1-metal-2 8.37
R1733 A1#4pin@353_polysilicon-1 A1#4pin@353_polysilicon-1##0 9.881
R1734 A1#4pin@353_polysilicon-1##0 A1#4pin@353_polysilicon-1##1 9.881
R1735 A1#4pin@353_polysilicon-1##1 A1#4pin@353_polysilicon-1##2 9.881
R1736 A1#4pin@353_polysilicon-1##2 A1#4pin@353_polysilicon-1##3 9.881
R1737 A1#4pin@353_polysilicon-1##3 A1#4pin@353_polysilicon-1##4 9.881
R1738 A1#4pin@353_polysilicon-1##4 A1#4pin@353_polysilicon-1##5 9.881
R1739 A1#4pin@353_polysilicon-1##5 A1#4pin@353_polysilicon-1##6 9.881
R1740 A1#4pin@353_polysilicon-1##6 A1#4pin@353_polysilicon-1##7 9.881
R1741 A1#4pin@353_polysilicon-1##7 A1#4pin@353_polysilicon-1##8 9.881
R1742 A1#4pin@353_polysilicon-1##8 A1#4pin@353_polysilicon-1##9 9.881
R1743 A1#4pin@353_polysilicon-1##9 A1#4pin@353_polysilicon-1##10 9.881
R1744 A1#4pin@353_polysilicon-1##10 A1#4pin@353_polysilicon-1##11 9.881
R1745 A1#4pin@353_polysilicon-1##11 A1#4pin@353_polysilicon-1##12 9.881
R1746 A1#4pin@353_polysilicon-1##12 A1#4pin@353_polysilicon-1##13 9.881
R1747 A1#4pin@353_polysilicon-1##13 A1#4pin@353_polysilicon-1##14 9.881
R1748 A1#4pin@353_polysilicon-1##14 A1#4pin@353_polysilicon-1##15 9.881
R1749 A1#4pin@353_polysilicon-1##15 A1#4pin@353_polysilicon-1##16 9.881
R1750 A1#4pin@353_polysilicon-1##16 A1#4pin@353_polysilicon-1##17 9.881
R1751 A1#4pin@353_polysilicon-1##17 A1#4pin@353_polysilicon-1##18 9.881
R1752 A1#4pin@353_polysilicon-1##18 A1#4pin@353_polysilicon-1##19 9.881
R1753 A1#4pin@353_polysilicon-1##19 A1#4pin@353_polysilicon-1##20 9.881
R1754 A1#4pin@353_polysilicon-1##20 A1#4pin@353_polysilicon-1##21 9.881
R1755 A1#4pin@353_polysilicon-1##21 A1#4pin@353_polysilicon-1##22 9.881
R1756 A1#4pin@353_polysilicon-1##22 A1#4pin@353_polysilicon-1##23 9.881
R1757 A1#4pin@353_polysilicon-1##23 A1#4pin@353_polysilicon-1##24 9.881
R1758 A1#4pin@353_polysilicon-1##24 A1#4pin@353_polysilicon-1##25 9.881
R1759 A1#4pin@353_polysilicon-1##25 A1#4pin@353_polysilicon-1##26 9.881
R1760 A1#4pin@353_polysilicon-1##26 A1#4pin@353_polysilicon-1##27 9.881
R1761 A1#4pin@353_polysilicon-1##27 A1#4pin@353_polysilicon-1##28 9.881
R1762 A1#4pin@353_polysilicon-1##28 A1#4pin@353_polysilicon-1##29 9.881
R1763 A1#4pin@353_polysilicon-1##29 A1#4pin@353_polysilicon-1##30 9.881
R1764 A1#4pin@353_polysilicon-1##30 A1#4pin@353_polysilicon-1##31 9.881
R1765 A1#4pin@353_polysilicon-1##31 A1#4pin@353_polysilicon-1##32 9.881
R1766 A1#4pin@353_polysilicon-1##32 A1#4pin@353_polysilicon-1##33 9.881
R1767 A1#4pin@353_polysilicon-1##33 A1#4pin@353_polysilicon-1##34 9.881
R1768 A1#4pin@353_polysilicon-1##34 A1#4pin@353_polysilicon-1##35 9.881
R1769 A1#4pin@353_polysilicon-1##35 A1#4pin@353_polysilicon-1##36 9.881
R1770 A1#4pin@353_polysilicon-1##36 A1#4pin@353_polysilicon-1##37 9.881
R1771 A1#4pin@353_polysilicon-1##37 A1#4pin@353_polysilicon-1##38 9.881
R1772 A1#4pin@353_polysilicon-1##38 A1#4pin@353_polysilicon-1##39 9.881
R1773 A1#4pin@353_polysilicon-1##39 A1#4pin@353_polysilicon-1##40 9.881
R1774 A1#4pin@353_polysilicon-1##40 A1#4pin@353_polysilicon-1##41 9.881
R1775 A1#4pin@353_polysilicon-1##41 A1#4pin@353_polysilicon-1##42 9.881
R1776 A1#4pin@353_polysilicon-1##42 A1#4pin@353_polysilicon-1##43 9.881
R1777 A1#4pin@353_polysilicon-1##43 A1#4pin@353_polysilicon-1##44 9.881
R1778 A1#4pin@353_polysilicon-1##44 A1#4pin@353_polysilicon-1##45 9.881
R1779 A1#4pin@353_polysilicon-1##45 A1#4pin@353_polysilicon-1##46 9.881
R1780 A1#4pin@353_polysilicon-1##46 A1#4pin@353_polysilicon-1##47 9.881
R1781 A1#4pin@353_polysilicon-1##47 A1#4pin@353_polysilicon-1##48 9.881
R1782 A1#4pin@353_polysilicon-1##48 A1#4pin@353_polysilicon-1##49 9.881
R1783 A1#4pin@353_polysilicon-1##49 A1#4pin@353_polysilicon-1##50 9.881
R1784 A1#4pin@353_polysilicon-1##50 A1#4pin@353_polysilicon-1##51 9.881
R1785 A1#4pin@353_polysilicon-1##51 A1#4pin@353_polysilicon-1##52 9.881
R1786 A1#4pin@353_polysilicon-1##52 A1#4pin@353_polysilicon-1##53 9.881
R1787 A1#4pin@353_polysilicon-1##53 A1#4pin@353_polysilicon-1##54 9.881
R1788 A1#4pin@353_polysilicon-1##54 A1#17nmos@65_poly-right 9.881
R1789 net@1209#5pmos@65_diff-top net@1209#2pin@342_metal-1 4.81
R1790 net@1209#1pin@352_polysilicon-1 net@1209#1pin@352_polysilicon-1##0 9.85
R1791 net@1209#1pin@352_polysilicon-1##0 net@1209#1pin@352_polysilicon-1##1 9.85
R1792 net@1209#1pin@352_polysilicon-1##1 net@1209#1pin@352_polysilicon-1##2 9.85
R1793 net@1209#1pin@352_polysilicon-1##2 net@1209#1pin@352_polysilicon-1##3 9.85
R1794 net@1209#1pin@352_polysilicon-1##3 net@1209#1pin@352_polysilicon-1##4 9.85
R1795 net@1209#1pin@352_polysilicon-1##4 net@1209#1pin@352_polysilicon-1##5 9.85
R1796 net@1209#1pin@352_polysilicon-1##5 net@1209#1pin@352_polysilicon-1##6 9.85
R1797 net@1209#1pin@352_polysilicon-1##6 net@1209#1pin@352_polysilicon-1##7 9.85
R1798 net@1209#1pin@352_polysilicon-1##7 net@1209#1pin@352_polysilicon-1##8 9.85
R1799 net@1209#1pin@352_polysilicon-1##8 net@1209#1pin@352_polysilicon-1##9 9.85
R1800 net@1209#1pin@352_polysilicon-1##9 net@1209#1pin@352_polysilicon-1##10 9.85
R1801 net@1209#1pin@352_polysilicon-1##10 net@1209#1pin@352_polysilicon-1##11 9.85
R1802 net@1209#1pin@352_polysilicon-1##11 net@1209#1pin@352_polysilicon-1##12 9.85
R1803 net@1209#1pin@352_polysilicon-1##12 net@1209#1pin@352_polysilicon-1##13 9.85
R1804 net@1209#1pin@352_polysilicon-1##13 net@1209#1pin@352_polysilicon-1##14 9.85
R1805 net@1209#1pin@352_polysilicon-1##14 net@1209#1pin@352_polysilicon-1##15 9.85
R1806 net@1209#1pin@352_polysilicon-1##15 net@1209#1pin@352_polysilicon-1##16 9.85
R1807 net@1209#1pin@352_polysilicon-1##16 net@1209#1pin@352_polysilicon-1##17 9.85
R1808 net@1209#1pin@352_polysilicon-1##17 net@1209#1pin@352_polysilicon-1##18 9.85
R1809 net@1209#1pin@352_polysilicon-1##18 net@1209#1pin@352_polysilicon-1##19 9.85
R1810 net@1209#1pin@352_polysilicon-1##19 net@1209#1pin@352_polysilicon-1##20 9.85
R1811 net@1209#1pin@352_polysilicon-1##20 net@1209#1pin@352_polysilicon-1##21 9.85
R1812 net@1209#1pin@352_polysilicon-1##21 net@1209#1pin@352_polysilicon-1##22 9.85
R1813 net@1209#1pin@352_polysilicon-1##22 net@1209#1pin@352_polysilicon-1##23 9.85
R1814 net@1209#1pin@352_polysilicon-1##23 net@1209#1pin@352_polysilicon-1##24 9.85
R1815 net@1209#1pin@352_polysilicon-1##24 net@1209#1pin@352_polysilicon-1##25 9.85
R1816 net@1209#1pin@352_polysilicon-1##25 net@1209#1pin@352_polysilicon-1##26 9.85
R1817 net@1209#1pin@352_polysilicon-1##26 net@1209#1pin@352_polysilicon-1##27 9.85
R1818 net@1209#1pin@352_polysilicon-1##27 net@1209#1pin@352_polysilicon-1##28 9.85
R1819 net@1209#1pin@352_polysilicon-1##28 net@1209#1pin@352_polysilicon-1##29 9.85
R1820 net@1209#1pin@352_polysilicon-1##29 net@1209#1pin@352_polysilicon-1##30 9.85
R1821 net@1209#1pin@352_polysilicon-1##30 net@1209#1pin@352_polysilicon-1##31 9.85
R1822 net@1209#1pin@352_polysilicon-1##31 net@1209#1pin@352_polysilicon-1##32 9.85
R1823 net@1209#1pin@352_polysilicon-1##32 net@1209#1pin@352_polysilicon-1##33 9.85
R1824 net@1209#1pin@352_polysilicon-1##33 net@1209#1pin@352_polysilicon-1##34 9.85
R1825 net@1209#1pin@352_polysilicon-1##34 net@1209#1pin@352_polysilicon-1##35 9.85
R1826 net@1209#1pin@352_polysilicon-1##35 net@1209#1pin@352_polysilicon-1##36 9.85
R1827 net@1209#1pin@352_polysilicon-1##36 net@1209#1pin@352_polysilicon-1##37 9.85
R1828 net@1209#1pin@352_polysilicon-1##37 net@1209#1pin@352_polysilicon-1##38 9.85
R1829 net@1209#1pin@352_polysilicon-1##38 net@1209#1pin@352_polysilicon-1##39 9.85
R1830 net@1209#1pin@352_polysilicon-1##39 net@1209#1pin@352_polysilicon-1##40 9.85
R1831 net@1209#1pin@352_polysilicon-1##40 net@1209#1pin@352_polysilicon-1##41 9.85
R1832 net@1209#1pin@352_polysilicon-1##41 net@1209#1pin@352_polysilicon-1##42 9.85
R1833 net@1209#1pin@352_polysilicon-1##42 net@1209#1pin@352_polysilicon-1##43 9.85
R1834 net@1209#1pin@352_polysilicon-1##43 net@1209#1pin@352_polysilicon-1##44 9.85
R1835 net@1209#1pin@352_polysilicon-1##44 net@1209#1pin@352_polysilicon-1##45 9.85
R1836 net@1209#1pin@352_polysilicon-1##45 net@1209#1pin@352_polysilicon-1##46 9.85
R1837 net@1209#1pin@352_polysilicon-1##46 net@1209#1pin@352_polysilicon-1##47 9.85
R1838 net@1209#1pin@352_polysilicon-1##47 net@1209#1pin@352_polysilicon-1##48 9.85
R1839 net@1209#1pin@352_polysilicon-1##48 net@1209#1pin@352_polysilicon-1##49 9.85
R1840 net@1209#1pin@352_polysilicon-1##49 net@1209#1pin@352_polysilicon-1##50 9.85
R1841 net@1209#1pin@352_polysilicon-1##50 net@1209#1pin@352_polysilicon-1##51 9.85
R1842 net@1209#1pin@352_polysilicon-1##51 net@1209#1pin@352_polysilicon-1##52 9.85
R1843 net@1209#1pin@352_polysilicon-1##52 net@1209#1pin@352_polysilicon-1##53 9.85
R1844 net@1209#1pin@352_polysilicon-1##53 net@1209#1pin@352_polysilicon-1##54 9.85
R1845 net@1209#1pin@352_polysilicon-1##54 net@1209#1pin@352_polysilicon-1##55 9.85
R1846 net@1209#1pin@352_polysilicon-1##55 net@1209#1pin@352_polysilicon-1##56 9.85
R1847 net@1209#1pin@352_polysilicon-1##56 net@1209#1pin@352_polysilicon-1##57 9.85
R1848 net@1209#1pin@352_polysilicon-1##57 net@1209#1pin@352_polysilicon-1##58 9.85
R1849 net@1209#1pin@352_polysilicon-1##58 net@1209#1pin@352_polysilicon-1##59 9.85
R1850 net@1209#1pin@352_polysilicon-1##59 net@1209#1pin@352_polysilicon-1##60 9.85
R1851 net@1209#1pin@352_polysilicon-1##60 net@1209#2pin@342_metal-1 9.85
R1852 B1#18pmos@64_poly-right B1#18pmos@64_poly-right##0 9.854
R1853 B1#18pmos@64_poly-right##0 B1#18pmos@64_poly-right##1 9.854
R1854 B1#18pmos@64_poly-right##1 B1#18pmos@64_poly-right##2 9.854
R1855 B1#18pmos@64_poly-right##2 B1#18pmos@64_poly-right##3 9.854
R1856 B1#18pmos@64_poly-right##3 B1#18pmos@64_poly-right##4 9.854
R1857 B1#18pmos@64_poly-right##4 B1#18pmos@64_poly-right##5 9.854
R1858 B1#18pmos@64_poly-right##5 B1#18pmos@64_poly-right##6 9.854
R1859 B1#18pmos@64_poly-right##6 B1#18pmos@64_poly-right##7 9.854
R1860 B1#18pmos@64_poly-right##7 B1#18pmos@64_poly-right##8 9.854
R1861 B1#18pmos@64_poly-right##8 B1#18pmos@64_poly-right##9 9.854
R1862 B1#18pmos@64_poly-right##9 B1#18pmos@64_poly-right##10 9.854
R1863 B1#18pmos@64_poly-right##10 B1#18pmos@64_poly-right##11 9.854
R1864 B1#18pmos@64_poly-right##11 B1#18pmos@64_poly-right##12 9.854
R1865 B1#18pmos@64_poly-right##12 B1#18pmos@64_poly-right##13 9.854
R1866 B1#18pmos@64_poly-right##13 B1#18pmos@64_poly-right##14 9.854
R1867 B1#18pmos@64_poly-right##14 B1#18pmos@64_poly-right##15 9.854
R1868 B1#18pmos@64_poly-right##15 B1#18pmos@64_poly-right##16 9.854
R1869 B1#18pmos@64_poly-right##16 B1#18pmos@64_poly-right##17 9.854
R1870 B1#18pmos@64_poly-right##17 B1#18pmos@64_poly-right##18 9.854
R1871 B1#18pmos@64_poly-right##18 B1#18pmos@64_poly-right##19 9.854
R1872 B1#18pmos@64_poly-right##19 B1#18pmos@64_poly-right##20 9.854
R1873 B1#18pmos@64_poly-right##20 B1#18pmos@64_poly-right##21 9.854
R1874 B1#18pmos@64_poly-right##21 B1#18pmos@64_poly-right##22 9.854
R1875 B1#18pmos@64_poly-right##22 B1#18pmos@64_poly-right##23 9.854
R1876 B1#18pmos@64_poly-right##23 B1#18pmos@64_poly-right##24 9.854
R1877 B1#18pmos@64_poly-right##24 B1#18pmos@64_poly-right##25 9.854
R1878 B1#18pmos@64_poly-right##25 B1#18pmos@64_poly-right##26 9.854
R1879 B1#18pmos@64_poly-right##26 B1#18pmos@64_poly-right##27 9.854
R1880 B1#18pmos@64_poly-right##27 B1#18pmos@64_poly-right##28 9.854
R1881 B1#18pmos@64_poly-right##28 B1#18pmos@64_poly-right##29 9.854
R1882 B1#18pmos@64_poly-right##29 B1#18pmos@64_poly-right##30 9.854
R1883 B1#18pmos@64_poly-right##30 B1#18pmos@64_poly-right##31 9.854
R1884 B1#18pmos@64_poly-right##31 B1#18pmos@64_poly-right##32 9.854
R1885 B1#18pmos@64_poly-right##32 B1#18pmos@64_poly-right##33 9.854
R1886 B1#18pmos@64_poly-right##33 B1#18pmos@64_poly-right##34 9.854
R1887 B1#18pmos@64_poly-right##34 B1#18pmos@64_poly-right##35 9.854
R1888 B1#18pmos@64_poly-right##35 B1#18pmos@64_poly-right##36 9.854
R1889 B1#18pmos@64_poly-right##36 B1#18pmos@64_poly-right##37 9.854
R1890 B1#18pmos@64_poly-right##37 B1#18pmos@64_poly-right##38 9.854
R1891 B1#18pmos@64_poly-right##38 B1#18pmos@64_poly-right##39 9.854
R1892 B1#18pmos@64_poly-right##39 B1#18pmos@64_poly-right##40 9.854
R1893 B1#18pmos@64_poly-right##40 B1#18pmos@64_poly-right##41 9.854
R1894 B1#18pmos@64_poly-right##41 B1#18pmos@64_poly-right##42 9.854
R1895 B1#18pmos@64_poly-right##42 B1#18pmos@64_poly-right##43 9.854
R1896 B1#18pmos@64_poly-right##43 B1#18pmos@64_poly-right##44 9.854
R1897 B1#18pmos@64_poly-right##44 B1#18pmos@64_poly-right##45 9.854
R1898 B1#18pmos@64_poly-right##45 B1#18pmos@64_poly-right##46 9.854
R1899 B1#18pmos@64_poly-right##46 B1#18pmos@64_poly-right##47 9.854
R1900 B1#18pmos@64_poly-right##47 B1#18pmos@64_poly-right##48 9.854
R1901 B1#18pmos@64_poly-right##48 B1#18pmos@64_poly-right##49 9.854
R1902 B1#18pmos@64_poly-right##49 B1#18pmos@64_poly-right##50 9.854
R1903 B1#18pmos@64_poly-right##50 B1#18pmos@64_poly-right##51 9.854
R1904 B1#18pmos@64_poly-right##51 B1#18pmos@64_poly-right##52 9.854
R1905 B1#18pmos@64_poly-right##52 B1#18pmos@64_poly-right##53 9.854
R1906 B1#18pmos@64_poly-right##53 B1#18pmos@64_poly-right##54 9.854
R1907 B1#18pmos@64_poly-right##54 B1#13pin@343_polysilicon-1 9.854
R1908 net@1314 net@1314#2contact@466_metal-1-metal-2 4.797
R1909 A1#18nmos@60_poly-right A1#18nmos@60_poly-right##0 9.871
R1910 A1#18nmos@60_poly-right##0 A1#18nmos@60_poly-right##1 9.871
R1911 A1#18nmos@60_poly-right##1 A1#18nmos@60_poly-right##2 9.871
R1912 A1#18nmos@60_poly-right##2 A1#18nmos@60_poly-right##3 9.871
R1913 A1#18nmos@60_poly-right##3 A1#18nmos@60_poly-right##4 9.871
R1914 A1#18nmos@60_poly-right##4 A1#18nmos@60_poly-right##5 9.871
R1915 A1#18nmos@60_poly-right##5 A1#18nmos@60_poly-right##6 9.871
R1916 A1#18nmos@60_poly-right##6 A1#18nmos@60_poly-right##7 9.871
R1917 A1#18nmos@60_poly-right##7 A1#18nmos@60_poly-right##8 9.871
R1918 A1#18nmos@60_poly-right##8 A1#18nmos@60_poly-right##9 9.871
R1919 A1#18nmos@60_poly-right##9 A1#18nmos@60_poly-right##10 9.871
R1920 A1#18nmos@60_poly-right##10 A1#18nmos@60_poly-right##11 9.871
R1921 A1#18nmos@60_poly-right##11 A1#18nmos@60_poly-right##12 9.871
R1922 A1#18nmos@60_poly-right##12 A1#18nmos@60_poly-right##13 9.871
R1923 A1#18nmos@60_poly-right##13 A1#18nmos@60_poly-right##14 9.871
R1924 A1#18nmos@60_poly-right##14 A1#18nmos@60_poly-right##15 9.871
R1925 A1#18nmos@60_poly-right##15 A1#18nmos@60_poly-right##16 9.871
R1926 A1#18nmos@60_poly-right##16 A1#18nmos@60_poly-right##17 9.871
R1927 A1#18nmos@60_poly-right##17 A1#18nmos@60_poly-right##18 9.871
R1928 A1#18nmos@60_poly-right##18 A1#18nmos@60_poly-right##19 9.871
R1929 A1#18nmos@60_poly-right##19 A1#18nmos@60_poly-right##20 9.871
R1930 A1#18nmos@60_poly-right##20 A1#18nmos@60_poly-right##21 9.871
R1931 A1#18nmos@60_poly-right##21 A1#18nmos@60_poly-right##22 9.871
R1932 A1#18nmos@60_poly-right##22 A1#18nmos@60_poly-right##23 9.871
R1933 A1#18nmos@60_poly-right##23 A1#18nmos@60_poly-right##24 9.871
R1934 A1#18nmos@60_poly-right##24 A1#18nmos@60_poly-right##25 9.871
R1935 A1#18nmos@60_poly-right##25 A1#18nmos@60_poly-right##26 9.871
R1936 A1#18nmos@60_poly-right##26 A1#18nmos@60_poly-right##27 9.871
R1937 A1#18nmos@60_poly-right##27 A1#18nmos@60_poly-right##28 9.871
R1938 A1#18nmos@60_poly-right##28 A1#18nmos@60_poly-right##29 9.871
R1939 A1#18nmos@60_poly-right##29 A1#18nmos@60_poly-right##30 9.871
R1940 A1#18nmos@60_poly-right##30 A1#18nmos@60_poly-right##31 9.871
R1941 A1#18nmos@60_poly-right##31 A1#18nmos@60_poly-right##32 9.871
R1942 A1#18nmos@60_poly-right##32 A1#18nmos@60_poly-right##33 9.871
R1943 A1#18nmos@60_poly-right##33 A1#18nmos@60_poly-right##34 9.871
R1944 A1#18nmos@60_poly-right##34 A1#18nmos@60_poly-right##35 9.871
R1945 A1#18nmos@60_poly-right##35 A1#18nmos@60_poly-right##36 9.871
R1946 A1#18nmos@60_poly-right##36 A1#18nmos@60_poly-right##37 9.871
R1947 A1#18nmos@60_poly-right##37 A1#18nmos@60_poly-right##38 9.871
R1948 A1#18nmos@60_poly-right##38 A1#18nmos@60_poly-right##39 9.871
R1949 A1#18nmos@60_poly-right##39 A1#18nmos@60_poly-right##40 9.871
R1950 A1#18nmos@60_poly-right##40 A1#18nmos@60_poly-right##41 9.871
R1951 A1#18nmos@60_poly-right##41 A1#18nmos@60_poly-right##42 9.871
R1952 A1#18nmos@60_poly-right##42 A1#18nmos@60_poly-right##43 9.871
R1953 A1#18nmos@60_poly-right##43 A1#18nmos@60_poly-right##44 9.871
R1954 A1#18nmos@60_poly-right##44 A1#18nmos@60_poly-right##45 9.871
R1955 A1#18nmos@60_poly-right##45 A1#18nmos@60_poly-right##46 9.871
R1956 A1#18nmos@60_poly-right##46 A1#18nmos@60_poly-right##47 9.871
R1957 A1#18nmos@60_poly-right##47 A1#18nmos@60_poly-right##48 9.871
R1958 A1#18nmos@60_poly-right##48 A1#18nmos@60_poly-right##49 9.871
R1959 A1#18nmos@60_poly-right##49 A1#18nmos@60_poly-right##50 9.871
R1960 A1#18nmos@60_poly-right##50 A1#18nmos@60_poly-right##51 9.871
R1961 A1#18nmos@60_poly-right##51 A1#18nmos@60_poly-right##52 9.871
R1962 A1#18nmos@60_poly-right##52 A1#18nmos@60_poly-right##53 9.871
R1963 A1#18nmos@60_poly-right##53 A1#18nmos@60_poly-right##54 9.871
R1964 A1#18nmos@60_poly-right##54 A1#18nmos@60_poly-right##55 9.871
R1965 A1#18nmos@60_poly-right##55 A1#13pmos@60_poly-left 9.871
R1966 net@1209#7pmos@61_poly-left net@1209#7pmos@61_poly-left##0 9.871
R1967 net@1209#7pmos@61_poly-left##0 net@1209#7pmos@61_poly-left##1 9.871
R1968 net@1209#7pmos@61_poly-left##1 net@1209#7pmos@61_poly-left##2 9.871
R1969 net@1209#7pmos@61_poly-left##2 net@1209#7pmos@61_poly-left##3 9.871
R1970 net@1209#7pmos@61_poly-left##3 net@1209#7pmos@61_poly-left##4 9.871
R1971 net@1209#7pmos@61_poly-left##4 net@1209#7pmos@61_poly-left##5 9.871
R1972 net@1209#7pmos@61_poly-left##5 net@1209#7pmos@61_poly-left##6 9.871
R1973 net@1209#7pmos@61_poly-left##6 net@1209#7pmos@61_poly-left##7 9.871
R1974 net@1209#7pmos@61_poly-left##7 net@1209#7pmos@61_poly-left##8 9.871
R1975 net@1209#7pmos@61_poly-left##8 net@1209#7pmos@61_poly-left##9 9.871
R1976 net@1209#7pmos@61_poly-left##9 net@1209#7pmos@61_poly-left##10 9.871
R1977 net@1209#7pmos@61_poly-left##10 net@1209#7pmos@61_poly-left##11 9.871
R1978 net@1209#7pmos@61_poly-left##11 net@1209#7pmos@61_poly-left##12 9.871
R1979 net@1209#7pmos@61_poly-left##12 net@1209#7pmos@61_poly-left##13 9.871
R1980 net@1209#7pmos@61_poly-left##13 net@1209#7pmos@61_poly-left##14 9.871
R1981 net@1209#7pmos@61_poly-left##14 net@1209#7pmos@61_poly-left##15 9.871
R1982 net@1209#7pmos@61_poly-left##15 net@1209#7pmos@61_poly-left##16 9.871
R1983 net@1209#7pmos@61_poly-left##16 net@1209#7pmos@61_poly-left##17 9.871
R1984 net@1209#7pmos@61_poly-left##17 net@1209#7pmos@61_poly-left##18 9.871
R1985 net@1209#7pmos@61_poly-left##18 net@1209#7pmos@61_poly-left##19 9.871
R1986 net@1209#7pmos@61_poly-left##19 net@1209#7pmos@61_poly-left##20 9.871
R1987 net@1209#7pmos@61_poly-left##20 net@1209#7pmos@61_poly-left##21 9.871
R1988 net@1209#7pmos@61_poly-left##21 net@1209#7pmos@61_poly-left##22 9.871
R1989 net@1209#7pmos@61_poly-left##22 net@1209#7pmos@61_poly-left##23 9.871
R1990 net@1209#7pmos@61_poly-left##23 net@1209#7pmos@61_poly-left##24 9.871
R1991 net@1209#7pmos@61_poly-left##24 net@1209#7pmos@61_poly-left##25 9.871
R1992 net@1209#7pmos@61_poly-left##25 net@1209#7pmos@61_poly-left##26 9.871
R1993 net@1209#7pmos@61_poly-left##26 net@1209#7pmos@61_poly-left##27 9.871
R1994 net@1209#7pmos@61_poly-left##27 net@1209#7pmos@61_poly-left##28 9.871
R1995 net@1209#7pmos@61_poly-left##28 net@1209#7pmos@61_poly-left##29 9.871
R1996 net@1209#7pmos@61_poly-left##29 net@1209#7pmos@61_poly-left##30 9.871
R1997 net@1209#7pmos@61_poly-left##30 net@1209#7pmos@61_poly-left##31 9.871
R1998 net@1209#7pmos@61_poly-left##31 net@1209#7pmos@61_poly-left##32 9.871
R1999 net@1209#7pmos@61_poly-left##32 net@1209#7pmos@61_poly-left##33 9.871
R2000 net@1209#7pmos@61_poly-left##33 net@1209#7pmos@61_poly-left##34 9.871
R2001 net@1209#7pmos@61_poly-left##34 net@1209#7pmos@61_poly-left##35 9.871
R2002 net@1209#7pmos@61_poly-left##35 net@1209#7pmos@61_poly-left##36 9.871
R2003 net@1209#7pmos@61_poly-left##36 net@1209#7pmos@61_poly-left##37 9.871
R2004 net@1209#7pmos@61_poly-left##37 net@1209#7pmos@61_poly-left##38 9.871
R2005 net@1209#7pmos@61_poly-left##38 net@1209#7pmos@61_poly-left##39 9.871
R2006 net@1209#7pmos@61_poly-left##39 net@1209#7pmos@61_poly-left##40 9.871
R2007 net@1209#7pmos@61_poly-left##40 net@1209#7pmos@61_poly-left##41 9.871
R2008 net@1209#7pmos@61_poly-left##41 net@1209#7pmos@61_poly-left##42 9.871
R2009 net@1209#7pmos@61_poly-left##42 net@1209#7pmos@61_poly-left##43 9.871
R2010 net@1209#7pmos@61_poly-left##43 net@1209#7pmos@61_poly-left##44 9.871
R2011 net@1209#7pmos@61_poly-left##44 net@1209#7pmos@61_poly-left##45 9.871
R2012 net@1209#7pmos@61_poly-left##45 net@1209#7pmos@61_poly-left##46 9.871
R2013 net@1209#7pmos@61_poly-left##46 net@1209#7pmos@61_poly-left##47 9.871
R2014 net@1209#7pmos@61_poly-left##47 net@1209#7pmos@61_poly-left##48 9.871
R2015 net@1209#7pmos@61_poly-left##48 net@1209#7pmos@61_poly-left##49 9.871
R2016 net@1209#7pmos@61_poly-left##49 net@1209#7pmos@61_poly-left##50 9.871
R2017 net@1209#7pmos@61_poly-left##50 net@1209#7pmos@61_poly-left##51 9.871
R2018 net@1209#7pmos@61_poly-left##51 net@1209#7pmos@61_poly-left##52 9.871
R2019 net@1209#7pmos@61_poly-left##52 net@1209#7pmos@61_poly-left##53 9.871
R2020 net@1209#7pmos@61_poly-left##53 net@1209#7pmos@61_poly-left##54 9.871
R2021 net@1209#7pmos@61_poly-left##54 net@1209#7pmos@61_poly-left##55 9.871
R2022 net@1209#7pmos@61_poly-left##55 net@1209#11nmos@61_poly-right 9.871
R2023 B1#19pmos@62_poly-right B1#19pmos@62_poly-right##0 9.871
R2024 B1#19pmos@62_poly-right##0 B1#19pmos@62_poly-right##1 9.871
R2025 B1#19pmos@62_poly-right##1 B1#19pmos@62_poly-right##2 9.871
R2026 B1#19pmos@62_poly-right##2 B1#19pmos@62_poly-right##3 9.871
R2027 B1#19pmos@62_poly-right##3 B1#19pmos@62_poly-right##4 9.871
R2028 B1#19pmos@62_poly-right##4 B1#19pmos@62_poly-right##5 9.871
R2029 B1#19pmos@62_poly-right##5 B1#19pmos@62_poly-right##6 9.871
R2030 B1#19pmos@62_poly-right##6 B1#19pmos@62_poly-right##7 9.871
R2031 B1#19pmos@62_poly-right##7 B1#19pmos@62_poly-right##8 9.871
R2032 B1#19pmos@62_poly-right##8 B1#19pmos@62_poly-right##9 9.871
R2033 B1#19pmos@62_poly-right##9 B1#19pmos@62_poly-right##10 9.871
R2034 B1#19pmos@62_poly-right##10 B1#19pmos@62_poly-right##11 9.871
R2035 B1#19pmos@62_poly-right##11 B1#19pmos@62_poly-right##12 9.871
R2036 B1#19pmos@62_poly-right##12 B1#19pmos@62_poly-right##13 9.871
R2037 B1#19pmos@62_poly-right##13 B1#19pmos@62_poly-right##14 9.871
R2038 B1#19pmos@62_poly-right##14 B1#19pmos@62_poly-right##15 9.871
R2039 B1#19pmos@62_poly-right##15 B1#19pmos@62_poly-right##16 9.871
R2040 B1#19pmos@62_poly-right##16 B1#19pmos@62_poly-right##17 9.871
R2041 B1#19pmos@62_poly-right##17 B1#19pmos@62_poly-right##18 9.871
R2042 B1#19pmos@62_poly-right##18 B1#19pmos@62_poly-right##19 9.871
R2043 B1#19pmos@62_poly-right##19 B1#19pmos@62_poly-right##20 9.871
R2044 B1#19pmos@62_poly-right##20 B1#19pmos@62_poly-right##21 9.871
R2045 B1#19pmos@62_poly-right##21 B1#19pmos@62_poly-right##22 9.871
R2046 B1#19pmos@62_poly-right##22 B1#19pmos@62_poly-right##23 9.871
R2047 B1#19pmos@62_poly-right##23 B1#19pmos@62_poly-right##24 9.871
R2048 B1#19pmos@62_poly-right##24 B1#19pmos@62_poly-right##25 9.871
R2049 B1#19pmos@62_poly-right##25 B1#19pmos@62_poly-right##26 9.871
R2050 B1#19pmos@62_poly-right##26 B1#19pmos@62_poly-right##27 9.871
R2051 B1#19pmos@62_poly-right##27 B1#19pmos@62_poly-right##28 9.871
R2052 B1#19pmos@62_poly-right##28 B1#19pmos@62_poly-right##29 9.871
R2053 B1#19pmos@62_poly-right##29 B1#19pmos@62_poly-right##30 9.871
R2054 B1#19pmos@62_poly-right##30 B1#19pmos@62_poly-right##31 9.871
R2055 B1#19pmos@62_poly-right##31 B1#19pmos@62_poly-right##32 9.871
R2056 B1#19pmos@62_poly-right##32 B1#19pmos@62_poly-right##33 9.871
R2057 B1#19pmos@62_poly-right##33 B1#19pmos@62_poly-right##34 9.871
R2058 B1#19pmos@62_poly-right##34 B1#19pmos@62_poly-right##35 9.871
R2059 B1#19pmos@62_poly-right##35 B1#19pmos@62_poly-right##36 9.871
R2060 B1#19pmos@62_poly-right##36 B1#19pmos@62_poly-right##37 9.871
R2061 B1#19pmos@62_poly-right##37 B1#19pmos@62_poly-right##38 9.871
R2062 B1#19pmos@62_poly-right##38 B1#19pmos@62_poly-right##39 9.871
R2063 B1#19pmos@62_poly-right##39 B1#19pmos@62_poly-right##40 9.871
R2064 B1#19pmos@62_poly-right##40 B1#19pmos@62_poly-right##41 9.871
R2065 B1#19pmos@62_poly-right##41 B1#19pmos@62_poly-right##42 9.871
R2066 B1#19pmos@62_poly-right##42 B1#19pmos@62_poly-right##43 9.871
R2067 B1#19pmos@62_poly-right##43 B1#19pmos@62_poly-right##44 9.871
R2068 B1#19pmos@62_poly-right##44 B1#19pmos@62_poly-right##45 9.871
R2069 B1#19pmos@62_poly-right##45 B1#19pmos@62_poly-right##46 9.871
R2070 B1#19pmos@62_poly-right##46 B1#19pmos@62_poly-right##47 9.871
R2071 B1#19pmos@62_poly-right##47 B1#19pmos@62_poly-right##48 9.871
R2072 B1#19pmos@62_poly-right##48 B1#19pmos@62_poly-right##49 9.871
R2073 B1#19pmos@62_poly-right##49 B1#19pmos@62_poly-right##50 9.871
R2074 B1#19pmos@62_poly-right##50 B1#19pmos@62_poly-right##51 9.871
R2075 B1#19pmos@62_poly-right##51 B1#19pmos@62_poly-right##52 9.871
R2076 B1#19pmos@62_poly-right##52 B1#19pmos@62_poly-right##53 9.871
R2077 B1#19pmos@62_poly-right##53 B1#19pmos@62_poly-right##54 9.871
R2078 B1#19pmos@62_poly-right##54 B1#19pmos@62_poly-right##55 9.871
R2079 B1#19pmos@62_poly-right##55 B1#17nmos@62_poly-left 9.871
R2080 net@1314#14pmos@63_poly-right net@1314#14pmos@63_poly-right##0 9.871
R2081 net@1314#14pmos@63_poly-right##0 net@1314#14pmos@63_poly-right##1 9.871
R2082 net@1314#14pmos@63_poly-right##1 net@1314#14pmos@63_poly-right##2 9.871
R2083 net@1314#14pmos@63_poly-right##2 net@1314#14pmos@63_poly-right##3 9.871
R2084 net@1314#14pmos@63_poly-right##3 net@1314#14pmos@63_poly-right##4 9.871
R2085 net@1314#14pmos@63_poly-right##4 net@1314#14pmos@63_poly-right##5 9.871
R2086 net@1314#14pmos@63_poly-right##5 net@1314#14pmos@63_poly-right##6 9.871
R2087 net@1314#14pmos@63_poly-right##6 net@1314#14pmos@63_poly-right##7 9.871
R2088 net@1314#14pmos@63_poly-right##7 net@1314#14pmos@63_poly-right##8 9.871
R2089 net@1314#14pmos@63_poly-right##8 net@1314#14pmos@63_poly-right##9 9.871
R2090 net@1314#14pmos@63_poly-right##9 net@1314#14pmos@63_poly-right##10 9.871
R2091 net@1314#14pmos@63_poly-right##10 net@1314#14pmos@63_poly-right##11 9.871
R2092 net@1314#14pmos@63_poly-right##11 net@1314#14pmos@63_poly-right##12 9.871
R2093 net@1314#14pmos@63_poly-right##12 net@1314#14pmos@63_poly-right##13 9.871
R2094 net@1314#14pmos@63_poly-right##13 net@1314#14pmos@63_poly-right##14 9.871
R2095 net@1314#14pmos@63_poly-right##14 net@1314#14pmos@63_poly-right##15 9.871
R2096 net@1314#14pmos@63_poly-right##15 net@1314#14pmos@63_poly-right##16 9.871
R2097 net@1314#14pmos@63_poly-right##16 net@1314#14pmos@63_poly-right##17 9.871
R2098 net@1314#14pmos@63_poly-right##17 net@1314#14pmos@63_poly-right##18 9.871
R2099 net@1314#14pmos@63_poly-right##18 net@1314#14pmos@63_poly-right##19 9.871
R2100 net@1314#14pmos@63_poly-right##19 net@1314#14pmos@63_poly-right##20 9.871
R2101 net@1314#14pmos@63_poly-right##20 net@1314#14pmos@63_poly-right##21 9.871
R2102 net@1314#14pmos@63_poly-right##21 net@1314#14pmos@63_poly-right##22 9.871
R2103 net@1314#14pmos@63_poly-right##22 net@1314#14pmos@63_poly-right##23 9.871
R2104 net@1314#14pmos@63_poly-right##23 net@1314#14pmos@63_poly-right##24 9.871
R2105 net@1314#14pmos@63_poly-right##24 net@1314#14pmos@63_poly-right##25 9.871
R2106 net@1314#14pmos@63_poly-right##25 net@1314#14pmos@63_poly-right##26 9.871
R2107 net@1314#14pmos@63_poly-right##26 net@1314#14pmos@63_poly-right##27 9.871
R2108 net@1314#14pmos@63_poly-right##27 net@1314#14pmos@63_poly-right##28 9.871
R2109 net@1314#14pmos@63_poly-right##28 net@1314#14pmos@63_poly-right##29 9.871
R2110 net@1314#14pmos@63_poly-right##29 net@1314#14pmos@63_poly-right##30 9.871
R2111 net@1314#14pmos@63_poly-right##30 net@1314#14pmos@63_poly-right##31 9.871
R2112 net@1314#14pmos@63_poly-right##31 net@1314#14pmos@63_poly-right##32 9.871
R2113 net@1314#14pmos@63_poly-right##32 net@1314#14pmos@63_poly-right##33 9.871
R2114 net@1314#14pmos@63_poly-right##33 net@1314#14pmos@63_poly-right##34 9.871
R2115 net@1314#14pmos@63_poly-right##34 net@1314#14pmos@63_poly-right##35 9.871
R2116 net@1314#14pmos@63_poly-right##35 net@1314#14pmos@63_poly-right##36 9.871
R2117 net@1314#14pmos@63_poly-right##36 net@1314#14pmos@63_poly-right##37 9.871
R2118 net@1314#14pmos@63_poly-right##37 net@1314#14pmos@63_poly-right##38 9.871
R2119 net@1314#14pmos@63_poly-right##38 net@1314#14pmos@63_poly-right##39 9.871
R2120 net@1314#14pmos@63_poly-right##39 net@1314#14pmos@63_poly-right##40 9.871
R2121 net@1314#14pmos@63_poly-right##40 net@1314#14pmos@63_poly-right##41 9.871
R2122 net@1314#14pmos@63_poly-right##41 net@1314#14pmos@63_poly-right##42 9.871
R2123 net@1314#14pmos@63_poly-right##42 net@1314#14pmos@63_poly-right##43 9.871
R2124 net@1314#14pmos@63_poly-right##43 net@1314#14pmos@63_poly-right##44 9.871
R2125 net@1314#14pmos@63_poly-right##44 net@1314#14pmos@63_poly-right##45 9.871
R2126 net@1314#14pmos@63_poly-right##45 net@1314#14pmos@63_poly-right##46 9.871
R2127 net@1314#14pmos@63_poly-right##46 net@1314#14pmos@63_poly-right##47 9.871
R2128 net@1314#14pmos@63_poly-right##47 net@1314#14pmos@63_poly-right##48 9.871
R2129 net@1314#14pmos@63_poly-right##48 net@1314#14pmos@63_poly-right##49 9.871
R2130 net@1314#14pmos@63_poly-right##49 net@1314#14pmos@63_poly-right##50 9.871
R2131 net@1314#14pmos@63_poly-right##50 net@1314#14pmos@63_poly-right##51 9.871
R2132 net@1314#14pmos@63_poly-right##51 net@1314#14pmos@63_poly-right##52 9.871
R2133 net@1314#14pmos@63_poly-right##52 net@1314#14pmos@63_poly-right##53 9.871
R2134 net@1314#14pmos@63_poly-right##53 net@1314#14pmos@63_poly-right##54 9.871
R2135 net@1314#14pmos@63_poly-right##54 net@1314#14pmos@63_poly-right##55 9.871
R2136 net@1314#14pmos@63_poly-right##55 net@1314#9nmos@63_poly-left 9.871
R2137 net@1307#2contact@491_metal-1-polysilicon-1 net@1307 4.706
R2138 net@1307#12pmos@66_poly-right net@1307#12pmos@66_poly-right##0 9.864
R2139 net@1307#12pmos@66_poly-right##0 net@1307#12pmos@66_poly-right##1 9.864
R2140 net@1307#12pmos@66_poly-right##1 net@1307#12pmos@66_poly-right##2 9.864
R2141 net@1307#12pmos@66_poly-right##2 net@1307#12pmos@66_poly-right##3 9.864
R2142 net@1307#12pmos@66_poly-right##3 net@1307#12pmos@66_poly-right##4 9.864
R2143 net@1307#12pmos@66_poly-right##4 net@1307#12pmos@66_poly-right##5 9.864
R2144 net@1307#12pmos@66_poly-right##5 net@1307#12pmos@66_poly-right##6 9.864
R2145 net@1307#12pmos@66_poly-right##6 net@1307#12pmos@66_poly-right##7 9.864
R2146 net@1307#12pmos@66_poly-right##7 net@1307#12pmos@66_poly-right##8 9.864
R2147 net@1307#12pmos@66_poly-right##8 net@1307#12pmos@66_poly-right##9 9.864
R2148 net@1307#12pmos@66_poly-right##9 net@1307#12pmos@66_poly-right##10 9.864
R2149 net@1307#12pmos@66_poly-right##10 net@1307#12pmos@66_poly-right##11 9.864
R2150 net@1307#12pmos@66_poly-right##11 net@1307#12pmos@66_poly-right##12 9.864
R2151 net@1307#12pmos@66_poly-right##12 net@1307#12pmos@66_poly-right##13 9.864
R2152 net@1307#12pmos@66_poly-right##13 net@1307#12pmos@66_poly-right##14 9.864
R2153 net@1307#12pmos@66_poly-right##14 net@1307#12pmos@66_poly-right##15 9.864
R2154 net@1307#12pmos@66_poly-right##15 net@1307#12pmos@66_poly-right##16 9.864
R2155 net@1307#12pmos@66_poly-right##16 net@1307#12pmos@66_poly-right##17 9.864
R2156 net@1307#12pmos@66_poly-right##17 net@1307#12pmos@66_poly-right##18 9.864
R2157 net@1307#12pmos@66_poly-right##18 net@1307#12pmos@66_poly-right##19 9.864
R2158 net@1307#12pmos@66_poly-right##19 net@1307#12pmos@66_poly-right##20 9.864
R2159 net@1307#12pmos@66_poly-right##20 net@1307#12pmos@66_poly-right##21 9.864
R2160 net@1307#12pmos@66_poly-right##21 net@1307#12pmos@66_poly-right##22 9.864
R2161 net@1307#12pmos@66_poly-right##22 net@1307#12pmos@66_poly-right##23 9.864
R2162 net@1307#12pmos@66_poly-right##23 net@1307#12pmos@66_poly-right##24 9.864
R2163 net@1307#12pmos@66_poly-right##24 net@1307#12pmos@66_poly-right##25 9.864
R2164 net@1307#12pmos@66_poly-right##25 net@1307#12pmos@66_poly-right##26 9.864
R2165 net@1307#12pmos@66_poly-right##26 net@1307#12pmos@66_poly-right##27 9.864
R2166 net@1307#12pmos@66_poly-right##27 net@1307#12pmos@66_poly-right##28 9.864
R2167 net@1307#12pmos@66_poly-right##28 net@1307#12pmos@66_poly-right##29 9.864
R2168 net@1307#12pmos@66_poly-right##29 net@1307#12pmos@66_poly-right##30 9.864
R2169 net@1307#12pmos@66_poly-right##30 net@1307#12pmos@66_poly-right##31 9.864
R2170 net@1307#12pmos@66_poly-right##31 net@1307#12pmos@66_poly-right##32 9.864
R2171 net@1307#12pmos@66_poly-right##32 net@1307#12pmos@66_poly-right##33 9.864
R2172 net@1307#12pmos@66_poly-right##33 net@1307#12pmos@66_poly-right##34 9.864
R2173 net@1307#12pmos@66_poly-right##34 net@1307#12pmos@66_poly-right##35 9.864
R2174 net@1307#12pmos@66_poly-right##35 net@1307#12pmos@66_poly-right##36 9.864
R2175 net@1307#12pmos@66_poly-right##36 net@1307#12pmos@66_poly-right##37 9.864
R2176 net@1307#12pmos@66_poly-right##37 net@1307#12pmos@66_poly-right##38 9.864
R2177 net@1307#12pmos@66_poly-right##38 net@1307#12pmos@66_poly-right##39 9.864
R2178 net@1307#12pmos@66_poly-right##39 net@1307#12pmos@66_poly-right##40 9.864
R2179 net@1307#12pmos@66_poly-right##40 net@1307#12pmos@66_poly-right##41 9.864
R2180 net@1307#12pmos@66_poly-right##41 net@1307#12pmos@66_poly-right##42 9.864
R2181 net@1307#12pmos@66_poly-right##42 net@1307#12pmos@66_poly-right##43 9.864
R2182 net@1307#12pmos@66_poly-right##43 net@1307#12pmos@66_poly-right##44 9.864
R2183 net@1307#12pmos@66_poly-right##44 net@1307#12pmos@66_poly-right##45 9.864
R2184 net@1307#12pmos@66_poly-right##45 net@1307#12pmos@66_poly-right##46 9.864
R2185 net@1307#12pmos@66_poly-right##46 net@1307#12pmos@66_poly-right##47 9.864
R2186 net@1307#12pmos@66_poly-right##47 net@1307#12pmos@66_poly-right##48 9.864
R2187 net@1307#12pmos@66_poly-right##48 net@1307#12pmos@66_poly-right##49 9.864
R2188 net@1307#12pmos@66_poly-right##49 net@1307#12pmos@66_poly-right##50 9.864
R2189 net@1307#12pmos@66_poly-right##50 net@1307#12pmos@66_poly-right##51 9.864
R2190 net@1307#12pmos@66_poly-right##51 net@1307#12pmos@66_poly-right##52 9.864
R2191 net@1307#12pmos@66_poly-right##52 net@1307#12pmos@66_poly-right##53 9.864
R2192 net@1307#12pmos@66_poly-right##53 net@1307#5pin@345_polysilicon-1 9.864
R2193 XOR1_to_NAND2#22pmos@66_diff-top XOR1_to_NAND2#1contact@544_metal-1-metal-2 4.862
R2194 XOR1_to_NAND2#3pin@378_polysilicon-1 XOR1_to_NAND2#3pin@378_polysilicon-1##0 9.881
R2195 XOR1_to_NAND2#3pin@378_polysilicon-1##0 XOR1_to_NAND2#3pin@378_polysilicon-1##1 9.881
R2196 XOR1_to_NAND2#3pin@378_polysilicon-1##1 XOR1_to_NAND2#3pin@378_polysilicon-1##2 9.881
R2197 XOR1_to_NAND2#3pin@378_polysilicon-1##2 XOR1_to_NAND2#3pin@378_polysilicon-1##3 9.881
R2198 XOR1_to_NAND2#3pin@378_polysilicon-1##3 XOR1_to_NAND2#3pin@378_polysilicon-1##4 9.881
R2199 XOR1_to_NAND2#3pin@378_polysilicon-1##4 XOR1_to_NAND2#3pin@378_polysilicon-1##5 9.881
R2200 XOR1_to_NAND2#3pin@378_polysilicon-1##5 XOR1_to_NAND2#3pin@378_polysilicon-1##6 9.881
R2201 XOR1_to_NAND2#3pin@378_polysilicon-1##6 XOR1_to_NAND2#3pin@378_polysilicon-1##7 9.881
R2202 XOR1_to_NAND2#3pin@378_polysilicon-1##7 XOR1_to_NAND2#3pin@378_polysilicon-1##8 9.881
R2203 XOR1_to_NAND2#3pin@378_polysilicon-1##8 XOR1_to_NAND2#3pin@378_polysilicon-1##9 9.881
R2204 XOR1_to_NAND2#3pin@378_polysilicon-1##9 XOR1_to_NAND2#3pin@378_polysilicon-1##10 9.881
R2205 XOR1_to_NAND2#3pin@378_polysilicon-1##10 XOR1_to_NAND2#3pin@378_polysilicon-1##11 9.881
R2206 XOR1_to_NAND2#3pin@378_polysilicon-1##11 XOR1_to_NAND2#3pin@378_polysilicon-1##12 9.881
R2207 XOR1_to_NAND2#3pin@378_polysilicon-1##12 XOR1_to_NAND2#3pin@378_polysilicon-1##13 9.881
R2208 XOR1_to_NAND2#3pin@378_polysilicon-1##13 XOR1_to_NAND2#3pin@378_polysilicon-1##14 9.881
R2209 XOR1_to_NAND2#3pin@378_polysilicon-1##14 XOR1_to_NAND2#3pin@378_polysilicon-1##15 9.881
R2210 XOR1_to_NAND2#3pin@378_polysilicon-1##15 XOR1_to_NAND2#3pin@378_polysilicon-1##16 9.881
R2211 XOR1_to_NAND2#3pin@378_polysilicon-1##16 XOR1_to_NAND2#3pin@378_polysilicon-1##17 9.881
R2212 XOR1_to_NAND2#3pin@378_polysilicon-1##17 XOR1_to_NAND2#3pin@378_polysilicon-1##18 9.881
R2213 XOR1_to_NAND2#3pin@378_polysilicon-1##18 XOR1_to_NAND2#3pin@378_polysilicon-1##19 9.881
R2214 XOR1_to_NAND2#3pin@378_polysilicon-1##19 XOR1_to_NAND2#3pin@378_polysilicon-1##20 9.881
R2215 XOR1_to_NAND2#3pin@378_polysilicon-1##20 XOR1_to_NAND2#3pin@378_polysilicon-1##21 9.881
R2216 XOR1_to_NAND2#3pin@378_polysilicon-1##21 XOR1_to_NAND2#3pin@378_polysilicon-1##22 9.881
R2217 XOR1_to_NAND2#3pin@378_polysilicon-1##22 XOR1_to_NAND2#3pin@378_polysilicon-1##23 9.881
R2218 XOR1_to_NAND2#3pin@378_polysilicon-1##23 XOR1_to_NAND2#3pin@378_polysilicon-1##24 9.881
R2219 XOR1_to_NAND2#3pin@378_polysilicon-1##24 XOR1_to_NAND2#3pin@378_polysilicon-1##25 9.881
R2220 XOR1_to_NAND2#3pin@378_polysilicon-1##25 XOR1_to_NAND2#3pin@378_polysilicon-1##26 9.881
R2221 XOR1_to_NAND2#3pin@378_polysilicon-1##26 XOR1_to_NAND2#3pin@378_polysilicon-1##27 9.881
R2222 XOR1_to_NAND2#3pin@378_polysilicon-1##27 XOR1_to_NAND2#3pin@378_polysilicon-1##28 9.881
R2223 XOR1_to_NAND2#3pin@378_polysilicon-1##28 XOR1_to_NAND2#3pin@378_polysilicon-1##29 9.881
R2224 XOR1_to_NAND2#3pin@378_polysilicon-1##29 XOR1_to_NAND2#3pin@378_polysilicon-1##30 9.881
R2225 XOR1_to_NAND2#3pin@378_polysilicon-1##30 XOR1_to_NAND2#3pin@378_polysilicon-1##31 9.881
R2226 XOR1_to_NAND2#3pin@378_polysilicon-1##31 XOR1_to_NAND2#3pin@378_polysilicon-1##32 9.881
R2227 XOR1_to_NAND2#3pin@378_polysilicon-1##32 XOR1_to_NAND2#3pin@378_polysilicon-1##33 9.881
R2228 XOR1_to_NAND2#3pin@378_polysilicon-1##33 XOR1_to_NAND2#3pin@378_polysilicon-1##34 9.881
R2229 XOR1_to_NAND2#3pin@378_polysilicon-1##34 XOR1_to_NAND2#3pin@378_polysilicon-1##35 9.881
R2230 XOR1_to_NAND2#3pin@378_polysilicon-1##35 XOR1_to_NAND2#3pin@378_polysilicon-1##36 9.881
R2231 XOR1_to_NAND2#3pin@378_polysilicon-1##36 XOR1_to_NAND2#3pin@378_polysilicon-1##37 9.881
R2232 XOR1_to_NAND2#3pin@378_polysilicon-1##37 XOR1_to_NAND2#3pin@378_polysilicon-1##38 9.881
R2233 XOR1_to_NAND2#3pin@378_polysilicon-1##38 XOR1_to_NAND2#3pin@378_polysilicon-1##39 9.881
R2234 XOR1_to_NAND2#3pin@378_polysilicon-1##39 XOR1_to_NAND2#3pin@378_polysilicon-1##40 9.881
R2235 XOR1_to_NAND2#3pin@378_polysilicon-1##40 XOR1_to_NAND2#3pin@378_polysilicon-1##41 9.881
R2236 XOR1_to_NAND2#3pin@378_polysilicon-1##41 XOR1_to_NAND2#3pin@378_polysilicon-1##42 9.881
R2237 XOR1_to_NAND2#3pin@378_polysilicon-1##42 XOR1_to_NAND2#3pin@378_polysilicon-1##43 9.881
R2238 XOR1_to_NAND2#3pin@378_polysilicon-1##43 XOR1_to_NAND2#3pin@378_polysilicon-1##44 9.881
R2239 XOR1_to_NAND2#3pin@378_polysilicon-1##44 XOR1_to_NAND2#3pin@378_polysilicon-1##45 9.881
R2240 XOR1_to_NAND2#3pin@378_polysilicon-1##45 XOR1_to_NAND2#3pin@378_polysilicon-1##46 9.881
R2241 XOR1_to_NAND2#3pin@378_polysilicon-1##46 XOR1_to_NAND2#3pin@378_polysilicon-1##47 9.881
R2242 XOR1_to_NAND2#3pin@378_polysilicon-1##47 XOR1_to_NAND2#3pin@378_polysilicon-1##48 9.881
R2243 XOR1_to_NAND2#3pin@378_polysilicon-1##48 XOR1_to_NAND2#3pin@378_polysilicon-1##49 9.881
R2244 XOR1_to_NAND2#3pin@378_polysilicon-1##49 XOR1_to_NAND2#3pin@378_polysilicon-1##50 9.881
R2245 XOR1_to_NAND2#3pin@378_polysilicon-1##50 XOR1_to_NAND2#3pin@378_polysilicon-1##51 9.881
R2246 XOR1_to_NAND2#3pin@378_polysilicon-1##51 XOR1_to_NAND2#3pin@378_polysilicon-1##52 9.881
R2247 XOR1_to_NAND2#3pin@378_polysilicon-1##52 XOR1_to_NAND2#3pin@378_polysilicon-1##53 9.881
R2248 XOR1_to_NAND2#3pin@378_polysilicon-1##53 XOR1_to_NAND2#3pin@378_polysilicon-1##54 9.881
R2249 XOR1_to_NAND2#3pin@378_polysilicon-1##54 XOR1_to_NAND2#24nmos@72_poly-right 9.881
R2250 net@1211#5pmos@72_diff-top net@1211#2pin@367_metal-1 4.81
R2251 net@1211#1pin@377_polysilicon-1 net@1211#1pin@377_polysilicon-1##0 9.85
R2252 net@1211#1pin@377_polysilicon-1##0 net@1211#1pin@377_polysilicon-1##1 9.85
R2253 net@1211#1pin@377_polysilicon-1##1 net@1211#1pin@377_polysilicon-1##2 9.85
R2254 net@1211#1pin@377_polysilicon-1##2 net@1211#1pin@377_polysilicon-1##3 9.85
R2255 net@1211#1pin@377_polysilicon-1##3 net@1211#1pin@377_polysilicon-1##4 9.85
R2256 net@1211#1pin@377_polysilicon-1##4 net@1211#1pin@377_polysilicon-1##5 9.85
R2257 net@1211#1pin@377_polysilicon-1##5 net@1211#1pin@377_polysilicon-1##6 9.85
R2258 net@1211#1pin@377_polysilicon-1##6 net@1211#1pin@377_polysilicon-1##7 9.85
R2259 net@1211#1pin@377_polysilicon-1##7 net@1211#1pin@377_polysilicon-1##8 9.85
R2260 net@1211#1pin@377_polysilicon-1##8 net@1211#1pin@377_polysilicon-1##9 9.85
R2261 net@1211#1pin@377_polysilicon-1##9 net@1211#1pin@377_polysilicon-1##10 9.85
R2262 net@1211#1pin@377_polysilicon-1##10 net@1211#1pin@377_polysilicon-1##11 9.85
R2263 net@1211#1pin@377_polysilicon-1##11 net@1211#1pin@377_polysilicon-1##12 9.85
R2264 net@1211#1pin@377_polysilicon-1##12 net@1211#1pin@377_polysilicon-1##13 9.85
R2265 net@1211#1pin@377_polysilicon-1##13 net@1211#1pin@377_polysilicon-1##14 9.85
R2266 net@1211#1pin@377_polysilicon-1##14 net@1211#1pin@377_polysilicon-1##15 9.85
R2267 net@1211#1pin@377_polysilicon-1##15 net@1211#1pin@377_polysilicon-1##16 9.85
R2268 net@1211#1pin@377_polysilicon-1##16 net@1211#1pin@377_polysilicon-1##17 9.85
R2269 net@1211#1pin@377_polysilicon-1##17 net@1211#1pin@377_polysilicon-1##18 9.85
R2270 net@1211#1pin@377_polysilicon-1##18 net@1211#1pin@377_polysilicon-1##19 9.85
R2271 net@1211#1pin@377_polysilicon-1##19 net@1211#1pin@377_polysilicon-1##20 9.85
R2272 net@1211#1pin@377_polysilicon-1##20 net@1211#1pin@377_polysilicon-1##21 9.85
R2273 net@1211#1pin@377_polysilicon-1##21 net@1211#1pin@377_polysilicon-1##22 9.85
R2274 net@1211#1pin@377_polysilicon-1##22 net@1211#1pin@377_polysilicon-1##23 9.85
R2275 net@1211#1pin@377_polysilicon-1##23 net@1211#1pin@377_polysilicon-1##24 9.85
R2276 net@1211#1pin@377_polysilicon-1##24 net@1211#1pin@377_polysilicon-1##25 9.85
R2277 net@1211#1pin@377_polysilicon-1##25 net@1211#1pin@377_polysilicon-1##26 9.85
R2278 net@1211#1pin@377_polysilicon-1##26 net@1211#1pin@377_polysilicon-1##27 9.85
R2279 net@1211#1pin@377_polysilicon-1##27 net@1211#1pin@377_polysilicon-1##28 9.85
R2280 net@1211#1pin@377_polysilicon-1##28 net@1211#1pin@377_polysilicon-1##29 9.85
R2281 net@1211#1pin@377_polysilicon-1##29 net@1211#1pin@377_polysilicon-1##30 9.85
R2282 net@1211#1pin@377_polysilicon-1##30 net@1211#1pin@377_polysilicon-1##31 9.85
R2283 net@1211#1pin@377_polysilicon-1##31 net@1211#1pin@377_polysilicon-1##32 9.85
R2284 net@1211#1pin@377_polysilicon-1##32 net@1211#1pin@377_polysilicon-1##33 9.85
R2285 net@1211#1pin@377_polysilicon-1##33 net@1211#1pin@377_polysilicon-1##34 9.85
R2286 net@1211#1pin@377_polysilicon-1##34 net@1211#1pin@377_polysilicon-1##35 9.85
R2287 net@1211#1pin@377_polysilicon-1##35 net@1211#1pin@377_polysilicon-1##36 9.85
R2288 net@1211#1pin@377_polysilicon-1##36 net@1211#1pin@377_polysilicon-1##37 9.85
R2289 net@1211#1pin@377_polysilicon-1##37 net@1211#1pin@377_polysilicon-1##38 9.85
R2290 net@1211#1pin@377_polysilicon-1##38 net@1211#1pin@377_polysilicon-1##39 9.85
R2291 net@1211#1pin@377_polysilicon-1##39 net@1211#1pin@377_polysilicon-1##40 9.85
R2292 net@1211#1pin@377_polysilicon-1##40 net@1211#1pin@377_polysilicon-1##41 9.85
R2293 net@1211#1pin@377_polysilicon-1##41 net@1211#1pin@377_polysilicon-1##42 9.85
R2294 net@1211#1pin@377_polysilicon-1##42 net@1211#1pin@377_polysilicon-1##43 9.85
R2295 net@1211#1pin@377_polysilicon-1##43 net@1211#1pin@377_polysilicon-1##44 9.85
R2296 net@1211#1pin@377_polysilicon-1##44 net@1211#1pin@377_polysilicon-1##45 9.85
R2297 net@1211#1pin@377_polysilicon-1##45 net@1211#1pin@377_polysilicon-1##46 9.85
R2298 net@1211#1pin@377_polysilicon-1##46 net@1211#1pin@377_polysilicon-1##47 9.85
R2299 net@1211#1pin@377_polysilicon-1##47 net@1211#1pin@377_polysilicon-1##48 9.85
R2300 net@1211#1pin@377_polysilicon-1##48 net@1211#1pin@377_polysilicon-1##49 9.85
R2301 net@1211#1pin@377_polysilicon-1##49 net@1211#1pin@377_polysilicon-1##50 9.85
R2302 net@1211#1pin@377_polysilicon-1##50 net@1211#1pin@377_polysilicon-1##51 9.85
R2303 net@1211#1pin@377_polysilicon-1##51 net@1211#1pin@377_polysilicon-1##52 9.85
R2304 net@1211#1pin@377_polysilicon-1##52 net@1211#1pin@377_polysilicon-1##53 9.85
R2305 net@1211#1pin@377_polysilicon-1##53 net@1211#1pin@377_polysilicon-1##54 9.85
R2306 net@1211#1pin@377_polysilicon-1##54 net@1211#1pin@377_polysilicon-1##55 9.85
R2307 net@1211#1pin@377_polysilicon-1##55 net@1211#1pin@377_polysilicon-1##56 9.85
R2308 net@1211#1pin@377_polysilicon-1##56 net@1211#1pin@377_polysilicon-1##57 9.85
R2309 net@1211#1pin@377_polysilicon-1##57 net@1211#1pin@377_polysilicon-1##58 9.85
R2310 net@1211#1pin@377_polysilicon-1##58 net@1211#1pin@377_polysilicon-1##59 9.85
R2311 net@1211#1pin@377_polysilicon-1##59 net@1211#1pin@377_polysilicon-1##60 9.85
R2312 net@1211#1pin@377_polysilicon-1##60 net@1211#2pin@367_metal-1 9.85
R2313 Cin_to_XOR2___NAND2#26pmos@71_poly-right Cin_to_XOR2___NAND2#26pmos@71_poly-right##0 9.854
R2314 Cin_to_XOR2___NAND2#26pmos@71_poly-right##0 Cin_to_XOR2___NAND2#26pmos@71_poly-right##1 9.854
R2315 Cin_to_XOR2___NAND2#26pmos@71_poly-right##1 Cin_to_XOR2___NAND2#26pmos@71_poly-right##2 9.854
R2316 Cin_to_XOR2___NAND2#26pmos@71_poly-right##2 Cin_to_XOR2___NAND2#26pmos@71_poly-right##3 9.854
R2317 Cin_to_XOR2___NAND2#26pmos@71_poly-right##3 Cin_to_XOR2___NAND2#26pmos@71_poly-right##4 9.854
R2318 Cin_to_XOR2___NAND2#26pmos@71_poly-right##4 Cin_to_XOR2___NAND2#26pmos@71_poly-right##5 9.854
R2319 Cin_to_XOR2___NAND2#26pmos@71_poly-right##5 Cin_to_XOR2___NAND2#26pmos@71_poly-right##6 9.854
R2320 Cin_to_XOR2___NAND2#26pmos@71_poly-right##6 Cin_to_XOR2___NAND2#26pmos@71_poly-right##7 9.854
R2321 Cin_to_XOR2___NAND2#26pmos@71_poly-right##7 Cin_to_XOR2___NAND2#26pmos@71_poly-right##8 9.854
R2322 Cin_to_XOR2___NAND2#26pmos@71_poly-right##8 Cin_to_XOR2___NAND2#26pmos@71_poly-right##9 9.854
R2323 Cin_to_XOR2___NAND2#26pmos@71_poly-right##9 Cin_to_XOR2___NAND2#26pmos@71_poly-right##10 9.854
R2324 Cin_to_XOR2___NAND2#26pmos@71_poly-right##10 Cin_to_XOR2___NAND2#26pmos@71_poly-right##11 9.854
R2325 Cin_to_XOR2___NAND2#26pmos@71_poly-right##11 Cin_to_XOR2___NAND2#26pmos@71_poly-right##12 9.854
R2326 Cin_to_XOR2___NAND2#26pmos@71_poly-right##12 Cin_to_XOR2___NAND2#26pmos@71_poly-right##13 9.854
R2327 Cin_to_XOR2___NAND2#26pmos@71_poly-right##13 Cin_to_XOR2___NAND2#26pmos@71_poly-right##14 9.854
R2328 Cin_to_XOR2___NAND2#26pmos@71_poly-right##14 Cin_to_XOR2___NAND2#26pmos@71_poly-right##15 9.854
R2329 Cin_to_XOR2___NAND2#26pmos@71_poly-right##15 Cin_to_XOR2___NAND2#26pmos@71_poly-right##16 9.854
R2330 Cin_to_XOR2___NAND2#26pmos@71_poly-right##16 Cin_to_XOR2___NAND2#26pmos@71_poly-right##17 9.854
R2331 Cin_to_XOR2___NAND2#26pmos@71_poly-right##17 Cin_to_XOR2___NAND2#26pmos@71_poly-right##18 9.854
R2332 Cin_to_XOR2___NAND2#26pmos@71_poly-right##18 Cin_to_XOR2___NAND2#26pmos@71_poly-right##19 9.854
R2333 Cin_to_XOR2___NAND2#26pmos@71_poly-right##19 Cin_to_XOR2___NAND2#26pmos@71_poly-right##20 9.854
R2334 Cin_to_XOR2___NAND2#26pmos@71_poly-right##20 Cin_to_XOR2___NAND2#26pmos@71_poly-right##21 9.854
R2335 Cin_to_XOR2___NAND2#26pmos@71_poly-right##21 Cin_to_XOR2___NAND2#26pmos@71_poly-right##22 9.854
R2336 Cin_to_XOR2___NAND2#26pmos@71_poly-right##22 Cin_to_XOR2___NAND2#26pmos@71_poly-right##23 9.854
R2337 Cin_to_XOR2___NAND2#26pmos@71_poly-right##23 Cin_to_XOR2___NAND2#26pmos@71_poly-right##24 9.854
R2338 Cin_to_XOR2___NAND2#26pmos@71_poly-right##24 Cin_to_XOR2___NAND2#26pmos@71_poly-right##25 9.854
R2339 Cin_to_XOR2___NAND2#26pmos@71_poly-right##25 Cin_to_XOR2___NAND2#26pmos@71_poly-right##26 9.854
R2340 Cin_to_XOR2___NAND2#26pmos@71_poly-right##26 Cin_to_XOR2___NAND2#26pmos@71_poly-right##27 9.854
R2341 Cin_to_XOR2___NAND2#26pmos@71_poly-right##27 Cin_to_XOR2___NAND2#26pmos@71_poly-right##28 9.854
R2342 Cin_to_XOR2___NAND2#26pmos@71_poly-right##28 Cin_to_XOR2___NAND2#26pmos@71_poly-right##29 9.854
R2343 Cin_to_XOR2___NAND2#26pmos@71_poly-right##29 Cin_to_XOR2___NAND2#26pmos@71_poly-right##30 9.854
R2344 Cin_to_XOR2___NAND2#26pmos@71_poly-right##30 Cin_to_XOR2___NAND2#26pmos@71_poly-right##31 9.854
R2345 Cin_to_XOR2___NAND2#26pmos@71_poly-right##31 Cin_to_XOR2___NAND2#26pmos@71_poly-right##32 9.854
R2346 Cin_to_XOR2___NAND2#26pmos@71_poly-right##32 Cin_to_XOR2___NAND2#26pmos@71_poly-right##33 9.854
R2347 Cin_to_XOR2___NAND2#26pmos@71_poly-right##33 Cin_to_XOR2___NAND2#26pmos@71_poly-right##34 9.854
R2348 Cin_to_XOR2___NAND2#26pmos@71_poly-right##34 Cin_to_XOR2___NAND2#26pmos@71_poly-right##35 9.854
R2349 Cin_to_XOR2___NAND2#26pmos@71_poly-right##35 Cin_to_XOR2___NAND2#26pmos@71_poly-right##36 9.854
R2350 Cin_to_XOR2___NAND2#26pmos@71_poly-right##36 Cin_to_XOR2___NAND2#26pmos@71_poly-right##37 9.854
R2351 Cin_to_XOR2___NAND2#26pmos@71_poly-right##37 Cin_to_XOR2___NAND2#26pmos@71_poly-right##38 9.854
R2352 Cin_to_XOR2___NAND2#26pmos@71_poly-right##38 Cin_to_XOR2___NAND2#26pmos@71_poly-right##39 9.854
R2353 Cin_to_XOR2___NAND2#26pmos@71_poly-right##39 Cin_to_XOR2___NAND2#26pmos@71_poly-right##40 9.854
R2354 Cin_to_XOR2___NAND2#26pmos@71_poly-right##40 Cin_to_XOR2___NAND2#26pmos@71_poly-right##41 9.854
R2355 Cin_to_XOR2___NAND2#26pmos@71_poly-right##41 Cin_to_XOR2___NAND2#26pmos@71_poly-right##42 9.854
R2356 Cin_to_XOR2___NAND2#26pmos@71_poly-right##42 Cin_to_XOR2___NAND2#26pmos@71_poly-right##43 9.854
R2357 Cin_to_XOR2___NAND2#26pmos@71_poly-right##43 Cin_to_XOR2___NAND2#26pmos@71_poly-right##44 9.854
R2358 Cin_to_XOR2___NAND2#26pmos@71_poly-right##44 Cin_to_XOR2___NAND2#26pmos@71_poly-right##45 9.854
R2359 Cin_to_XOR2___NAND2#26pmos@71_poly-right##45 Cin_to_XOR2___NAND2#26pmos@71_poly-right##46 9.854
R2360 Cin_to_XOR2___NAND2#26pmos@71_poly-right##46 Cin_to_XOR2___NAND2#26pmos@71_poly-right##47 9.854
R2361 Cin_to_XOR2___NAND2#26pmos@71_poly-right##47 Cin_to_XOR2___NAND2#26pmos@71_poly-right##48 9.854
R2362 Cin_to_XOR2___NAND2#26pmos@71_poly-right##48 Cin_to_XOR2___NAND2#26pmos@71_poly-right##49 9.854
R2363 Cin_to_XOR2___NAND2#26pmos@71_poly-right##49 Cin_to_XOR2___NAND2#26pmos@71_poly-right##50 9.854
R2364 Cin_to_XOR2___NAND2#26pmos@71_poly-right##50 Cin_to_XOR2___NAND2#26pmos@71_poly-right##51 9.854
R2365 Cin_to_XOR2___NAND2#26pmos@71_poly-right##51 Cin_to_XOR2___NAND2#26pmos@71_poly-right##52 9.854
R2366 Cin_to_XOR2___NAND2#26pmos@71_poly-right##52 Cin_to_XOR2___NAND2#26pmos@71_poly-right##53 9.854
R2367 Cin_to_XOR2___NAND2#26pmos@71_poly-right##53 Cin_to_XOR2___NAND2#26pmos@71_poly-right##54 9.854
R2368 Cin_to_XOR2___NAND2#26pmos@71_poly-right##54 Cin_to_XOR2___NAND2#15pin@368_polysilicon-1 9.854
R2369 net@1221 net@1221#2contact@505_metal-1-metal-2 4.797
R2370 XOR1_to_NAND2#9pmos@67_poly-left XOR1_to_NAND2#9pmos@67_poly-left##0 9.871
R2371 XOR1_to_NAND2#9pmos@67_poly-left##0 XOR1_to_NAND2#9pmos@67_poly-left##1 9.871
R2372 XOR1_to_NAND2#9pmos@67_poly-left##1 XOR1_to_NAND2#9pmos@67_poly-left##2 9.871
R2373 XOR1_to_NAND2#9pmos@67_poly-left##2 XOR1_to_NAND2#9pmos@67_poly-left##3 9.871
R2374 XOR1_to_NAND2#9pmos@67_poly-left##3 XOR1_to_NAND2#9pmos@67_poly-left##4 9.871
R2375 XOR1_to_NAND2#9pmos@67_poly-left##4 XOR1_to_NAND2#9pmos@67_poly-left##5 9.871
R2376 XOR1_to_NAND2#9pmos@67_poly-left##5 XOR1_to_NAND2#9pmos@67_poly-left##6 9.871
R2377 XOR1_to_NAND2#9pmos@67_poly-left##6 XOR1_to_NAND2#9pmos@67_poly-left##7 9.871
R2378 XOR1_to_NAND2#9pmos@67_poly-left##7 XOR1_to_NAND2#9pmos@67_poly-left##8 9.871
R2379 XOR1_to_NAND2#9pmos@67_poly-left##8 XOR1_to_NAND2#9pmos@67_poly-left##9 9.871
R2380 XOR1_to_NAND2#9pmos@67_poly-left##9 XOR1_to_NAND2#9pmos@67_poly-left##10 9.871
R2381 XOR1_to_NAND2#9pmos@67_poly-left##10 XOR1_to_NAND2#9pmos@67_poly-left##11 9.871
R2382 XOR1_to_NAND2#9pmos@67_poly-left##11 XOR1_to_NAND2#9pmos@67_poly-left##12 9.871
R2383 XOR1_to_NAND2#9pmos@67_poly-left##12 XOR1_to_NAND2#9pmos@67_poly-left##13 9.871
R2384 XOR1_to_NAND2#9pmos@67_poly-left##13 XOR1_to_NAND2#9pmos@67_poly-left##14 9.871
R2385 XOR1_to_NAND2#9pmos@67_poly-left##14 XOR1_to_NAND2#9pmos@67_poly-left##15 9.871
R2386 XOR1_to_NAND2#9pmos@67_poly-left##15 XOR1_to_NAND2#9pmos@67_poly-left##16 9.871
R2387 XOR1_to_NAND2#9pmos@67_poly-left##16 XOR1_to_NAND2#9pmos@67_poly-left##17 9.871
R2388 XOR1_to_NAND2#9pmos@67_poly-left##17 XOR1_to_NAND2#9pmos@67_poly-left##18 9.871
R2389 XOR1_to_NAND2#9pmos@67_poly-left##18 XOR1_to_NAND2#9pmos@67_poly-left##19 9.871
R2390 XOR1_to_NAND2#9pmos@67_poly-left##19 XOR1_to_NAND2#9pmos@67_poly-left##20 9.871
R2391 XOR1_to_NAND2#9pmos@67_poly-left##20 XOR1_to_NAND2#9pmos@67_poly-left##21 9.871
R2392 XOR1_to_NAND2#9pmos@67_poly-left##21 XOR1_to_NAND2#9pmos@67_poly-left##22 9.871
R2393 XOR1_to_NAND2#9pmos@67_poly-left##22 XOR1_to_NAND2#9pmos@67_poly-left##23 9.871
R2394 XOR1_to_NAND2#9pmos@67_poly-left##23 XOR1_to_NAND2#9pmos@67_poly-left##24 9.871
R2395 XOR1_to_NAND2#9pmos@67_poly-left##24 XOR1_to_NAND2#9pmos@67_poly-left##25 9.871
R2396 XOR1_to_NAND2#9pmos@67_poly-left##25 XOR1_to_NAND2#9pmos@67_poly-left##26 9.871
R2397 XOR1_to_NAND2#9pmos@67_poly-left##26 XOR1_to_NAND2#9pmos@67_poly-left##27 9.871
R2398 XOR1_to_NAND2#9pmos@67_poly-left##27 XOR1_to_NAND2#9pmos@67_poly-left##28 9.871
R2399 XOR1_to_NAND2#9pmos@67_poly-left##28 XOR1_to_NAND2#9pmos@67_poly-left##29 9.871
R2400 XOR1_to_NAND2#9pmos@67_poly-left##29 XOR1_to_NAND2#9pmos@67_poly-left##30 9.871
R2401 XOR1_to_NAND2#9pmos@67_poly-left##30 XOR1_to_NAND2#9pmos@67_poly-left##31 9.871
R2402 XOR1_to_NAND2#9pmos@67_poly-left##31 XOR1_to_NAND2#9pmos@67_poly-left##32 9.871
R2403 XOR1_to_NAND2#9pmos@67_poly-left##32 XOR1_to_NAND2#9pmos@67_poly-left##33 9.871
R2404 XOR1_to_NAND2#9pmos@67_poly-left##33 XOR1_to_NAND2#9pmos@67_poly-left##34 9.871
R2405 XOR1_to_NAND2#9pmos@67_poly-left##34 XOR1_to_NAND2#9pmos@67_poly-left##35 9.871
R2406 XOR1_to_NAND2#9pmos@67_poly-left##35 XOR1_to_NAND2#9pmos@67_poly-left##36 9.871
R2407 XOR1_to_NAND2#9pmos@67_poly-left##36 XOR1_to_NAND2#9pmos@67_poly-left##37 9.871
R2408 XOR1_to_NAND2#9pmos@67_poly-left##37 XOR1_to_NAND2#9pmos@67_poly-left##38 9.871
R2409 XOR1_to_NAND2#9pmos@67_poly-left##38 XOR1_to_NAND2#9pmos@67_poly-left##39 9.871
R2410 XOR1_to_NAND2#9pmos@67_poly-left##39 XOR1_to_NAND2#9pmos@67_poly-left##40 9.871
R2411 XOR1_to_NAND2#9pmos@67_poly-left##40 XOR1_to_NAND2#9pmos@67_poly-left##41 9.871
R2412 XOR1_to_NAND2#9pmos@67_poly-left##41 XOR1_to_NAND2#9pmos@67_poly-left##42 9.871
R2413 XOR1_to_NAND2#9pmos@67_poly-left##42 XOR1_to_NAND2#9pmos@67_poly-left##43 9.871
R2414 XOR1_to_NAND2#9pmos@67_poly-left##43 XOR1_to_NAND2#9pmos@67_poly-left##44 9.871
R2415 XOR1_to_NAND2#9pmos@67_poly-left##44 XOR1_to_NAND2#9pmos@67_poly-left##45 9.871
R2416 XOR1_to_NAND2#9pmos@67_poly-left##45 XOR1_to_NAND2#9pmos@67_poly-left##46 9.871
R2417 XOR1_to_NAND2#9pmos@67_poly-left##46 XOR1_to_NAND2#9pmos@67_poly-left##47 9.871
R2418 XOR1_to_NAND2#9pmos@67_poly-left##47 XOR1_to_NAND2#9pmos@67_poly-left##48 9.871
R2419 XOR1_to_NAND2#9pmos@67_poly-left##48 XOR1_to_NAND2#9pmos@67_poly-left##49 9.871
R2420 XOR1_to_NAND2#9pmos@67_poly-left##49 XOR1_to_NAND2#9pmos@67_poly-left##50 9.871
R2421 XOR1_to_NAND2#9pmos@67_poly-left##50 XOR1_to_NAND2#9pmos@67_poly-left##51 9.871
R2422 XOR1_to_NAND2#9pmos@67_poly-left##51 XOR1_to_NAND2#9pmos@67_poly-left##52 9.871
R2423 XOR1_to_NAND2#9pmos@67_poly-left##52 XOR1_to_NAND2#9pmos@67_poly-left##53 9.871
R2424 XOR1_to_NAND2#9pmos@67_poly-left##53 XOR1_to_NAND2#9pmos@67_poly-left##54 9.871
R2425 XOR1_to_NAND2#9pmos@67_poly-left##54 XOR1_to_NAND2#9pmos@67_poly-left##55 9.871
R2426 XOR1_to_NAND2#9pmos@67_poly-left##55 XOR1_to_NAND2#26nmos@67_poly-right 9.871
R2427 net@1211#7pmos@68_poly-left net@1211#7pmos@68_poly-left##0 9.871
R2428 net@1211#7pmos@68_poly-left##0 net@1211#7pmos@68_poly-left##1 9.871
R2429 net@1211#7pmos@68_poly-left##1 net@1211#7pmos@68_poly-left##2 9.871
R2430 net@1211#7pmos@68_poly-left##2 net@1211#7pmos@68_poly-left##3 9.871
R2431 net@1211#7pmos@68_poly-left##3 net@1211#7pmos@68_poly-left##4 9.871
R2432 net@1211#7pmos@68_poly-left##4 net@1211#7pmos@68_poly-left##5 9.871
R2433 net@1211#7pmos@68_poly-left##5 net@1211#7pmos@68_poly-left##6 9.871
R2434 net@1211#7pmos@68_poly-left##6 net@1211#7pmos@68_poly-left##7 9.871
R2435 net@1211#7pmos@68_poly-left##7 net@1211#7pmos@68_poly-left##8 9.871
R2436 net@1211#7pmos@68_poly-left##8 net@1211#7pmos@68_poly-left##9 9.871
R2437 net@1211#7pmos@68_poly-left##9 net@1211#7pmos@68_poly-left##10 9.871
R2438 net@1211#7pmos@68_poly-left##10 net@1211#7pmos@68_poly-left##11 9.871
R2439 net@1211#7pmos@68_poly-left##11 net@1211#7pmos@68_poly-left##12 9.871
R2440 net@1211#7pmos@68_poly-left##12 net@1211#7pmos@68_poly-left##13 9.871
R2441 net@1211#7pmos@68_poly-left##13 net@1211#7pmos@68_poly-left##14 9.871
R2442 net@1211#7pmos@68_poly-left##14 net@1211#7pmos@68_poly-left##15 9.871
R2443 net@1211#7pmos@68_poly-left##15 net@1211#7pmos@68_poly-left##16 9.871
R2444 net@1211#7pmos@68_poly-left##16 net@1211#7pmos@68_poly-left##17 9.871
R2445 net@1211#7pmos@68_poly-left##17 net@1211#7pmos@68_poly-left##18 9.871
R2446 net@1211#7pmos@68_poly-left##18 net@1211#7pmos@68_poly-left##19 9.871
R2447 net@1211#7pmos@68_poly-left##19 net@1211#7pmos@68_poly-left##20 9.871
R2448 net@1211#7pmos@68_poly-left##20 net@1211#7pmos@68_poly-left##21 9.871
R2449 net@1211#7pmos@68_poly-left##21 net@1211#7pmos@68_poly-left##22 9.871
R2450 net@1211#7pmos@68_poly-left##22 net@1211#7pmos@68_poly-left##23 9.871
R2451 net@1211#7pmos@68_poly-left##23 net@1211#7pmos@68_poly-left##24 9.871
R2452 net@1211#7pmos@68_poly-left##24 net@1211#7pmos@68_poly-left##25 9.871
R2453 net@1211#7pmos@68_poly-left##25 net@1211#7pmos@68_poly-left##26 9.871
R2454 net@1211#7pmos@68_poly-left##26 net@1211#7pmos@68_poly-left##27 9.871
R2455 net@1211#7pmos@68_poly-left##27 net@1211#7pmos@68_poly-left##28 9.871
R2456 net@1211#7pmos@68_poly-left##28 net@1211#7pmos@68_poly-left##29 9.871
R2457 net@1211#7pmos@68_poly-left##29 net@1211#7pmos@68_poly-left##30 9.871
R2458 net@1211#7pmos@68_poly-left##30 net@1211#7pmos@68_poly-left##31 9.871
R2459 net@1211#7pmos@68_poly-left##31 net@1211#7pmos@68_poly-left##32 9.871
R2460 net@1211#7pmos@68_poly-left##32 net@1211#7pmos@68_poly-left##33 9.871
R2461 net@1211#7pmos@68_poly-left##33 net@1211#7pmos@68_poly-left##34 9.871
R2462 net@1211#7pmos@68_poly-left##34 net@1211#7pmos@68_poly-left##35 9.871
R2463 net@1211#7pmos@68_poly-left##35 net@1211#7pmos@68_poly-left##36 9.871
R2464 net@1211#7pmos@68_poly-left##36 net@1211#7pmos@68_poly-left##37 9.871
R2465 net@1211#7pmos@68_poly-left##37 net@1211#7pmos@68_poly-left##38 9.871
R2466 net@1211#7pmos@68_poly-left##38 net@1211#7pmos@68_poly-left##39 9.871
R2467 net@1211#7pmos@68_poly-left##39 net@1211#7pmos@68_poly-left##40 9.871
R2468 net@1211#7pmos@68_poly-left##40 net@1211#7pmos@68_poly-left##41 9.871
R2469 net@1211#7pmos@68_poly-left##41 net@1211#7pmos@68_poly-left##42 9.871
R2470 net@1211#7pmos@68_poly-left##42 net@1211#7pmos@68_poly-left##43 9.871
R2471 net@1211#7pmos@68_poly-left##43 net@1211#7pmos@68_poly-left##44 9.871
R2472 net@1211#7pmos@68_poly-left##44 net@1211#7pmos@68_poly-left##45 9.871
R2473 net@1211#7pmos@68_poly-left##45 net@1211#7pmos@68_poly-left##46 9.871
R2474 net@1211#7pmos@68_poly-left##46 net@1211#7pmos@68_poly-left##47 9.871
R2475 net@1211#7pmos@68_poly-left##47 net@1211#7pmos@68_poly-left##48 9.871
R2476 net@1211#7pmos@68_poly-left##48 net@1211#7pmos@68_poly-left##49 9.871
R2477 net@1211#7pmos@68_poly-left##49 net@1211#7pmos@68_poly-left##50 9.871
R2478 net@1211#7pmos@68_poly-left##50 net@1211#7pmos@68_poly-left##51 9.871
R2479 net@1211#7pmos@68_poly-left##51 net@1211#7pmos@68_poly-left##52 9.871
R2480 net@1211#7pmos@68_poly-left##52 net@1211#7pmos@68_poly-left##53 9.871
R2481 net@1211#7pmos@68_poly-left##53 net@1211#7pmos@68_poly-left##54 9.871
R2482 net@1211#7pmos@68_poly-left##54 net@1211#7pmos@68_poly-left##55 9.871
R2483 net@1211#7pmos@68_poly-left##55 net@1211#11nmos@68_poly-right 9.871
R2484 Cin_to_XOR2___NAND2#27pmos@69_poly-right Cin_to_XOR2___NAND2#27pmos@69_poly-right##0 9.871
R2485 Cin_to_XOR2___NAND2#27pmos@69_poly-right##0 Cin_to_XOR2___NAND2#27pmos@69_poly-right##1 9.871
R2486 Cin_to_XOR2___NAND2#27pmos@69_poly-right##1 Cin_to_XOR2___NAND2#27pmos@69_poly-right##2 9.871
R2487 Cin_to_XOR2___NAND2#27pmos@69_poly-right##2 Cin_to_XOR2___NAND2#27pmos@69_poly-right##3 9.871
R2488 Cin_to_XOR2___NAND2#27pmos@69_poly-right##3 Cin_to_XOR2___NAND2#27pmos@69_poly-right##4 9.871
R2489 Cin_to_XOR2___NAND2#27pmos@69_poly-right##4 Cin_to_XOR2___NAND2#27pmos@69_poly-right##5 9.871
R2490 Cin_to_XOR2___NAND2#27pmos@69_poly-right##5 Cin_to_XOR2___NAND2#27pmos@69_poly-right##6 9.871
R2491 Cin_to_XOR2___NAND2#27pmos@69_poly-right##6 Cin_to_XOR2___NAND2#27pmos@69_poly-right##7 9.871
R2492 Cin_to_XOR2___NAND2#27pmos@69_poly-right##7 Cin_to_XOR2___NAND2#27pmos@69_poly-right##8 9.871
R2493 Cin_to_XOR2___NAND2#27pmos@69_poly-right##8 Cin_to_XOR2___NAND2#27pmos@69_poly-right##9 9.871
R2494 Cin_to_XOR2___NAND2#27pmos@69_poly-right##9 Cin_to_XOR2___NAND2#27pmos@69_poly-right##10 9.871
R2495 Cin_to_XOR2___NAND2#27pmos@69_poly-right##10 Cin_to_XOR2___NAND2#27pmos@69_poly-right##11 9.871
R2496 Cin_to_XOR2___NAND2#27pmos@69_poly-right##11 Cin_to_XOR2___NAND2#27pmos@69_poly-right##12 9.871
R2497 Cin_to_XOR2___NAND2#27pmos@69_poly-right##12 Cin_to_XOR2___NAND2#27pmos@69_poly-right##13 9.871
R2498 Cin_to_XOR2___NAND2#27pmos@69_poly-right##13 Cin_to_XOR2___NAND2#27pmos@69_poly-right##14 9.871
R2499 Cin_to_XOR2___NAND2#27pmos@69_poly-right##14 Cin_to_XOR2___NAND2#27pmos@69_poly-right##15 9.871
R2500 Cin_to_XOR2___NAND2#27pmos@69_poly-right##15 Cin_to_XOR2___NAND2#27pmos@69_poly-right##16 9.871
R2501 Cin_to_XOR2___NAND2#27pmos@69_poly-right##16 Cin_to_XOR2___NAND2#27pmos@69_poly-right##17 9.871
R2502 Cin_to_XOR2___NAND2#27pmos@69_poly-right##17 Cin_to_XOR2___NAND2#27pmos@69_poly-right##18 9.871
R2503 Cin_to_XOR2___NAND2#27pmos@69_poly-right##18 Cin_to_XOR2___NAND2#27pmos@69_poly-right##19 9.871
R2504 Cin_to_XOR2___NAND2#27pmos@69_poly-right##19 Cin_to_XOR2___NAND2#27pmos@69_poly-right##20 9.871
R2505 Cin_to_XOR2___NAND2#27pmos@69_poly-right##20 Cin_to_XOR2___NAND2#27pmos@69_poly-right##21 9.871
R2506 Cin_to_XOR2___NAND2#27pmos@69_poly-right##21 Cin_to_XOR2___NAND2#27pmos@69_poly-right##22 9.871
R2507 Cin_to_XOR2___NAND2#27pmos@69_poly-right##22 Cin_to_XOR2___NAND2#27pmos@69_poly-right##23 9.871
R2508 Cin_to_XOR2___NAND2#27pmos@69_poly-right##23 Cin_to_XOR2___NAND2#27pmos@69_poly-right##24 9.871
R2509 Cin_to_XOR2___NAND2#27pmos@69_poly-right##24 Cin_to_XOR2___NAND2#27pmos@69_poly-right##25 9.871
R2510 Cin_to_XOR2___NAND2#27pmos@69_poly-right##25 Cin_to_XOR2___NAND2#27pmos@69_poly-right##26 9.871
R2511 Cin_to_XOR2___NAND2#27pmos@69_poly-right##26 Cin_to_XOR2___NAND2#27pmos@69_poly-right##27 9.871
R2512 Cin_to_XOR2___NAND2#27pmos@69_poly-right##27 Cin_to_XOR2___NAND2#27pmos@69_poly-right##28 9.871
R2513 Cin_to_XOR2___NAND2#27pmos@69_poly-right##28 Cin_to_XOR2___NAND2#27pmos@69_poly-right##29 9.871
R2514 Cin_to_XOR2___NAND2#27pmos@69_poly-right##29 Cin_to_XOR2___NAND2#27pmos@69_poly-right##30 9.871
R2515 Cin_to_XOR2___NAND2#27pmos@69_poly-right##30 Cin_to_XOR2___NAND2#27pmos@69_poly-right##31 9.871
R2516 Cin_to_XOR2___NAND2#27pmos@69_poly-right##31 Cin_to_XOR2___NAND2#27pmos@69_poly-right##32 9.871
R2517 Cin_to_XOR2___NAND2#27pmos@69_poly-right##32 Cin_to_XOR2___NAND2#27pmos@69_poly-right##33 9.871
R2518 Cin_to_XOR2___NAND2#27pmos@69_poly-right##33 Cin_to_XOR2___NAND2#27pmos@69_poly-right##34 9.871
R2519 Cin_to_XOR2___NAND2#27pmos@69_poly-right##34 Cin_to_XOR2___NAND2#27pmos@69_poly-right##35 9.871
R2520 Cin_to_XOR2___NAND2#27pmos@69_poly-right##35 Cin_to_XOR2___NAND2#27pmos@69_poly-right##36 9.871
R2521 Cin_to_XOR2___NAND2#27pmos@69_poly-right##36 Cin_to_XOR2___NAND2#27pmos@69_poly-right##37 9.871
R2522 Cin_to_XOR2___NAND2#27pmos@69_poly-right##37 Cin_to_XOR2___NAND2#27pmos@69_poly-right##38 9.871
R2523 Cin_to_XOR2___NAND2#27pmos@69_poly-right##38 Cin_to_XOR2___NAND2#27pmos@69_poly-right##39 9.871
R2524 Cin_to_XOR2___NAND2#27pmos@69_poly-right##39 Cin_to_XOR2___NAND2#27pmos@69_poly-right##40 9.871
R2525 Cin_to_XOR2___NAND2#27pmos@69_poly-right##40 Cin_to_XOR2___NAND2#27pmos@69_poly-right##41 9.871
R2526 Cin_to_XOR2___NAND2#27pmos@69_poly-right##41 Cin_to_XOR2___NAND2#27pmos@69_poly-right##42 9.871
R2527 Cin_to_XOR2___NAND2#27pmos@69_poly-right##42 Cin_to_XOR2___NAND2#27pmos@69_poly-right##43 9.871
R2528 Cin_to_XOR2___NAND2#27pmos@69_poly-right##43 Cin_to_XOR2___NAND2#27pmos@69_poly-right##44 9.871
R2529 Cin_to_XOR2___NAND2#27pmos@69_poly-right##44 Cin_to_XOR2___NAND2#27pmos@69_poly-right##45 9.871
R2530 Cin_to_XOR2___NAND2#27pmos@69_poly-right##45 Cin_to_XOR2___NAND2#27pmos@69_poly-right##46 9.871
R2531 Cin_to_XOR2___NAND2#27pmos@69_poly-right##46 Cin_to_XOR2___NAND2#27pmos@69_poly-right##47 9.871
R2532 Cin_to_XOR2___NAND2#27pmos@69_poly-right##47 Cin_to_XOR2___NAND2#27pmos@69_poly-right##48 9.871
R2533 Cin_to_XOR2___NAND2#27pmos@69_poly-right##48 Cin_to_XOR2___NAND2#27pmos@69_poly-right##49 9.871
R2534 Cin_to_XOR2___NAND2#27pmos@69_poly-right##49 Cin_to_XOR2___NAND2#27pmos@69_poly-right##50 9.871
R2535 Cin_to_XOR2___NAND2#27pmos@69_poly-right##50 Cin_to_XOR2___NAND2#27pmos@69_poly-right##51 9.871
R2536 Cin_to_XOR2___NAND2#27pmos@69_poly-right##51 Cin_to_XOR2___NAND2#27pmos@69_poly-right##52 9.871
R2537 Cin_to_XOR2___NAND2#27pmos@69_poly-right##52 Cin_to_XOR2___NAND2#27pmos@69_poly-right##53 9.871
R2538 Cin_to_XOR2___NAND2#27pmos@69_poly-right##53 Cin_to_XOR2___NAND2#27pmos@69_poly-right##54 9.871
R2539 Cin_to_XOR2___NAND2#27pmos@69_poly-right##54 Cin_to_XOR2___NAND2#27pmos@69_poly-right##55 9.871
R2540 Cin_to_XOR2___NAND2#27pmos@69_poly-right##55 Cin_to_XOR2___NAND2#18nmos@69_poly-left 9.871
R2541 net@1221#14pmos@70_poly-right net@1221#14pmos@70_poly-right##0 9.871
R2542 net@1221#14pmos@70_poly-right##0 net@1221#14pmos@70_poly-right##1 9.871
R2543 net@1221#14pmos@70_poly-right##1 net@1221#14pmos@70_poly-right##2 9.871
R2544 net@1221#14pmos@70_poly-right##2 net@1221#14pmos@70_poly-right##3 9.871
R2545 net@1221#14pmos@70_poly-right##3 net@1221#14pmos@70_poly-right##4 9.871
R2546 net@1221#14pmos@70_poly-right##4 net@1221#14pmos@70_poly-right##5 9.871
R2547 net@1221#14pmos@70_poly-right##5 net@1221#14pmos@70_poly-right##6 9.871
R2548 net@1221#14pmos@70_poly-right##6 net@1221#14pmos@70_poly-right##7 9.871
R2549 net@1221#14pmos@70_poly-right##7 net@1221#14pmos@70_poly-right##8 9.871
R2550 net@1221#14pmos@70_poly-right##8 net@1221#14pmos@70_poly-right##9 9.871
R2551 net@1221#14pmos@70_poly-right##9 net@1221#14pmos@70_poly-right##10 9.871
R2552 net@1221#14pmos@70_poly-right##10 net@1221#14pmos@70_poly-right##11 9.871
R2553 net@1221#14pmos@70_poly-right##11 net@1221#14pmos@70_poly-right##12 9.871
R2554 net@1221#14pmos@70_poly-right##12 net@1221#14pmos@70_poly-right##13 9.871
R2555 net@1221#14pmos@70_poly-right##13 net@1221#14pmos@70_poly-right##14 9.871
R2556 net@1221#14pmos@70_poly-right##14 net@1221#14pmos@70_poly-right##15 9.871
R2557 net@1221#14pmos@70_poly-right##15 net@1221#14pmos@70_poly-right##16 9.871
R2558 net@1221#14pmos@70_poly-right##16 net@1221#14pmos@70_poly-right##17 9.871
R2559 net@1221#14pmos@70_poly-right##17 net@1221#14pmos@70_poly-right##18 9.871
R2560 net@1221#14pmos@70_poly-right##18 net@1221#14pmos@70_poly-right##19 9.871
R2561 net@1221#14pmos@70_poly-right##19 net@1221#14pmos@70_poly-right##20 9.871
R2562 net@1221#14pmos@70_poly-right##20 net@1221#14pmos@70_poly-right##21 9.871
R2563 net@1221#14pmos@70_poly-right##21 net@1221#14pmos@70_poly-right##22 9.871
R2564 net@1221#14pmos@70_poly-right##22 net@1221#14pmos@70_poly-right##23 9.871
R2565 net@1221#14pmos@70_poly-right##23 net@1221#14pmos@70_poly-right##24 9.871
R2566 net@1221#14pmos@70_poly-right##24 net@1221#14pmos@70_poly-right##25 9.871
R2567 net@1221#14pmos@70_poly-right##25 net@1221#14pmos@70_poly-right##26 9.871
R2568 net@1221#14pmos@70_poly-right##26 net@1221#14pmos@70_poly-right##27 9.871
R2569 net@1221#14pmos@70_poly-right##27 net@1221#14pmos@70_poly-right##28 9.871
R2570 net@1221#14pmos@70_poly-right##28 net@1221#14pmos@70_poly-right##29 9.871
R2571 net@1221#14pmos@70_poly-right##29 net@1221#14pmos@70_poly-right##30 9.871
R2572 net@1221#14pmos@70_poly-right##30 net@1221#14pmos@70_poly-right##31 9.871
R2573 net@1221#14pmos@70_poly-right##31 net@1221#14pmos@70_poly-right##32 9.871
R2574 net@1221#14pmos@70_poly-right##32 net@1221#14pmos@70_poly-right##33 9.871
R2575 net@1221#14pmos@70_poly-right##33 net@1221#14pmos@70_poly-right##34 9.871
R2576 net@1221#14pmos@70_poly-right##34 net@1221#14pmos@70_poly-right##35 9.871
R2577 net@1221#14pmos@70_poly-right##35 net@1221#14pmos@70_poly-right##36 9.871
R2578 net@1221#14pmos@70_poly-right##36 net@1221#14pmos@70_poly-right##37 9.871
R2579 net@1221#14pmos@70_poly-right##37 net@1221#14pmos@70_poly-right##38 9.871
R2580 net@1221#14pmos@70_poly-right##38 net@1221#14pmos@70_poly-right##39 9.871
R2581 net@1221#14pmos@70_poly-right##39 net@1221#14pmos@70_poly-right##40 9.871
R2582 net@1221#14pmos@70_poly-right##40 net@1221#14pmos@70_poly-right##41 9.871
R2583 net@1221#14pmos@70_poly-right##41 net@1221#14pmos@70_poly-right##42 9.871
R2584 net@1221#14pmos@70_poly-right##42 net@1221#14pmos@70_poly-right##43 9.871
R2585 net@1221#14pmos@70_poly-right##43 net@1221#14pmos@70_poly-right##44 9.871
R2586 net@1221#14pmos@70_poly-right##44 net@1221#14pmos@70_poly-right##45 9.871
R2587 net@1221#14pmos@70_poly-right##45 net@1221#14pmos@70_poly-right##46 9.871
R2588 net@1221#14pmos@70_poly-right##46 net@1221#14pmos@70_poly-right##47 9.871
R2589 net@1221#14pmos@70_poly-right##47 net@1221#14pmos@70_poly-right##48 9.871
R2590 net@1221#14pmos@70_poly-right##48 net@1221#14pmos@70_poly-right##49 9.871
R2591 net@1221#14pmos@70_poly-right##49 net@1221#14pmos@70_poly-right##50 9.871
R2592 net@1221#14pmos@70_poly-right##50 net@1221#14pmos@70_poly-right##51 9.871
R2593 net@1221#14pmos@70_poly-right##51 net@1221#14pmos@70_poly-right##52 9.871
R2594 net@1221#14pmos@70_poly-right##52 net@1221#14pmos@70_poly-right##53 9.871
R2595 net@1221#14pmos@70_poly-right##53 net@1221#14pmos@70_poly-right##54 9.871
R2596 net@1221#14pmos@70_poly-right##54 net@1221#14pmos@70_poly-right##55 9.871
R2597 net@1221#14pmos@70_poly-right##55 net@1221#9nmos@70_poly-left 9.871
R2598 net@1220#2contact@530_metal-1-polysilicon-1 net@1220 4.654
R2599 net@1220#12pmos@73_poly-right net@1220#12pmos@73_poly-right##0 9.931
R2600 net@1220#12pmos@73_poly-right##0 net@1220#12pmos@73_poly-right##1 9.931
R2601 net@1220#12pmos@73_poly-right##1 net@1220#12pmos@73_poly-right##2 9.931
R2602 net@1220#12pmos@73_poly-right##2 net@1220#12pmos@73_poly-right##3 9.931
R2603 net@1220#12pmos@73_poly-right##3 net@1220#12pmos@73_poly-right##4 9.931
R2604 net@1220#12pmos@73_poly-right##4 net@1220#12pmos@73_poly-right##5 9.931
R2605 net@1220#12pmos@73_poly-right##5 net@1220#12pmos@73_poly-right##6 9.931
R2606 net@1220#12pmos@73_poly-right##6 net@1220#12pmos@73_poly-right##7 9.931
R2607 net@1220#12pmos@73_poly-right##7 net@1220#12pmos@73_poly-right##8 9.931
R2608 net@1220#12pmos@73_poly-right##8 net@1220#12pmos@73_poly-right##9 9.931
R2609 net@1220#12pmos@73_poly-right##9 net@1220#12pmos@73_poly-right##10 9.931
R2610 net@1220#12pmos@73_poly-right##10 net@1220#12pmos@73_poly-right##11 9.931
R2611 net@1220#12pmos@73_poly-right##11 net@1220#12pmos@73_poly-right##12 9.931
R2612 net@1220#12pmos@73_poly-right##12 net@1220#12pmos@73_poly-right##13 9.931
R2613 net@1220#12pmos@73_poly-right##13 net@1220#12pmos@73_poly-right##14 9.931
R2614 net@1220#12pmos@73_poly-right##14 net@1220#12pmos@73_poly-right##15 9.931
R2615 net@1220#12pmos@73_poly-right##15 net@1220#12pmos@73_poly-right##16 9.931
R2616 net@1220#12pmos@73_poly-right##16 net@1220#12pmos@73_poly-right##17 9.931
R2617 net@1220#12pmos@73_poly-right##17 net@1220#12pmos@73_poly-right##18 9.931
R2618 net@1220#12pmos@73_poly-right##18 net@1220#12pmos@73_poly-right##19 9.931
R2619 net@1220#12pmos@73_poly-right##19 net@1220#12pmos@73_poly-right##20 9.931
R2620 net@1220#12pmos@73_poly-right##20 net@1220#12pmos@73_poly-right##21 9.931
R2621 net@1220#12pmos@73_poly-right##21 net@1220#12pmos@73_poly-right##22 9.931
R2622 net@1220#12pmos@73_poly-right##22 net@1220#12pmos@73_poly-right##23 9.931
R2623 net@1220#12pmos@73_poly-right##23 net@1220#12pmos@73_poly-right##24 9.931
R2624 net@1220#12pmos@73_poly-right##24 net@1220#12pmos@73_poly-right##25 9.931
R2625 net@1220#12pmos@73_poly-right##25 net@1220#12pmos@73_poly-right##26 9.931
R2626 net@1220#12pmos@73_poly-right##26 net@1220#12pmos@73_poly-right##27 9.931
R2627 net@1220#12pmos@73_poly-right##27 net@1220#12pmos@73_poly-right##28 9.931
R2628 net@1220#12pmos@73_poly-right##28 net@1220#12pmos@73_poly-right##29 9.931
R2629 net@1220#12pmos@73_poly-right##29 net@1220#12pmos@73_poly-right##30 9.931
R2630 net@1220#12pmos@73_poly-right##30 net@1220#12pmos@73_poly-right##31 9.931
R2631 net@1220#12pmos@73_poly-right##31 net@1220#12pmos@73_poly-right##32 9.931
R2632 net@1220#12pmos@73_poly-right##32 net@1220#12pmos@73_poly-right##33 9.931
R2633 net@1220#12pmos@73_poly-right##33 net@1220#12pmos@73_poly-right##34 9.931
R2634 net@1220#12pmos@73_poly-right##34 net@1220#12pmos@73_poly-right##35 9.931
R2635 net@1220#12pmos@73_poly-right##35 net@1220#12pmos@73_poly-right##36 9.931
R2636 net@1220#12pmos@73_poly-right##36 net@1220#12pmos@73_poly-right##37 9.931
R2637 net@1220#12pmos@73_poly-right##37 net@1220#12pmos@73_poly-right##38 9.931
R2638 net@1220#12pmos@73_poly-right##38 net@1220#12pmos@73_poly-right##39 9.931
R2639 net@1220#12pmos@73_poly-right##39 net@1220#12pmos@73_poly-right##40 9.931
R2640 net@1220#12pmos@73_poly-right##40 net@1220#12pmos@73_poly-right##41 9.931
R2641 net@1220#12pmos@73_poly-right##41 net@1220#12pmos@73_poly-right##42 9.931
R2642 net@1220#12pmos@73_poly-right##42 net@1220#12pmos@73_poly-right##43 9.931
R2643 net@1220#12pmos@73_poly-right##43 net@1220#12pmos@73_poly-right##44 9.931
R2644 net@1220#12pmos@73_poly-right##44 net@1220#12pmos@73_poly-right##45 9.931
R2645 net@1220#12pmos@73_poly-right##45 net@1220#12pmos@73_poly-right##46 9.931
R2646 net@1220#12pmos@73_poly-right##46 net@1220#12pmos@73_poly-right##47 9.931
R2647 net@1220#12pmos@73_poly-right##47 net@1220#12pmos@73_poly-right##48 9.931
R2648 net@1220#12pmos@73_poly-right##48 net@1220#12pmos@73_poly-right##49 9.931
R2649 net@1220#12pmos@73_poly-right##49 net@1220#12pmos@73_poly-right##50 9.931
R2650 net@1220#12pmos@73_poly-right##50 net@1220#12pmos@73_poly-right##51 9.931
R2651 net@1220#12pmos@73_poly-right##51 net@1220#12pmos@73_poly-right##52 9.931
R2652 net@1220#12pmos@73_poly-right##52 net@1220#5pin@370_polysilicon-1 9.931
R2653 Sum1#4pmos@73_diff-top Sum1 4.823
R2654 XOR1_to_NAND2#14pin@382_polysilicon-1 XOR1_to_NAND2#14pin@382_polysilicon-1##0 9.854
R2655 XOR1_to_NAND2#14pin@382_polysilicon-1##0 XOR1_to_NAND2#14pin@382_polysilicon-1##1 9.854
R2656 XOR1_to_NAND2#14pin@382_polysilicon-1##1 XOR1_to_NAND2#14pin@382_polysilicon-1##2 9.854
R2657 XOR1_to_NAND2#14pin@382_polysilicon-1##2 XOR1_to_NAND2#14pin@382_polysilicon-1##3 9.854
R2658 XOR1_to_NAND2#14pin@382_polysilicon-1##3 XOR1_to_NAND2#14pin@382_polysilicon-1##4 9.854
R2659 XOR1_to_NAND2#14pin@382_polysilicon-1##4 XOR1_to_NAND2#14pin@382_polysilicon-1##5 9.854
R2660 XOR1_to_NAND2#14pin@382_polysilicon-1##5 XOR1_to_NAND2#14pin@382_polysilicon-1##6 9.854
R2661 XOR1_to_NAND2#14pin@382_polysilicon-1##6 XOR1_to_NAND2#14pin@382_polysilicon-1##7 9.854
R2662 XOR1_to_NAND2#14pin@382_polysilicon-1##7 XOR1_to_NAND2#14pin@382_polysilicon-1##8 9.854
R2663 XOR1_to_NAND2#14pin@382_polysilicon-1##8 XOR1_to_NAND2#14pin@382_polysilicon-1##9 9.854
R2664 XOR1_to_NAND2#14pin@382_polysilicon-1##9 XOR1_to_NAND2#14pin@382_polysilicon-1##10 9.854
R2665 XOR1_to_NAND2#14pin@382_polysilicon-1##10 XOR1_to_NAND2#14pin@382_polysilicon-1##11 9.854
R2666 XOR1_to_NAND2#14pin@382_polysilicon-1##11 XOR1_to_NAND2#14pin@382_polysilicon-1##12 9.854
R2667 XOR1_to_NAND2#14pin@382_polysilicon-1##12 XOR1_to_NAND2#14pin@382_polysilicon-1##13 9.854
R2668 XOR1_to_NAND2#14pin@382_polysilicon-1##13 XOR1_to_NAND2#14pin@382_polysilicon-1##14 9.854
R2669 XOR1_to_NAND2#14pin@382_polysilicon-1##14 XOR1_to_NAND2#14pin@382_polysilicon-1##15 9.854
R2670 XOR1_to_NAND2#14pin@382_polysilicon-1##15 XOR1_to_NAND2#14pin@382_polysilicon-1##16 9.854
R2671 XOR1_to_NAND2#14pin@382_polysilicon-1##16 XOR1_to_NAND2#14pin@382_polysilicon-1##17 9.854
R2672 XOR1_to_NAND2#14pin@382_polysilicon-1##17 XOR1_to_NAND2#14pin@382_polysilicon-1##18 9.854
R2673 XOR1_to_NAND2#14pin@382_polysilicon-1##18 XOR1_to_NAND2#14pin@382_polysilicon-1##19 9.854
R2674 XOR1_to_NAND2#14pin@382_polysilicon-1##19 XOR1_to_NAND2#14pin@382_polysilicon-1##20 9.854
R2675 XOR1_to_NAND2#14pin@382_polysilicon-1##20 XOR1_to_NAND2#14pin@382_polysilicon-1##21 9.854
R2676 XOR1_to_NAND2#14pin@382_polysilicon-1##21 XOR1_to_NAND2#14pin@382_polysilicon-1##22 9.854
R2677 XOR1_to_NAND2#14pin@382_polysilicon-1##22 XOR1_to_NAND2#14pin@382_polysilicon-1##23 9.854
R2678 XOR1_to_NAND2#14pin@382_polysilicon-1##23 XOR1_to_NAND2#14pin@382_polysilicon-1##24 9.854
R2679 XOR1_to_NAND2#14pin@382_polysilicon-1##24 XOR1_to_NAND2#14pin@382_polysilicon-1##25 9.854
R2680 XOR1_to_NAND2#14pin@382_polysilicon-1##25 XOR1_to_NAND2#14pin@382_polysilicon-1##26 9.854
R2681 XOR1_to_NAND2#14pin@382_polysilicon-1##26 XOR1_to_NAND2#14pin@382_polysilicon-1##27 9.854
R2682 XOR1_to_NAND2#14pin@382_polysilicon-1##27 XOR1_to_NAND2#14pin@382_polysilicon-1##28 9.854
R2683 XOR1_to_NAND2#14pin@382_polysilicon-1##28 XOR1_to_NAND2#14pin@382_polysilicon-1##29 9.854
R2684 XOR1_to_NAND2#14pin@382_polysilicon-1##29 XOR1_to_NAND2#14pin@382_polysilicon-1##30 9.854
R2685 XOR1_to_NAND2#14pin@382_polysilicon-1##30 XOR1_to_NAND2#14pin@382_polysilicon-1##31 9.854
R2686 XOR1_to_NAND2#14pin@382_polysilicon-1##31 XOR1_to_NAND2#14pin@382_polysilicon-1##32 9.854
R2687 XOR1_to_NAND2#14pin@382_polysilicon-1##32 XOR1_to_NAND2#14pin@382_polysilicon-1##33 9.854
R2688 XOR1_to_NAND2#14pin@382_polysilicon-1##33 XOR1_to_NAND2#14pin@382_polysilicon-1##34 9.854
R2689 XOR1_to_NAND2#14pin@382_polysilicon-1##34 XOR1_to_NAND2#14pin@382_polysilicon-1##35 9.854
R2690 XOR1_to_NAND2#14pin@382_polysilicon-1##35 XOR1_to_NAND2#14pin@382_polysilicon-1##36 9.854
R2691 XOR1_to_NAND2#14pin@382_polysilicon-1##36 XOR1_to_NAND2#14pin@382_polysilicon-1##37 9.854
R2692 XOR1_to_NAND2#14pin@382_polysilicon-1##37 XOR1_to_NAND2#14pin@382_polysilicon-1##38 9.854
R2693 XOR1_to_NAND2#14pin@382_polysilicon-1##38 XOR1_to_NAND2#14pin@382_polysilicon-1##39 9.854
R2694 XOR1_to_NAND2#14pin@382_polysilicon-1##39 XOR1_to_NAND2#14pin@382_polysilicon-1##40 9.854
R2695 XOR1_to_NAND2#14pin@382_polysilicon-1##40 XOR1_to_NAND2#14pin@382_polysilicon-1##41 9.854
R2696 XOR1_to_NAND2#14pin@382_polysilicon-1##41 XOR1_to_NAND2#14pin@382_polysilicon-1##42 9.854
R2697 XOR1_to_NAND2#14pin@382_polysilicon-1##42 XOR1_to_NAND2#14pin@382_polysilicon-1##43 9.854
R2698 XOR1_to_NAND2#14pin@382_polysilicon-1##43 XOR1_to_NAND2#14pin@382_polysilicon-1##44 9.854
R2699 XOR1_to_NAND2#14pin@382_polysilicon-1##44 XOR1_to_NAND2#14pin@382_polysilicon-1##45 9.854
R2700 XOR1_to_NAND2#14pin@382_polysilicon-1##45 XOR1_to_NAND2#14pin@382_polysilicon-1##46 9.854
R2701 XOR1_to_NAND2#14pin@382_polysilicon-1##46 XOR1_to_NAND2#14pin@382_polysilicon-1##47 9.854
R2702 XOR1_to_NAND2#14pin@382_polysilicon-1##47 XOR1_to_NAND2#14pin@382_polysilicon-1##48 9.854
R2703 XOR1_to_NAND2#14pin@382_polysilicon-1##48 XOR1_to_NAND2#14pin@382_polysilicon-1##49 9.854
R2704 XOR1_to_NAND2#14pin@382_polysilicon-1##49 XOR1_to_NAND2#14pin@382_polysilicon-1##50 9.854
R2705 XOR1_to_NAND2#14pin@382_polysilicon-1##50 XOR1_to_NAND2#14pin@382_polysilicon-1##51 9.854
R2706 XOR1_to_NAND2#14pin@382_polysilicon-1##51 XOR1_to_NAND2#14pin@382_polysilicon-1##52 9.854
R2707 XOR1_to_NAND2#14pin@382_polysilicon-1##52 XOR1_to_NAND2#14pin@382_polysilicon-1##53 9.854
R2708 XOR1_to_NAND2#14pin@382_polysilicon-1##53 XOR1_to_NAND2#14pin@382_polysilicon-1##54 9.854
R2709 XOR1_to_NAND2#14pin@382_polysilicon-1##54 XOR1_to_NAND2#27nmos@74_poly-right 9.854
R2710 Cin_to_XOR2___NAND2#29pmos@75_poly-right Cin_to_XOR2___NAND2#29pmos@75_poly-right##0 9.877
R2711 Cin_to_XOR2___NAND2#29pmos@75_poly-right##0 Cin_to_XOR2___NAND2#29pmos@75_poly-right##1 9.877
R2712 Cin_to_XOR2___NAND2#29pmos@75_poly-right##1 Cin_to_XOR2___NAND2#29pmos@75_poly-right##2 9.877
R2713 Cin_to_XOR2___NAND2#29pmos@75_poly-right##2 Cin_to_XOR2___NAND2#29pmos@75_poly-right##3 9.877
R2714 Cin_to_XOR2___NAND2#29pmos@75_poly-right##3 Cin_to_XOR2___NAND2#29pmos@75_poly-right##4 9.877
R2715 Cin_to_XOR2___NAND2#29pmos@75_poly-right##4 Cin_to_XOR2___NAND2#29pmos@75_poly-right##5 9.877
R2716 Cin_to_XOR2___NAND2#29pmos@75_poly-right##5 Cin_to_XOR2___NAND2#29pmos@75_poly-right##6 9.877
R2717 Cin_to_XOR2___NAND2#29pmos@75_poly-right##6 Cin_to_XOR2___NAND2#29pmos@75_poly-right##7 9.877
R2718 Cin_to_XOR2___NAND2#29pmos@75_poly-right##7 Cin_to_XOR2___NAND2#29pmos@75_poly-right##8 9.877
R2719 Cin_to_XOR2___NAND2#29pmos@75_poly-right##8 Cin_to_XOR2___NAND2#29pmos@75_poly-right##9 9.877
R2720 Cin_to_XOR2___NAND2#29pmos@75_poly-right##9 Cin_to_XOR2___NAND2#29pmos@75_poly-right##10 9.877
R2721 Cin_to_XOR2___NAND2#29pmos@75_poly-right##10 Cin_to_XOR2___NAND2#29pmos@75_poly-right##11 9.877
R2722 Cin_to_XOR2___NAND2#29pmos@75_poly-right##11 Cin_to_XOR2___NAND2#29pmos@75_poly-right##12 9.877
R2723 Cin_to_XOR2___NAND2#29pmos@75_poly-right##12 Cin_to_XOR2___NAND2#29pmos@75_poly-right##13 9.877
R2724 Cin_to_XOR2___NAND2#29pmos@75_poly-right##13 Cin_to_XOR2___NAND2#29pmos@75_poly-right##14 9.877
R2725 Cin_to_XOR2___NAND2#29pmos@75_poly-right##14 Cin_to_XOR2___NAND2#29pmos@75_poly-right##15 9.877
R2726 Cin_to_XOR2___NAND2#29pmos@75_poly-right##15 Cin_to_XOR2___NAND2#29pmos@75_poly-right##16 9.877
R2727 Cin_to_XOR2___NAND2#29pmos@75_poly-right##16 Cin_to_XOR2___NAND2#29pmos@75_poly-right##17 9.877
R2728 Cin_to_XOR2___NAND2#29pmos@75_poly-right##17 Cin_to_XOR2___NAND2#29pmos@75_poly-right##18 9.877
R2729 Cin_to_XOR2___NAND2#29pmos@75_poly-right##18 Cin_to_XOR2___NAND2#29pmos@75_poly-right##19 9.877
R2730 Cin_to_XOR2___NAND2#29pmos@75_poly-right##19 Cin_to_XOR2___NAND2#29pmos@75_poly-right##20 9.877
R2731 Cin_to_XOR2___NAND2#29pmos@75_poly-right##20 Cin_to_XOR2___NAND2#29pmos@75_poly-right##21 9.877
R2732 Cin_to_XOR2___NAND2#29pmos@75_poly-right##21 Cin_to_XOR2___NAND2#29pmos@75_poly-right##22 9.877
R2733 Cin_to_XOR2___NAND2#29pmos@75_poly-right##22 Cin_to_XOR2___NAND2#29pmos@75_poly-right##23 9.877
R2734 Cin_to_XOR2___NAND2#29pmos@75_poly-right##23 Cin_to_XOR2___NAND2#29pmos@75_poly-right##24 9.877
R2735 Cin_to_XOR2___NAND2#29pmos@75_poly-right##24 Cin_to_XOR2___NAND2#29pmos@75_poly-right##25 9.877
R2736 Cin_to_XOR2___NAND2#29pmos@75_poly-right##25 Cin_to_XOR2___NAND2#29pmos@75_poly-right##26 9.877
R2737 Cin_to_XOR2___NAND2#29pmos@75_poly-right##26 Cin_to_XOR2___NAND2#29pmos@75_poly-right##27 9.877
R2738 Cin_to_XOR2___NAND2#29pmos@75_poly-right##27 Cin_to_XOR2___NAND2#29pmos@75_poly-right##28 9.877
R2739 Cin_to_XOR2___NAND2#29pmos@75_poly-right##28 Cin_to_XOR2___NAND2#29pmos@75_poly-right##29 9.877
R2740 Cin_to_XOR2___NAND2#29pmos@75_poly-right##29 Cin_to_XOR2___NAND2#29pmos@75_poly-right##30 9.877
R2741 Cin_to_XOR2___NAND2#29pmos@75_poly-right##30 Cin_to_XOR2___NAND2#29pmos@75_poly-right##31 9.877
R2742 Cin_to_XOR2___NAND2#29pmos@75_poly-right##31 Cin_to_XOR2___NAND2#29pmos@75_poly-right##32 9.877
R2743 Cin_to_XOR2___NAND2#29pmos@75_poly-right##32 Cin_to_XOR2___NAND2#29pmos@75_poly-right##33 9.877
R2744 Cin_to_XOR2___NAND2#29pmos@75_poly-right##33 Cin_to_XOR2___NAND2#29pmos@75_poly-right##34 9.877
R2745 Cin_to_XOR2___NAND2#29pmos@75_poly-right##34 Cin_to_XOR2___NAND2#29pmos@75_poly-right##35 9.877
R2746 Cin_to_XOR2___NAND2#29pmos@75_poly-right##35 Cin_to_XOR2___NAND2#29pmos@75_poly-right##36 9.877
R2747 Cin_to_XOR2___NAND2#29pmos@75_poly-right##36 Cin_to_XOR2___NAND2#29pmos@75_poly-right##37 9.877
R2748 Cin_to_XOR2___NAND2#29pmos@75_poly-right##37 Cin_to_XOR2___NAND2#29pmos@75_poly-right##38 9.877
R2749 Cin_to_XOR2___NAND2#29pmos@75_poly-right##38 Cin_to_XOR2___NAND2#29pmos@75_poly-right##39 9.877
R2750 Cin_to_XOR2___NAND2#29pmos@75_poly-right##39 Cin_to_XOR2___NAND2#29pmos@75_poly-right##40 9.877
R2751 Cin_to_XOR2___NAND2#29pmos@75_poly-right##40 Cin_to_XOR2___NAND2#29pmos@75_poly-right##41 9.877
R2752 Cin_to_XOR2___NAND2#29pmos@75_poly-right##41 Cin_to_XOR2___NAND2#29pmos@75_poly-right##42 9.877
R2753 Cin_to_XOR2___NAND2#29pmos@75_poly-right##42 Cin_to_XOR2___NAND2#29pmos@75_poly-right##43 9.877
R2754 Cin_to_XOR2___NAND2#29pmos@75_poly-right##43 Cin_to_XOR2___NAND2#29pmos@75_poly-right##44 9.877
R2755 Cin_to_XOR2___NAND2#29pmos@75_poly-right##44 Cin_to_XOR2___NAND2#29pmos@75_poly-right##45 9.877
R2756 Cin_to_XOR2___NAND2#29pmos@75_poly-right##45 Cin_to_XOR2___NAND2#29pmos@75_poly-right##46 9.877
R2757 Cin_to_XOR2___NAND2#29pmos@75_poly-right##46 Cin_to_XOR2___NAND2#29pmos@75_poly-right##47 9.877
R2758 Cin_to_XOR2___NAND2#29pmos@75_poly-right##47 Cin_to_XOR2___NAND2#29pmos@75_poly-right##48 9.877
R2759 Cin_to_XOR2___NAND2#29pmos@75_poly-right##48 Cin_to_XOR2___NAND2#29pmos@75_poly-right##49 9.877
R2760 Cin_to_XOR2___NAND2#29pmos@75_poly-right##49 Cin_to_XOR2___NAND2#23pin@386_polysilicon-1 9.877
R2761 NAND1_to_NAND4 NAND1_to_NAND4#4nmos@75_diff-bottom 4.823
R2762 A1#11pin@389_polysilicon-1 A1#11pin@389_polysilicon-1##0 9.938
R2763 A1#11pin@389_polysilicon-1##0 A1#11pin@389_polysilicon-1##1 9.938
R2764 A1#11pin@389_polysilicon-1##1 A1#11pin@389_polysilicon-1##2 9.938
R2765 A1#11pin@389_polysilicon-1##2 A1#11pin@389_polysilicon-1##3 9.938
R2766 A1#11pin@389_polysilicon-1##3 A1#11pin@389_polysilicon-1##4 9.938
R2767 A1#11pin@389_polysilicon-1##4 A1#11pin@389_polysilicon-1##5 9.938
R2768 A1#11pin@389_polysilicon-1##5 A1#11pin@389_polysilicon-1##6 9.938
R2769 A1#11pin@389_polysilicon-1##6 A1#11pin@389_polysilicon-1##7 9.938
R2770 A1#11pin@389_polysilicon-1##7 A1#11pin@389_polysilicon-1##8 9.938
R2771 A1#11pin@389_polysilicon-1##8 A1#11pin@389_polysilicon-1##9 9.938
R2772 A1#11pin@389_polysilicon-1##9 A1#11pin@389_polysilicon-1##10 9.938
R2773 A1#11pin@389_polysilicon-1##10 A1#11pin@389_polysilicon-1##11 9.938
R2774 A1#11pin@389_polysilicon-1##11 A1#11pin@389_polysilicon-1##12 9.938
R2775 A1#11pin@389_polysilicon-1##12 A1#11pin@389_polysilicon-1##13 9.938
R2776 A1#11pin@389_polysilicon-1##13 A1#11pin@389_polysilicon-1##14 9.938
R2777 A1#11pin@389_polysilicon-1##14 A1#11pin@389_polysilicon-1##15 9.938
R2778 A1#11pin@389_polysilicon-1##15 A1#11pin@389_polysilicon-1##16 9.938
R2779 A1#11pin@389_polysilicon-1##16 A1#11pin@389_polysilicon-1##17 9.938
R2780 A1#11pin@389_polysilicon-1##17 A1#11pin@389_polysilicon-1##18 9.938
R2781 A1#11pin@389_polysilicon-1##18 A1#11pin@389_polysilicon-1##19 9.938
R2782 A1#11pin@389_polysilicon-1##19 A1#11pin@389_polysilicon-1##20 9.938
R2783 A1#11pin@389_polysilicon-1##20 A1#11pin@389_polysilicon-1##21 9.938
R2784 A1#11pin@389_polysilicon-1##21 A1#11pin@389_polysilicon-1##22 9.938
R2785 A1#11pin@389_polysilicon-1##22 A1#11pin@389_polysilicon-1##23 9.938
R2786 A1#11pin@389_polysilicon-1##23 A1#11pin@389_polysilicon-1##24 9.938
R2787 A1#11pin@389_polysilicon-1##24 A1#11pin@389_polysilicon-1##25 9.938
R2788 A1#11pin@389_polysilicon-1##25 A1#11pin@389_polysilicon-1##26 9.938
R2789 A1#11pin@389_polysilicon-1##26 A1#11pin@389_polysilicon-1##27 9.938
R2790 A1#11pin@389_polysilicon-1##27 A1#11pin@389_polysilicon-1##28 9.938
R2791 A1#11pin@389_polysilicon-1##28 A1#11pin@389_polysilicon-1##29 9.938
R2792 A1#11pin@389_polysilicon-1##29 A1#11pin@389_polysilicon-1##30 9.938
R2793 A1#11pin@389_polysilicon-1##30 A1#11pin@389_polysilicon-1##31 9.938
R2794 A1#11pin@389_polysilicon-1##31 A1#11pin@389_polysilicon-1##32 9.938
R2795 A1#11pin@389_polysilicon-1##32 A1#11pin@389_polysilicon-1##33 9.938
R2796 A1#11pin@389_polysilicon-1##33 A1#11pin@389_polysilicon-1##34 9.938
R2797 A1#11pin@389_polysilicon-1##34 A1#11pin@389_polysilicon-1##35 9.938
R2798 A1#11pin@389_polysilicon-1##35 A1#11pin@389_polysilicon-1##36 9.938
R2799 A1#11pin@389_polysilicon-1##36 A1#11pin@389_polysilicon-1##37 9.938
R2800 A1#11pin@389_polysilicon-1##37 A1#11pin@389_polysilicon-1##38 9.938
R2801 A1#11pin@389_polysilicon-1##38 A1#11pin@389_polysilicon-1##39 9.938
R2802 A1#11pin@389_polysilicon-1##39 A1#11pin@389_polysilicon-1##40 9.938
R2803 A1#11pin@389_polysilicon-1##40 A1#11pin@389_polysilicon-1##41 9.938
R2804 A1#11pin@389_polysilicon-1##41 A1#11pin@389_polysilicon-1##42 9.938
R2805 A1#11pin@389_polysilicon-1##42 A1#11pin@389_polysilicon-1##43 9.938
R2806 A1#11pin@389_polysilicon-1##43 A1#11pin@389_polysilicon-1##44 9.938
R2807 A1#11pin@389_polysilicon-1##44 A1#11pin@389_polysilicon-1##45 9.938
R2808 A1#11pin@389_polysilicon-1##45 A1#11pin@389_polysilicon-1##46 9.938
R2809 A1#11pin@389_polysilicon-1##46 A1#11pin@389_polysilicon-1##47 9.938
R2810 A1#11pin@389_polysilicon-1##47 A1#11pin@389_polysilicon-1##48 9.938
R2811 A1#11pin@389_polysilicon-1##48 A1#11pin@389_polysilicon-1##49 9.938
R2812 A1#11pin@389_polysilicon-1##49 A1#20nmos@76_poly-right 9.938
R2813 B1#21pmos@77_poly-right B1#21pmos@77_poly-right##0 9.869
R2814 B1#21pmos@77_poly-right##0 B1#21pmos@77_poly-right##1 9.869
R2815 B1#21pmos@77_poly-right##1 B1#21pmos@77_poly-right##2 9.869
R2816 B1#21pmos@77_poly-right##2 B1#21pmos@77_poly-right##3 9.869
R2817 B1#21pmos@77_poly-right##3 B1#21pmos@77_poly-right##4 9.869
R2818 B1#21pmos@77_poly-right##4 B1#21pmos@77_poly-right##5 9.869
R2819 B1#21pmos@77_poly-right##5 B1#21pmos@77_poly-right##6 9.869
R2820 B1#21pmos@77_poly-right##6 B1#21pmos@77_poly-right##7 9.869
R2821 B1#21pmos@77_poly-right##7 B1#21pmos@77_poly-right##8 9.869
R2822 B1#21pmos@77_poly-right##8 B1#21pmos@77_poly-right##9 9.869
R2823 B1#21pmos@77_poly-right##9 B1#21pmos@77_poly-right##10 9.869
R2824 B1#21pmos@77_poly-right##10 B1#21pmos@77_poly-right##11 9.869
R2825 B1#21pmos@77_poly-right##11 B1#21pmos@77_poly-right##12 9.869
R2826 B1#21pmos@77_poly-right##12 B1#21pmos@77_poly-right##13 9.869
R2827 B1#21pmos@77_poly-right##13 B1#21pmos@77_poly-right##14 9.869
R2828 B1#21pmos@77_poly-right##14 B1#21pmos@77_poly-right##15 9.869
R2829 B1#21pmos@77_poly-right##15 B1#21pmos@77_poly-right##16 9.869
R2830 B1#21pmos@77_poly-right##16 B1#21pmos@77_poly-right##17 9.869
R2831 B1#21pmos@77_poly-right##17 B1#21pmos@77_poly-right##18 9.869
R2832 B1#21pmos@77_poly-right##18 B1#21pmos@77_poly-right##19 9.869
R2833 B1#21pmos@77_poly-right##19 B1#21pmos@77_poly-right##20 9.869
R2834 B1#21pmos@77_poly-right##20 B1#21pmos@77_poly-right##21 9.869
R2835 B1#21pmos@77_poly-right##21 B1#21pmos@77_poly-right##22 9.869
R2836 B1#21pmos@77_poly-right##22 B1#21pmos@77_poly-right##23 9.869
R2837 B1#21pmos@77_poly-right##23 B1#21pmos@77_poly-right##24 9.869
R2838 B1#21pmos@77_poly-right##24 B1#21pmos@77_poly-right##25 9.869
R2839 B1#21pmos@77_poly-right##25 B1#21pmos@77_poly-right##26 9.869
R2840 B1#21pmos@77_poly-right##26 B1#21pmos@77_poly-right##27 9.869
R2841 B1#21pmos@77_poly-right##27 B1#21pmos@77_poly-right##28 9.869
R2842 B1#21pmos@77_poly-right##28 B1#21pmos@77_poly-right##29 9.869
R2843 B1#21pmos@77_poly-right##29 B1#21pmos@77_poly-right##30 9.869
R2844 B1#21pmos@77_poly-right##30 B1#21pmos@77_poly-right##31 9.869
R2845 B1#21pmos@77_poly-right##31 B1#21pmos@77_poly-right##32 9.869
R2846 B1#21pmos@77_poly-right##32 B1#21pmos@77_poly-right##33 9.869
R2847 B1#21pmos@77_poly-right##33 B1#21pmos@77_poly-right##34 9.869
R2848 B1#21pmos@77_poly-right##34 B1#21pmos@77_poly-right##35 9.869
R2849 B1#21pmos@77_poly-right##35 B1#21pmos@77_poly-right##36 9.869
R2850 B1#21pmos@77_poly-right##36 B1#21pmos@77_poly-right##37 9.869
R2851 B1#21pmos@77_poly-right##37 B1#21pmos@77_poly-right##38 9.869
R2852 B1#21pmos@77_poly-right##38 B1#21pmos@77_poly-right##39 9.869
R2853 B1#21pmos@77_poly-right##39 B1#21pmos@77_poly-right##40 9.869
R2854 B1#21pmos@77_poly-right##40 B1#21pmos@77_poly-right##41 9.869
R2855 B1#21pmos@77_poly-right##41 B1#21pmos@77_poly-right##42 9.869
R2856 B1#21pmos@77_poly-right##42 B1#21pmos@77_poly-right##43 9.869
R2857 B1#21pmos@77_poly-right##43 B1#21pmos@77_poly-right##44 9.869
R2858 B1#21pmos@77_poly-right##44 B1#21pmos@77_poly-right##45 9.869
R2859 B1#21pmos@77_poly-right##45 B1#21pmos@77_poly-right##46 9.869
R2860 B1#21pmos@77_poly-right##46 B1#21pmos@77_poly-right##47 9.869
R2861 B1#21pmos@77_poly-right##47 B1#11pin@393_polysilicon-1 9.869
R2862 NAND2_to_Nand4#9pin@395_polysilicon-1 NAND2_to_Nand4#9pin@395_polysilicon-1##0 9.938
R2863 NAND2_to_Nand4#9pin@395_polysilicon-1##0 NAND2_to_Nand4#9pin@395_polysilicon-1##1 9.938
R2864 NAND2_to_Nand4#9pin@395_polysilicon-1##1 NAND2_to_Nand4#9pin@395_polysilicon-1##2 9.938
R2865 NAND2_to_Nand4#9pin@395_polysilicon-1##2 NAND2_to_Nand4#9pin@395_polysilicon-1##3 9.938
R2866 NAND2_to_Nand4#9pin@395_polysilicon-1##3 NAND2_to_Nand4#9pin@395_polysilicon-1##4 9.938
R2867 NAND2_to_Nand4#9pin@395_polysilicon-1##4 NAND2_to_Nand4#9pin@395_polysilicon-1##5 9.938
R2868 NAND2_to_Nand4#9pin@395_polysilicon-1##5 NAND2_to_Nand4#9pin@395_polysilicon-1##6 9.938
R2869 NAND2_to_Nand4#9pin@395_polysilicon-1##6 NAND2_to_Nand4#9pin@395_polysilicon-1##7 9.938
R2870 NAND2_to_Nand4#9pin@395_polysilicon-1##7 NAND2_to_Nand4#9pin@395_polysilicon-1##8 9.938
R2871 NAND2_to_Nand4#9pin@395_polysilicon-1##8 NAND2_to_Nand4#9pin@395_polysilicon-1##9 9.938
R2872 NAND2_to_Nand4#9pin@395_polysilicon-1##9 NAND2_to_Nand4#9pin@395_polysilicon-1##10 9.938
R2873 NAND2_to_Nand4#9pin@395_polysilicon-1##10 NAND2_to_Nand4#9pin@395_polysilicon-1##11 9.938
R2874 NAND2_to_Nand4#9pin@395_polysilicon-1##11 NAND2_to_Nand4#9pin@395_polysilicon-1##12 9.938
R2875 NAND2_to_Nand4#9pin@395_polysilicon-1##12 NAND2_to_Nand4#9pin@395_polysilicon-1##13 9.938
R2876 NAND2_to_Nand4#9pin@395_polysilicon-1##13 NAND2_to_Nand4#9pin@395_polysilicon-1##14 9.938
R2877 NAND2_to_Nand4#9pin@395_polysilicon-1##14 NAND2_to_Nand4#9pin@395_polysilicon-1##15 9.938
R2878 NAND2_to_Nand4#9pin@395_polysilicon-1##15 NAND2_to_Nand4#9pin@395_polysilicon-1##16 9.938
R2879 NAND2_to_Nand4#9pin@395_polysilicon-1##16 NAND2_to_Nand4#9pin@395_polysilicon-1##17 9.938
R2880 NAND2_to_Nand4#9pin@395_polysilicon-1##17 NAND2_to_Nand4#9pin@395_polysilicon-1##18 9.938
R2881 NAND2_to_Nand4#9pin@395_polysilicon-1##18 NAND2_to_Nand4#9pin@395_polysilicon-1##19 9.938
R2882 NAND2_to_Nand4#9pin@395_polysilicon-1##19 NAND2_to_Nand4#9pin@395_polysilicon-1##20 9.938
R2883 NAND2_to_Nand4#9pin@395_polysilicon-1##20 NAND2_to_Nand4#9pin@395_polysilicon-1##21 9.938
R2884 NAND2_to_Nand4#9pin@395_polysilicon-1##21 NAND2_to_Nand4#9pin@395_polysilicon-1##22 9.938
R2885 NAND2_to_Nand4#9pin@395_polysilicon-1##22 NAND2_to_Nand4#9pin@395_polysilicon-1##23 9.938
R2886 NAND2_to_Nand4#9pin@395_polysilicon-1##23 NAND2_to_Nand4#9pin@395_polysilicon-1##24 9.938
R2887 NAND2_to_Nand4#9pin@395_polysilicon-1##24 NAND2_to_Nand4#9pin@395_polysilicon-1##25 9.938
R2888 NAND2_to_Nand4#9pin@395_polysilicon-1##25 NAND2_to_Nand4#9pin@395_polysilicon-1##26 9.938
R2889 NAND2_to_Nand4#9pin@395_polysilicon-1##26 NAND2_to_Nand4#9pin@395_polysilicon-1##27 9.938
R2890 NAND2_to_Nand4#9pin@395_polysilicon-1##27 NAND2_to_Nand4#9pin@395_polysilicon-1##28 9.938
R2891 NAND2_to_Nand4#9pin@395_polysilicon-1##28 NAND2_to_Nand4#9pin@395_polysilicon-1##29 9.938
R2892 NAND2_to_Nand4#9pin@395_polysilicon-1##29 NAND2_to_Nand4#9pin@395_polysilicon-1##30 9.938
R2893 NAND2_to_Nand4#9pin@395_polysilicon-1##30 NAND2_to_Nand4#9pin@395_polysilicon-1##31 9.938
R2894 NAND2_to_Nand4#9pin@395_polysilicon-1##31 NAND2_to_Nand4#9pin@395_polysilicon-1##32 9.938
R2895 NAND2_to_Nand4#9pin@395_polysilicon-1##32 NAND2_to_Nand4#9pin@395_polysilicon-1##33 9.938
R2896 NAND2_to_Nand4#9pin@395_polysilicon-1##33 NAND2_to_Nand4#9pin@395_polysilicon-1##34 9.938
R2897 NAND2_to_Nand4#9pin@395_polysilicon-1##34 NAND2_to_Nand4#9pin@395_polysilicon-1##35 9.938
R2898 NAND2_to_Nand4#9pin@395_polysilicon-1##35 NAND2_to_Nand4#9pin@395_polysilicon-1##36 9.938
R2899 NAND2_to_Nand4#9pin@395_polysilicon-1##36 NAND2_to_Nand4#9pin@395_polysilicon-1##37 9.938
R2900 NAND2_to_Nand4#9pin@395_polysilicon-1##37 NAND2_to_Nand4#9pin@395_polysilicon-1##38 9.938
R2901 NAND2_to_Nand4#9pin@395_polysilicon-1##38 NAND2_to_Nand4#9pin@395_polysilicon-1##39 9.938
R2902 NAND2_to_Nand4#9pin@395_polysilicon-1##39 NAND2_to_Nand4#9pin@395_polysilicon-1##40 9.938
R2903 NAND2_to_Nand4#9pin@395_polysilicon-1##40 NAND2_to_Nand4#9pin@395_polysilicon-1##41 9.938
R2904 NAND2_to_Nand4#9pin@395_polysilicon-1##41 NAND2_to_Nand4#9pin@395_polysilicon-1##42 9.938
R2905 NAND2_to_Nand4#9pin@395_polysilicon-1##42 NAND2_to_Nand4#9pin@395_polysilicon-1##43 9.938
R2906 NAND2_to_Nand4#9pin@395_polysilicon-1##43 NAND2_to_Nand4#9pin@395_polysilicon-1##44 9.938
R2907 NAND2_to_Nand4#9pin@395_polysilicon-1##44 NAND2_to_Nand4#9pin@395_polysilicon-1##45 9.938
R2908 NAND2_to_Nand4#9pin@395_polysilicon-1##45 NAND2_to_Nand4#9pin@395_polysilicon-1##46 9.938
R2909 NAND2_to_Nand4#9pin@395_polysilicon-1##46 NAND2_to_Nand4#9pin@395_polysilicon-1##47 9.938
R2910 NAND2_to_Nand4#9pin@395_polysilicon-1##47 NAND2_to_Nand4#9pin@395_polysilicon-1##48 9.938
R2911 NAND2_to_Nand4#9pin@395_polysilicon-1##48 NAND2_to_Nand4#9pin@395_polysilicon-1##49 9.938
R2912 NAND2_to_Nand4#9pin@395_polysilicon-1##49 NAND2_to_Nand4#11nmos@78_poly-right 9.938
R2913 NAND1_to_NAND4#14nmos@79_poly-right NAND1_to_NAND4#14nmos@79_poly-right##0 9.898
R2914 NAND1_to_NAND4#14nmos@79_poly-right##0 NAND1_to_NAND4#14nmos@79_poly-right##1 9.898
R2915 NAND1_to_NAND4#14nmos@79_poly-right##1 NAND1_to_NAND4#14nmos@79_poly-right##2 9.898
R2916 NAND1_to_NAND4#14nmos@79_poly-right##2 NAND1_to_NAND4#14nmos@79_poly-right##3 9.898
R2917 NAND1_to_NAND4#14nmos@79_poly-right##3 NAND1_to_NAND4#14nmos@79_poly-right##4 9.898
R2918 NAND1_to_NAND4#14nmos@79_poly-right##4 NAND1_to_NAND4#14nmos@79_poly-right##5 9.898
R2919 NAND1_to_NAND4#14nmos@79_poly-right##5 NAND1_to_NAND4#14nmos@79_poly-right##6 9.898
R2920 NAND1_to_NAND4#14nmos@79_poly-right##6 NAND1_to_NAND4#14nmos@79_poly-right##7 9.898
R2921 NAND1_to_NAND4#14nmos@79_poly-right##7 NAND1_to_NAND4#14nmos@79_poly-right##8 9.898
R2922 NAND1_to_NAND4#14nmos@79_poly-right##8 NAND1_to_NAND4#14nmos@79_poly-right##9 9.898
R2923 NAND1_to_NAND4#14nmos@79_poly-right##9 NAND1_to_NAND4#14nmos@79_poly-right##10 9.898
R2924 NAND1_to_NAND4#14nmos@79_poly-right##10 NAND1_to_NAND4#14nmos@79_poly-right##11 9.898
R2925 NAND1_to_NAND4#14nmos@79_poly-right##11 NAND1_to_NAND4#14nmos@79_poly-right##12 9.898
R2926 NAND1_to_NAND4#14nmos@79_poly-right##12 NAND1_to_NAND4#14nmos@79_poly-right##13 9.898
R2927 NAND1_to_NAND4#14nmos@79_poly-right##13 NAND1_to_NAND4#14nmos@79_poly-right##14 9.898
R2928 NAND1_to_NAND4#14nmos@79_poly-right##14 NAND1_to_NAND4#14nmos@79_poly-right##15 9.898
R2929 NAND1_to_NAND4#14nmos@79_poly-right##15 NAND1_to_NAND4#14nmos@79_poly-right##16 9.898
R2930 NAND1_to_NAND4#14nmos@79_poly-right##16 NAND1_to_NAND4#14nmos@79_poly-right##17 9.898
R2931 NAND1_to_NAND4#14nmos@79_poly-right##17 NAND1_to_NAND4#14nmos@79_poly-right##18 9.898
R2932 NAND1_to_NAND4#14nmos@79_poly-right##18 NAND1_to_NAND4#14nmos@79_poly-right##19 9.898
R2933 NAND1_to_NAND4#14nmos@79_poly-right##19 NAND1_to_NAND4#14nmos@79_poly-right##20 9.898
R2934 NAND1_to_NAND4#14nmos@79_poly-right##20 NAND1_to_NAND4#14nmos@79_poly-right##21 9.898
R2935 NAND1_to_NAND4#14nmos@79_poly-right##21 NAND1_to_NAND4#14nmos@79_poly-right##22 9.898
R2936 NAND1_to_NAND4#14nmos@79_poly-right##22 NAND1_to_NAND4#14nmos@79_poly-right##23 9.898
R2937 NAND1_to_NAND4#14nmos@79_poly-right##23 NAND1_to_NAND4#14nmos@79_poly-right##24 9.898
R2938 NAND1_to_NAND4#14nmos@79_poly-right##24 NAND1_to_NAND4#14nmos@79_poly-right##25 9.898
R2939 NAND1_to_NAND4#14nmos@79_poly-right##25 NAND1_to_NAND4#14nmos@79_poly-right##26 9.898
R2940 NAND1_to_NAND4#14nmos@79_poly-right##26 NAND1_to_NAND4#14nmos@79_poly-right##27 9.898
R2941 NAND1_to_NAND4#14nmos@79_poly-right##27 NAND1_to_NAND4#14nmos@79_poly-right##28 9.898
R2942 NAND1_to_NAND4#14nmos@79_poly-right##28 NAND1_to_NAND4#14nmos@79_poly-right##29 9.898
R2943 NAND1_to_NAND4#14nmos@79_poly-right##29 NAND1_to_NAND4#14nmos@79_poly-right##30 9.898
R2944 NAND1_to_NAND4#14nmos@79_poly-right##30 NAND1_to_NAND4#14nmos@79_poly-right##31 9.898
R2945 NAND1_to_NAND4#14nmos@79_poly-right##31 NAND1_to_NAND4#14nmos@79_poly-right##32 9.898
R2946 NAND1_to_NAND4#14nmos@79_poly-right##32 NAND1_to_NAND4#14nmos@79_poly-right##33 9.898
R2947 NAND1_to_NAND4#14nmos@79_poly-right##33 NAND1_to_NAND4#14nmos@79_poly-right##34 9.898
R2948 NAND1_to_NAND4#14nmos@79_poly-right##34 NAND1_to_NAND4#14nmos@79_poly-right##35 9.898
R2949 NAND1_to_NAND4#14nmos@79_poly-right##35 NAND1_to_NAND4#14nmos@79_poly-right##36 9.898
R2950 NAND1_to_NAND4#14nmos@79_poly-right##36 NAND1_to_NAND4#14nmos@79_poly-right##37 9.898
R2951 NAND1_to_NAND4#14nmos@79_poly-right##37 NAND1_to_NAND4#14nmos@79_poly-right##38 9.898
R2952 NAND1_to_NAND4#14nmos@79_poly-right##38 NAND1_to_NAND4#14nmos@79_poly-right##39 9.898
R2953 NAND1_to_NAND4#14nmos@79_poly-right##39 NAND1_to_NAND4#14nmos@79_poly-right##40 9.898
R2954 NAND1_to_NAND4#14nmos@79_poly-right##40 NAND1_to_NAND4#14nmos@79_poly-right##41 9.898
R2955 NAND1_to_NAND4#14nmos@79_poly-right##41 NAND1_to_NAND4#14nmos@79_poly-right##42 9.898
R2956 NAND1_to_NAND4#14nmos@79_poly-right##42 NAND1_to_NAND4#14nmos@79_poly-right##43 9.898
R2957 NAND1_to_NAND4#14nmos@79_poly-right##43 NAND1_to_NAND4#14nmos@79_poly-right##44 9.898
R2958 NAND1_to_NAND4#14nmos@79_poly-right##44 NAND1_to_NAND4#14nmos@79_poly-right##45 9.898
R2959 NAND1_to_NAND4#14nmos@79_poly-right##45 NAND1_to_NAND4#14nmos@79_poly-right##46 9.898
R2960 NAND1_to_NAND4#14nmos@79_poly-right##46 NAND1_to_NAND4#14nmos@79_poly-right##47 9.898
R2961 NAND1_to_NAND4#14nmos@79_poly-right##47 NAND1_to_NAND4#14nmos@79_poly-right##48 9.898
R2962 NAND1_to_NAND4#14nmos@79_poly-right##48 NAND1_to_NAND4#14nmos@79_poly-right##49 9.898
R2963 NAND1_to_NAND4#14nmos@79_poly-right##49 NAND1_to_NAND4#14nmos@79_poly-right##50 9.898
R2964 NAND1_to_NAND4#14nmos@79_poly-right##50 NAND1_to_NAND4#14nmos@79_poly-right##51 9.898
R2965 NAND1_to_NAND4#14nmos@79_poly-right##51 NAND1_to_NAND4#14nmos@79_poly-right##52 9.898
R2966 NAND1_to_NAND4#14nmos@79_poly-right##52 NAND1_to_NAND4#14nmos@79_poly-right##53 9.898
R2967 NAND1_to_NAND4#14nmos@79_poly-right##53 NAND1_to_NAND4#14nmos@79_poly-right##54 9.898
R2968 NAND1_to_NAND4#14nmos@79_poly-right##54 NAND1_to_NAND4#14nmos@79_poly-right##55 9.898
R2969 NAND1_to_NAND4#14nmos@79_poly-right##55 NAND1_to_NAND4#11pmos@79_poly-right 9.898
R2970 NAND2_to_Nand4 NAND2_to_Nand4#4nmos@77_diff-bottom 4.42
R2971 B1 B1##0 5.018
C547 B1##0 0 5.383fF
R2972 B1##0 B1#0pin@508_metal-2 5.018
R2973 net@1809 net@1809##0 9.92
R2974 net@1809##0 net@1809##1 9.92
R2975 net@1809##1 net@1809##2 9.92
R2976 net@1809##2 net@1809##3 9.92
R2977 net@1809##3 net@1809##4 9.92
R2978 net@1809##4 net@1809##5 9.92
R2979 net@1809##5 net@1809##6 9.92
R2980 net@1809##6 net@1809##7 9.92
R2981 net@1809##7 net@1809##8 9.92
R2982 net@1809##8 net@1809##9 9.92
R2983 net@1809##9 net@1809##10 9.92
R2984 net@1809##10 net@1809##11 9.92
R2985 net@1809##11 net@1809##12 9.92
R2986 net@1809##12 net@1809##13 9.92
R2987 net@1809##13 net@1809##14 9.92
R2988 net@1809##14 net@1809##15 9.92
R2989 net@1809##15 net@1809##16 9.92
R2990 net@1809##16 net@1809##17 9.92
R2991 net@1809##17 net@1809##18 9.92
R2992 net@1809##18 net@1809#1pin@546_polysilicon-1 9.92
R2993 net@1811 net@1811##0 9.92
R2994 net@1811##0 net@1811##1 9.92
R2995 net@1811##1 net@1811##2 9.92
R2996 net@1811##2 net@1811##3 9.92
R2997 net@1811##3 net@1811##4 9.92
R2998 net@1811##4 net@1811##5 9.92
R2999 net@1811##5 net@1811##6 9.92
R3000 net@1811##6 net@1811##7 9.92
R3001 net@1811##7 net@1811##8 9.92
R3002 net@1811##8 net@1811##9 9.92
R3003 net@1811##9 net@1811##10 9.92
R3004 net@1811##10 net@1811##11 9.92
R3005 net@1811##11 net@1811##12 9.92
R3006 net@1811##12 net@1811##13 9.92
R3007 net@1811##13 net@1811##14 9.92
R3008 net@1811##14 net@1811##15 9.92
R3009 net@1811##15 net@1811##16 9.92
R3010 net@1811##16 net@1811##17 9.92
R3011 net@1811##17 net@1811##18 9.92
R3012 net@1811##18 net@1811#1pin@571_polysilicon-1 9.92
R3013 XOR1_to_NAND3#3pin@572_polysilicon-1 XOR1_to_NAND3#3pin@572_polysilicon-1##0 6.2
R3014 XOR1_to_NAND3#3pin@572_polysilicon-1##0 XOR1_to_NAND3#4pmos@92_poly-right 6.2
R3015 XOR1_to_NAND3#3pin@572_polysilicon-1 XOR1_to_NAND3#3pin@572_polysilicon-1##0 8.138
R3016 XOR1_to_NAND3#3pin@572_polysilicon-1##0 XOR1_to_NAND3#3pin@572_polysilicon-1##1 8.138
R3017 XOR1_to_NAND3#3pin@572_polysilicon-1##1 XOR1_to_NAND3#3pin@572_polysilicon-1##2 8.138
R3018 XOR1_to_NAND3#3pin@572_polysilicon-1##2 XOR1_to_NAND3#1contact@656_metal-1-metal-2 8.138
R3019 Cin_to_XOR2___NAND3#14nmos@91_poly-right Cin_to_XOR2___NAND3#14nmos@91_poly-right##0 5.425
R3020 Cin_to_XOR2___NAND3#14nmos@91_poly-right##0 Cin_to_XOR2___NAND3#15pin@562_polysilicon-1 5.425
R3021 Cin_to_XOR2___NAND3 Cin_to_XOR2___NAND3##0 8.99
R3022 Cin_to_XOR2___NAND3##0 Cin_to_XOR2___NAND3##1 8.99
R3023 Cin_to_XOR2___NAND3##1 Cin_to_XOR2___NAND3##2 8.99
R3024 Cin_to_XOR2___NAND3##2 Cin_to_XOR2___NAND3##3 8.99
R3025 Cin_to_XOR2___NAND3##3 Cin_to_XOR2___NAND3#15pin@562_polysilicon-1 8.99
R3026 A2#3pin@547_polysilicon-1 A2#3pin@547_polysilicon-1##0 6.2
R3027 A2#3pin@547_polysilicon-1##0 A2#4pmos@85_poly-right 6.2
R3028 XOR1_to_NAND3#9pmos@87_poly-left XOR1_to_NAND3#9pmos@87_poly-left##0 8.138
R3029 XOR1_to_NAND3#9pmos@87_poly-left##0 XOR1_to_NAND3#9pmos@87_poly-left##1 8.138
R3030 XOR1_to_NAND3#9pmos@87_poly-left##1 XOR1_to_NAND3#9pmos@87_poly-left##2 8.138
R3031 XOR1_to_NAND3#9pmos@87_poly-left##2 XOR1_to_NAND3#10pin@559_polysilicon-1 8.138
R3032 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##0 9.843
R3033 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##0 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##1 9.843
R3034 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##1 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##2 9.843
R3035 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##2 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##3 9.843
R3036 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##3 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##4 9.843
R3037 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##4 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##5 9.843
R3038 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##5 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##6 9.843
R3039 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##6 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##7 9.843
R3040 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##7 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##8 9.843
R3041 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##8 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##9 9.843
R3042 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##9 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##10 9.843
R3043 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##10 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##11 9.843
R3044 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##11 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##12 9.843
R3045 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##12 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##13 9.843
R3046 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##13 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##14 9.843
R3047 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##14 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##15 9.843
R3048 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##15 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##16 9.843
R3049 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##16 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##17 9.843
R3050 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##17 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##18 9.843
R3051 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1##18 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1 9.843
R3052 net@1820#4nmos@93_poly-right net@1820#4nmos@93_poly-right##0 9.3
R3053 net@1820#4nmos@93_poly-right##0 net@1820#4nmos@93_poly-right##1 9.3
R3054 net@1820#4nmos@93_poly-right##1 net@1820#5pin@564_polysilicon-1 9.3
R3055 net@1820#2contact@642_metal-1-polysilicon-1 net@1820#2contact@642_metal-1-polysilicon-1##0 8.99
R3056 net@1820#2contact@642_metal-1-polysilicon-1##0 net@1820#2contact@642_metal-1-polysilicon-1##1 8.99
R3057 net@1820#2contact@642_metal-1-polysilicon-1##1 net@1820#2contact@642_metal-1-polysilicon-1##2 8.99
R3058 net@1820#2contact@642_metal-1-polysilicon-1##2 net@1820#2contact@642_metal-1-polysilicon-1##3 8.99
R3059 net@1820#2contact@642_metal-1-polysilicon-1##3 net@1820#5pin@564_polysilicon-1 8.99
R3060 A2#3pin@547_polysilicon-1 A2#3pin@547_polysilicon-1##0 8.138
R3061 A2#3pin@547_polysilicon-1##0 A2#3pin@547_polysilicon-1##1 8.138
R3062 A2#3pin@547_polysilicon-1##1 A2#3pin@547_polysilicon-1##2 8.138
R3063 A2#3pin@547_polysilicon-1##2 A2#1pin@586_metal-2 8.138
R3064 XOR1_to_NAND3#1contact@656_metal-1-metal-2 XOR1_to_NAND3#1contact@656_metal-1-metal-2##0 6.717
R3065 XOR1_to_NAND3#1contact@656_metal-1-metal-2##0 XOR1_to_NAND3#1contact@656_metal-1-metal-2##1 6.717
R3066 XOR1_to_NAND3#1contact@656_metal-1-metal-2##1 XOR1_to_NAND3#12pin@560_polysilicon-1 6.717
R3067 XOR1_to_NAND3#10pin@559_polysilicon-1 XOR1_to_NAND3#10pin@559_polysilicon-1##0 7.75
R3068 XOR1_to_NAND3#10pin@559_polysilicon-1##0 XOR1_to_NAND3#10pin@559_polysilicon-1##1 7.75
R3069 XOR1_to_NAND3#10pin@559_polysilicon-1##1 XOR1_to_NAND3#12pin@560_polysilicon-1 7.75
R3070 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1##0 9.743
R3071 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1##0 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1##1 9.743
R3072 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1##1 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1##2 9.743
R3073 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1##2 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1##3 9.743
R3074 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1##3 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1##4 9.743
R3075 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1##4 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1##5 9.743
R3076 Cin_to_XOR2___NAND3#17pin@569_polysilicon-1##5 Cin_to_XOR2___NAND3 9.743
R3077 net@1811#7pmos@88_poly-left net@1811#7pmos@88_poly-left##0 7.75
R3078 net@1811#7pmos@88_poly-left##0 net@1811 7.75
R3079 Cin_to_XOR2___NAND3#18nmos@89_poly-left Cin_to_XOR2___NAND3#18nmos@89_poly-left##0 6.2
R3080 Cin_to_XOR2___NAND3#18nmos@89_poly-left##0 Cin_to_XOR2___NAND3#16pin@552_polysilicon-1 6.2
R3081 net@1821#9nmos@90_poly-left net@1821#9nmos@90_poly-left##0 8.37
R3082 net@1821#9nmos@90_poly-left##0 net@1821#9nmos@90_poly-left##1 8.37
R3083 net@1821#9nmos@90_poly-left##1 net@1821#9nmos@90_poly-left##2 8.37
R3084 net@1821#9nmos@90_poly-left##2 net@1821#9nmos@90_poly-left##3 8.37
R3085 net@1821#9nmos@90_poly-left##3 net@1821#2contact@617_metal-1-metal-2 8.37
R3086 XOR1_to_NAND3 XOR1_to_NAND3##0 6.717
R3087 XOR1_to_NAND3##0 XOR1_to_NAND3##1 6.717
R3088 XOR1_to_NAND3##1 XOR1_to_NAND3#14pin@576_polysilicon-1 6.717
R3089 XOR1_to_NAND3#16pmos@94_poly-right XOR1_to_NAND3#16pmos@94_poly-right##0 6.2
R3090 XOR1_to_NAND3#16pmos@94_poly-right##0 XOR1_to_NAND3#14pin@576_polysilicon-1 6.2
R3091 Cin_to_XOR2___NAND3#23pin@580_polysilicon-1 Cin_to_XOR2___NAND3#23pin@580_polysilicon-1##0 9.688
R3092 Cin_to_XOR2___NAND3#23pin@580_polysilicon-1##0 Cin_to_XOR2___NAND3#23pin@580_polysilicon-1##1 9.688
R3093 Cin_to_XOR2___NAND3#23pin@580_polysilicon-1##1 Cin_to_XOR2___NAND3#23pin@580_polysilicon-1##2 9.688
R3094 Cin_to_XOR2___NAND3#23pin@580_polysilicon-1##2 Cin_to_XOR2___NAND3#20contact@655_metal-1-metal-2 9.688
R3095 Cin_to_XOR2___NAND3#20contact@655_metal-1-metal-2 Cin_to_XOR2___NAND3 4.953
R3096 A2#0contact@664_metal-1-metal-2 A2#0contact@664_metal-1-metal-2##0 6.717
R3097 A2#0contact@664_metal-1-metal-2##0 A2#0contact@664_metal-1-metal-2##1 6.717
R3098 A2#0contact@664_metal-1-metal-2##1 A2#10pin@583_polysilicon-1 6.717
R3099 A2#11pmos@96_poly-right A2#11pmos@96_poly-right##0 9.558
R3100 A2#11pmos@96_poly-right##0 A2#11pmos@96_poly-right##1 9.558
R3101 A2#11pmos@96_poly-right##1 A2#11pmos@96_poly-right##2 9.558
R3102 A2#11pmos@96_poly-right##2 A2#11pmos@96_poly-right##3 9.558
R3103 A2#11pmos@96_poly-right##3 A2#11pmos@96_poly-right##4 9.558
R3104 A2#11pmos@96_poly-right##4 A2#10pin@583_polysilicon-1 9.558
R3105 B2#10pin@587_polysilicon-1 B2#10pin@587_polysilicon-1##0 8.138
R3106 B2#10pin@587_polysilicon-1##0 B2#10pin@587_polysilicon-1##1 8.138
R3107 B2#10pin@587_polysilicon-1##1 B2#10pin@587_polysilicon-1##2 8.138
R3108 B2#10pin@587_polysilicon-1##2 B2#0contact@665_metal-1-metal-2 8.138
R3109 B2#11nmos@84_poly-right B2#11nmos@84_poly-right##0 5.425
R3110 B2#11nmos@84_poly-right##0 B2#12pin@537_polysilicon-1 5.425
R3111 NAND2_to_Nand5 NAND2_to_Nand5##0 6.717
R3112 NAND2_to_Nand5##0 NAND2_to_Nand5##1 6.717
R3113 NAND2_to_Nand5##1 NAND2_to_Nand5#9pin@589_polysilicon-1 6.717
R3114 NAND2_to_Nand5#10pmos@98_poly-right NAND2_to_Nand5#10pmos@98_poly-right##0 9.558
R3115 NAND2_to_Nand5#10pmos@98_poly-right##0 NAND2_to_Nand5#10pmos@98_poly-right##1 9.558
R3116 NAND2_to_Nand5#10pmos@98_poly-right##1 NAND2_to_Nand5#10pmos@98_poly-right##2 9.558
R3117 NAND2_to_Nand5#10pmos@98_poly-right##2 NAND2_to_Nand5#10pmos@98_poly-right##3 9.558
R3118 NAND2_to_Nand5#10pmos@98_poly-right##3 NAND2_to_Nand5#10pmos@98_poly-right##4 9.558
R3119 NAND2_to_Nand5#10pmos@98_poly-right##4 NAND2_to_Nand5#9pin@589_polysilicon-1 9.558
R3120 B2#1pin@588_metal-2 B2#1pin@588_metal-2##0 8.99
R3121 B2#1pin@588_metal-2##0 B2#1pin@588_metal-2##1 8.99
R3122 B2#1pin@588_metal-2##1 B2#1pin@588_metal-2##2 8.99
R3123 B2#1pin@588_metal-2##2 B2#1pin@588_metal-2##3 8.99
R3124 B2#1pin@588_metal-2##3 B2#12pin@537_polysilicon-1 8.99
R3125 NAND1_to_NAND5#11pmos@99_poly-right NAND1_to_NAND5#11pmos@99_poly-right##0 5.425
R3126 NAND1_to_NAND5#11pmos@99_poly-right##0 NAND1_to_NAND5#12pin@593_polysilicon-1 5.425
R3127 NAND1_to_NAND5#12pin@593_polysilicon-1 NAND1_to_NAND5#12pin@593_polysilicon-1##0 9.3
R3128 NAND1_to_NAND5#12pin@593_polysilicon-1##0 NAND1_to_NAND5#12pin@593_polysilicon-1##1 9.3
R3129 NAND1_to_NAND5#12pin@593_polysilicon-1##1 NAND1_to_NAND5 9.3
R3130 Cin_to_XOR2___NAND3#25nmos@95_poly-right Cin_to_XOR2___NAND3#25nmos@95_poly-right##0 8.636
R3131 Cin_to_XOR2___NAND3#25nmos@95_poly-right##0 Cin_to_XOR2___NAND3#25nmos@95_poly-right##1 8.636
R3132 Cin_to_XOR2___NAND3#25nmos@95_poly-right##1 Cin_to_XOR2___NAND3#25nmos@95_poly-right##2 8.636
R3133 Cin_to_XOR2___NAND3#25nmos@95_poly-right##2 Cin_to_XOR2___NAND3#25nmos@95_poly-right##3 8.636
R3134 Cin_to_XOR2___NAND3#25nmos@95_poly-right##3 Cin_to_XOR2___NAND3#25nmos@95_poly-right##4 8.636
R3135 Cin_to_XOR2___NAND3#25nmos@95_poly-right##4 Cin_to_XOR2___NAND3#25nmos@95_poly-right##5 8.636
R3136 Cin_to_XOR2___NAND3#25nmos@95_poly-right##5 Cin_to_XOR2___NAND3#23pin@580_polysilicon-1 8.636
R3137 B2#13nmos@97_poly-right B2#13nmos@97_poly-right##0 8.956
R3138 B2#13nmos@97_poly-right##0 B2#13nmos@97_poly-right##1 8.956
R3139 B2#13nmos@97_poly-right##1 B2#13nmos@97_poly-right##2 8.956
R3140 B2#13nmos@97_poly-right##2 B2#13nmos@97_poly-right##3 8.956
R3141 B2#13nmos@97_poly-right##3 B2#13nmos@97_poly-right##4 8.956
R3142 B2#13nmos@97_poly-right##4 B2#13nmos@97_poly-right##5 8.956
R3143 B2#13nmos@97_poly-right##5 B2#13nmos@97_poly-right##6 8.956
R3144 B2#13nmos@97_poly-right##6 B2#13nmos@97_poly-right##7 8.956
R3145 B2#13nmos@97_poly-right##7 B2#10pin@587_polysilicon-1 8.956
R3146 A2#12pmos@80_poly-left A2#12pmos@80_poly-left##0 8.138
R3147 A2#12pmos@80_poly-left##0 A2#12pmos@80_poly-left##1 8.138
R3148 A2#12pmos@80_poly-left##1 A2#12pmos@80_poly-left##2 8.138
R3149 A2#12pmos@80_poly-left##2 A2#13pin@534_polysilicon-1 8.138
R3150 B2#14pin@527_polysilicon-1 B2#14pin@527_polysilicon-1##0 9.843
R3151 B2#14pin@527_polysilicon-1##0 B2#14pin@527_polysilicon-1##1 9.843
R3152 B2#14pin@527_polysilicon-1##1 B2#14pin@527_polysilicon-1##2 9.843
R3153 B2#14pin@527_polysilicon-1##2 B2#14pin@527_polysilicon-1##3 9.843
R3154 B2#14pin@527_polysilicon-1##3 B2#14pin@527_polysilicon-1##4 9.843
R3155 B2#14pin@527_polysilicon-1##4 B2#14pin@527_polysilicon-1##5 9.843
R3156 B2#14pin@527_polysilicon-1##5 B2#14pin@527_polysilicon-1##6 9.843
R3157 B2#14pin@527_polysilicon-1##6 B2#14pin@527_polysilicon-1##7 9.843
R3158 B2#14pin@527_polysilicon-1##7 B2#14pin@527_polysilicon-1##8 9.843
R3159 B2#14pin@527_polysilicon-1##8 B2#14pin@527_polysilicon-1##9 9.843
R3160 B2#14pin@527_polysilicon-1##9 B2#14pin@527_polysilicon-1##10 9.843
R3161 B2#14pin@527_polysilicon-1##10 B2#14pin@527_polysilicon-1##11 9.843
R3162 B2#14pin@527_polysilicon-1##11 B2#14pin@527_polysilicon-1##12 9.843
R3163 B2#14pin@527_polysilicon-1##12 B2#14pin@527_polysilicon-1##13 9.843
R3164 B2#14pin@527_polysilicon-1##13 B2#14pin@527_polysilicon-1##14 9.843
R3165 B2#14pin@527_polysilicon-1##14 B2#14pin@527_polysilicon-1##15 9.843
R3166 B2#14pin@527_polysilicon-1##15 B2#14pin@527_polysilicon-1##16 9.843
R3167 B2#14pin@527_polysilicon-1##16 B2#14pin@527_polysilicon-1##17 9.843
R3168 B2#14pin@527_polysilicon-1##17 B2#14pin@527_polysilicon-1##18 9.843
R3169 B2#14pin@527_polysilicon-1##18 B2#15pin@544_polysilicon-1 9.843
R3170 net@1907#4nmos@86_poly-right net@1907#4nmos@86_poly-right##0 7.233
R3171 net@1907#4nmos@86_poly-right##0 net@1907#4nmos@86_poly-right##1 7.233
R3172 net@1907#4nmos@86_poly-right##1 net@1907#5pin@539_polysilicon-1 7.233
R3173 net@1907#2contact@603_metal-1-polysilicon-1 net@1907#2contact@603_metal-1-polysilicon-1##0 8.99
R3174 net@1907#2contact@603_metal-1-polysilicon-1##0 net@1907#2contact@603_metal-1-polysilicon-1##1 8.99
R3175 net@1907#2contact@603_metal-1-polysilicon-1##1 net@1907#2contact@603_metal-1-polysilicon-1##2 8.99
R3176 net@1907#2contact@603_metal-1-polysilicon-1##2 net@1907#2contact@603_metal-1-polysilicon-1##3 8.99
R3177 net@1907#2contact@603_metal-1-polysilicon-1##3 net@1907#5pin@539_polysilicon-1 8.99
R3178 A2#1pin@586_metal-2 A2#1pin@586_metal-2##0 6.717
R3179 A2#1pin@586_metal-2##0 A2#1pin@586_metal-2##1 6.717
R3180 A2#1pin@586_metal-2##1 A2#15pin@535_polysilicon-1 6.717
R3181 A2#13pin@534_polysilicon-1 A2#13pin@534_polysilicon-1##0 7.75
R3182 A2#13pin@534_polysilicon-1##0 A2#13pin@534_polysilicon-1##1 7.75
R3183 A2#13pin@534_polysilicon-1##1 A2#15pin@535_polysilicon-1 7.75
R3184 B2#15pin@544_polysilicon-1 B2#15pin@544_polysilicon-1##0 9.743
R3185 B2#15pin@544_polysilicon-1##0 B2#15pin@544_polysilicon-1##1 9.743
R3186 B2#15pin@544_polysilicon-1##1 B2#15pin@544_polysilicon-1##2 9.743
R3187 B2#15pin@544_polysilicon-1##2 B2#15pin@544_polysilicon-1##3 9.743
R3188 B2#15pin@544_polysilicon-1##3 B2#15pin@544_polysilicon-1##4 9.743
R3189 B2#15pin@544_polysilicon-1##4 B2#15pin@544_polysilicon-1##5 9.743
R3190 B2#15pin@544_polysilicon-1##5 B2#1pin@588_metal-2 9.743
R3191 net@1809#7pmos@81_poly-left net@1809#7pmos@81_poly-left##0 7.75
R3192 net@1809#7pmos@81_poly-left##0 net@1809 7.75
R3193 B2#16nmos@82_poly-left B2#16nmos@82_poly-left##0 6.2
R3194 B2#16nmos@82_poly-left##0 B2#14pin@527_polysilicon-1 6.2
R3195 net@1914#9nmos@83_poly-left net@1914#9nmos@83_poly-left##0 8.37
R3196 net@1914#9nmos@83_poly-left##0 net@1914#9nmos@83_poly-left##1 8.37
R3197 net@1914#9nmos@83_poly-left##1 net@1914#9nmos@83_poly-left##2 8.37
R3198 net@1914#9nmos@83_poly-left##2 net@1914#9nmos@83_poly-left##3 8.37
R3199 net@1914#9nmos@83_poly-left##3 net@1914#2contact@579_metal-1-metal-2 8.37
R3200 A2#3pin@547_polysilicon-1 A2#3pin@547_polysilicon-1##0 9.881
R3201 A2#3pin@547_polysilicon-1##0 A2#3pin@547_polysilicon-1##1 9.881
R3202 A2#3pin@547_polysilicon-1##1 A2#3pin@547_polysilicon-1##2 9.881
R3203 A2#3pin@547_polysilicon-1##2 A2#3pin@547_polysilicon-1##3 9.881
R3204 A2#3pin@547_polysilicon-1##3 A2#3pin@547_polysilicon-1##4 9.881
R3205 A2#3pin@547_polysilicon-1##4 A2#3pin@547_polysilicon-1##5 9.881
R3206 A2#3pin@547_polysilicon-1##5 A2#3pin@547_polysilicon-1##6 9.881
R3207 A2#3pin@547_polysilicon-1##6 A2#3pin@547_polysilicon-1##7 9.881
R3208 A2#3pin@547_polysilicon-1##7 A2#3pin@547_polysilicon-1##8 9.881
R3209 A2#3pin@547_polysilicon-1##8 A2#3pin@547_polysilicon-1##9 9.881
R3210 A2#3pin@547_polysilicon-1##9 A2#3pin@547_polysilicon-1##10 9.881
R3211 A2#3pin@547_polysilicon-1##10 A2#3pin@547_polysilicon-1##11 9.881
R3212 A2#3pin@547_polysilicon-1##11 A2#3pin@547_polysilicon-1##12 9.881
R3213 A2#3pin@547_polysilicon-1##12 A2#3pin@547_polysilicon-1##13 9.881
R3214 A2#3pin@547_polysilicon-1##13 A2#3pin@547_polysilicon-1##14 9.881
R3215 A2#3pin@547_polysilicon-1##14 A2#3pin@547_polysilicon-1##15 9.881
R3216 A2#3pin@547_polysilicon-1##15 A2#3pin@547_polysilicon-1##16 9.881
R3217 A2#3pin@547_polysilicon-1##16 A2#3pin@547_polysilicon-1##17 9.881
R3218 A2#3pin@547_polysilicon-1##17 A2#3pin@547_polysilicon-1##18 9.881
R3219 A2#3pin@547_polysilicon-1##18 A2#3pin@547_polysilicon-1##19 9.881
R3220 A2#3pin@547_polysilicon-1##19 A2#3pin@547_polysilicon-1##20 9.881
R3221 A2#3pin@547_polysilicon-1##20 A2#3pin@547_polysilicon-1##21 9.881
R3222 A2#3pin@547_polysilicon-1##21 A2#3pin@547_polysilicon-1##22 9.881
R3223 A2#3pin@547_polysilicon-1##22 A2#3pin@547_polysilicon-1##23 9.881
R3224 A2#3pin@547_polysilicon-1##23 A2#3pin@547_polysilicon-1##24 9.881
R3225 A2#3pin@547_polysilicon-1##24 A2#3pin@547_polysilicon-1##25 9.881
R3226 A2#3pin@547_polysilicon-1##25 A2#3pin@547_polysilicon-1##26 9.881
R3227 A2#3pin@547_polysilicon-1##26 A2#3pin@547_polysilicon-1##27 9.881
R3228 A2#3pin@547_polysilicon-1##27 A2#3pin@547_polysilicon-1##28 9.881
R3229 A2#3pin@547_polysilicon-1##28 A2#3pin@547_polysilicon-1##29 9.881
R3230 A2#3pin@547_polysilicon-1##29 A2#3pin@547_polysilicon-1##30 9.881
R3231 A2#3pin@547_polysilicon-1##30 A2#3pin@547_polysilicon-1##31 9.881
R3232 A2#3pin@547_polysilicon-1##31 A2#3pin@547_polysilicon-1##32 9.881
R3233 A2#3pin@547_polysilicon-1##32 A2#3pin@547_polysilicon-1##33 9.881
R3234 A2#3pin@547_polysilicon-1##33 A2#3pin@547_polysilicon-1##34 9.881
R3235 A2#3pin@547_polysilicon-1##34 A2#3pin@547_polysilicon-1##35 9.881
R3236 A2#3pin@547_polysilicon-1##35 A2#3pin@547_polysilicon-1##36 9.881
R3237 A2#3pin@547_polysilicon-1##36 A2#3pin@547_polysilicon-1##37 9.881
R3238 A2#3pin@547_polysilicon-1##37 A2#3pin@547_polysilicon-1##38 9.881
R3239 A2#3pin@547_polysilicon-1##38 A2#3pin@547_polysilicon-1##39 9.881
R3240 A2#3pin@547_polysilicon-1##39 A2#3pin@547_polysilicon-1##40 9.881
R3241 A2#3pin@547_polysilicon-1##40 A2#3pin@547_polysilicon-1##41 9.881
R3242 A2#3pin@547_polysilicon-1##41 A2#3pin@547_polysilicon-1##42 9.881
R3243 A2#3pin@547_polysilicon-1##42 A2#3pin@547_polysilicon-1##43 9.881
R3244 A2#3pin@547_polysilicon-1##43 A2#3pin@547_polysilicon-1##44 9.881
R3245 A2#3pin@547_polysilicon-1##44 A2#3pin@547_polysilicon-1##45 9.881
R3246 A2#3pin@547_polysilicon-1##45 A2#3pin@547_polysilicon-1##46 9.881
R3247 A2#3pin@547_polysilicon-1##46 A2#3pin@547_polysilicon-1##47 9.881
R3248 A2#3pin@547_polysilicon-1##47 A2#3pin@547_polysilicon-1##48 9.881
R3249 A2#3pin@547_polysilicon-1##48 A2#3pin@547_polysilicon-1##49 9.881
R3250 A2#3pin@547_polysilicon-1##49 A2#3pin@547_polysilicon-1##50 9.881
R3251 A2#3pin@547_polysilicon-1##50 A2#3pin@547_polysilicon-1##51 9.881
R3252 A2#3pin@547_polysilicon-1##51 A2#3pin@547_polysilicon-1##52 9.881
R3253 A2#3pin@547_polysilicon-1##52 A2#3pin@547_polysilicon-1##53 9.881
R3254 A2#3pin@547_polysilicon-1##53 A2#3pin@547_polysilicon-1##54 9.881
R3255 A2#3pin@547_polysilicon-1##54 A2#16nmos@85_poly-right 9.881
R3256 net@1809#5pmos@85_diff-top net@1809#2pin@536_metal-1 4.81
R3257 net@1809#1pin@546_polysilicon-1 net@1809#1pin@546_polysilicon-1##0 9.85
R3258 net@1809#1pin@546_polysilicon-1##0 net@1809#1pin@546_polysilicon-1##1 9.85
R3259 net@1809#1pin@546_polysilicon-1##1 net@1809#1pin@546_polysilicon-1##2 9.85
R3260 net@1809#1pin@546_polysilicon-1##2 net@1809#1pin@546_polysilicon-1##3 9.85
R3261 net@1809#1pin@546_polysilicon-1##3 net@1809#1pin@546_polysilicon-1##4 9.85
R3262 net@1809#1pin@546_polysilicon-1##4 net@1809#1pin@546_polysilicon-1##5 9.85
R3263 net@1809#1pin@546_polysilicon-1##5 net@1809#1pin@546_polysilicon-1##6 9.85
R3264 net@1809#1pin@546_polysilicon-1##6 net@1809#1pin@546_polysilicon-1##7 9.85
R3265 net@1809#1pin@546_polysilicon-1##7 net@1809#1pin@546_polysilicon-1##8 9.85
R3266 net@1809#1pin@546_polysilicon-1##8 net@1809#1pin@546_polysilicon-1##9 9.85
R3267 net@1809#1pin@546_polysilicon-1##9 net@1809#1pin@546_polysilicon-1##10 9.85
R3268 net@1809#1pin@546_polysilicon-1##10 net@1809#1pin@546_polysilicon-1##11 9.85
R3269 net@1809#1pin@546_polysilicon-1##11 net@1809#1pin@546_polysilicon-1##12 9.85
R3270 net@1809#1pin@546_polysilicon-1##12 net@1809#1pin@546_polysilicon-1##13 9.85
R3271 net@1809#1pin@546_polysilicon-1##13 net@1809#1pin@546_polysilicon-1##14 9.85
R3272 net@1809#1pin@546_polysilicon-1##14 net@1809#1pin@546_polysilicon-1##15 9.85
R3273 net@1809#1pin@546_polysilicon-1##15 net@1809#1pin@546_polysilicon-1##16 9.85
R3274 net@1809#1pin@546_polysilicon-1##16 net@1809#1pin@546_polysilicon-1##17 9.85
R3275 net@1809#1pin@546_polysilicon-1##17 net@1809#1pin@546_polysilicon-1##18 9.85
R3276 net@1809#1pin@546_polysilicon-1##18 net@1809#1pin@546_polysilicon-1##19 9.85
R3277 net@1809#1pin@546_polysilicon-1##19 net@1809#1pin@546_polysilicon-1##20 9.85
R3278 net@1809#1pin@546_polysilicon-1##20 net@1809#1pin@546_polysilicon-1##21 9.85
R3279 net@1809#1pin@546_polysilicon-1##21 net@1809#1pin@546_polysilicon-1##22 9.85
R3280 net@1809#1pin@546_polysilicon-1##22 net@1809#1pin@546_polysilicon-1##23 9.85
R3281 net@1809#1pin@546_polysilicon-1##23 net@1809#1pin@546_polysilicon-1##24 9.85
R3282 net@1809#1pin@546_polysilicon-1##24 net@1809#1pin@546_polysilicon-1##25 9.85
R3283 net@1809#1pin@546_polysilicon-1##25 net@1809#1pin@546_polysilicon-1##26 9.85
R3284 net@1809#1pin@546_polysilicon-1##26 net@1809#1pin@546_polysilicon-1##27 9.85
R3285 net@1809#1pin@546_polysilicon-1##27 net@1809#1pin@546_polysilicon-1##28 9.85
R3286 net@1809#1pin@546_polysilicon-1##28 net@1809#1pin@546_polysilicon-1##29 9.85
R3287 net@1809#1pin@546_polysilicon-1##29 net@1809#1pin@546_polysilicon-1##30 9.85
R3288 net@1809#1pin@546_polysilicon-1##30 net@1809#1pin@546_polysilicon-1##31 9.85
R3289 net@1809#1pin@546_polysilicon-1##31 net@1809#1pin@546_polysilicon-1##32 9.85
R3290 net@1809#1pin@546_polysilicon-1##32 net@1809#1pin@546_polysilicon-1##33 9.85
R3291 net@1809#1pin@546_polysilicon-1##33 net@1809#1pin@546_polysilicon-1##34 9.85
R3292 net@1809#1pin@546_polysilicon-1##34 net@1809#1pin@546_polysilicon-1##35 9.85
R3293 net@1809#1pin@546_polysilicon-1##35 net@1809#1pin@546_polysilicon-1##36 9.85
R3294 net@1809#1pin@546_polysilicon-1##36 net@1809#1pin@546_polysilicon-1##37 9.85
R3295 net@1809#1pin@546_polysilicon-1##37 net@1809#1pin@546_polysilicon-1##38 9.85
R3296 net@1809#1pin@546_polysilicon-1##38 net@1809#1pin@546_polysilicon-1##39 9.85
R3297 net@1809#1pin@546_polysilicon-1##39 net@1809#1pin@546_polysilicon-1##40 9.85
R3298 net@1809#1pin@546_polysilicon-1##40 net@1809#1pin@546_polysilicon-1##41 9.85
R3299 net@1809#1pin@546_polysilicon-1##41 net@1809#1pin@546_polysilicon-1##42 9.85
R3300 net@1809#1pin@546_polysilicon-1##42 net@1809#1pin@546_polysilicon-1##43 9.85
R3301 net@1809#1pin@546_polysilicon-1##43 net@1809#1pin@546_polysilicon-1##44 9.85
R3302 net@1809#1pin@546_polysilicon-1##44 net@1809#1pin@546_polysilicon-1##45 9.85
R3303 net@1809#1pin@546_polysilicon-1##45 net@1809#1pin@546_polysilicon-1##46 9.85
R3304 net@1809#1pin@546_polysilicon-1##46 net@1809#1pin@546_polysilicon-1##47 9.85
R3305 net@1809#1pin@546_polysilicon-1##47 net@1809#1pin@546_polysilicon-1##48 9.85
R3306 net@1809#1pin@546_polysilicon-1##48 net@1809#1pin@546_polysilicon-1##49 9.85
R3307 net@1809#1pin@546_polysilicon-1##49 net@1809#1pin@546_polysilicon-1##50 9.85
R3308 net@1809#1pin@546_polysilicon-1##50 net@1809#1pin@546_polysilicon-1##51 9.85
R3309 net@1809#1pin@546_polysilicon-1##51 net@1809#1pin@546_polysilicon-1##52 9.85
R3310 net@1809#1pin@546_polysilicon-1##52 net@1809#1pin@546_polysilicon-1##53 9.85
R3311 net@1809#1pin@546_polysilicon-1##53 net@1809#1pin@546_polysilicon-1##54 9.85
R3312 net@1809#1pin@546_polysilicon-1##54 net@1809#1pin@546_polysilicon-1##55 9.85
R3313 net@1809#1pin@546_polysilicon-1##55 net@1809#1pin@546_polysilicon-1##56 9.85
R3314 net@1809#1pin@546_polysilicon-1##56 net@1809#1pin@546_polysilicon-1##57 9.85
R3315 net@1809#1pin@546_polysilicon-1##57 net@1809#1pin@546_polysilicon-1##58 9.85
R3316 net@1809#1pin@546_polysilicon-1##58 net@1809#1pin@546_polysilicon-1##59 9.85
R3317 net@1809#1pin@546_polysilicon-1##59 net@1809#1pin@546_polysilicon-1##60 9.85
R3318 net@1809#1pin@546_polysilicon-1##60 net@1809#2pin@536_metal-1 9.85
R3319 B2#17pmos@84_poly-right B2#17pmos@84_poly-right##0 9.854
R3320 B2#17pmos@84_poly-right##0 B2#17pmos@84_poly-right##1 9.854
R3321 B2#17pmos@84_poly-right##1 B2#17pmos@84_poly-right##2 9.854
R3322 B2#17pmos@84_poly-right##2 B2#17pmos@84_poly-right##3 9.854
R3323 B2#17pmos@84_poly-right##3 B2#17pmos@84_poly-right##4 9.854
R3324 B2#17pmos@84_poly-right##4 B2#17pmos@84_poly-right##5 9.854
R3325 B2#17pmos@84_poly-right##5 B2#17pmos@84_poly-right##6 9.854
R3326 B2#17pmos@84_poly-right##6 B2#17pmos@84_poly-right##7 9.854
R3327 B2#17pmos@84_poly-right##7 B2#17pmos@84_poly-right##8 9.854
R3328 B2#17pmos@84_poly-right##8 B2#17pmos@84_poly-right##9 9.854
R3329 B2#17pmos@84_poly-right##9 B2#17pmos@84_poly-right##10 9.854
R3330 B2#17pmos@84_poly-right##10 B2#17pmos@84_poly-right##11 9.854
R3331 B2#17pmos@84_poly-right##11 B2#17pmos@84_poly-right##12 9.854
R3332 B2#17pmos@84_poly-right##12 B2#17pmos@84_poly-right##13 9.854
R3333 B2#17pmos@84_poly-right##13 B2#17pmos@84_poly-right##14 9.854
R3334 B2#17pmos@84_poly-right##14 B2#17pmos@84_poly-right##15 9.854
R3335 B2#17pmos@84_poly-right##15 B2#17pmos@84_poly-right##16 9.854
R3336 B2#17pmos@84_poly-right##16 B2#17pmos@84_poly-right##17 9.854
R3337 B2#17pmos@84_poly-right##17 B2#17pmos@84_poly-right##18 9.854
R3338 B2#17pmos@84_poly-right##18 B2#17pmos@84_poly-right##19 9.854
R3339 B2#17pmos@84_poly-right##19 B2#17pmos@84_poly-right##20 9.854
R3340 B2#17pmos@84_poly-right##20 B2#17pmos@84_poly-right##21 9.854
R3341 B2#17pmos@84_poly-right##21 B2#17pmos@84_poly-right##22 9.854
R3342 B2#17pmos@84_poly-right##22 B2#17pmos@84_poly-right##23 9.854
R3343 B2#17pmos@84_poly-right##23 B2#17pmos@84_poly-right##24 9.854
R3344 B2#17pmos@84_poly-right##24 B2#17pmos@84_poly-right##25 9.854
R3345 B2#17pmos@84_poly-right##25 B2#17pmos@84_poly-right##26 9.854
R3346 B2#17pmos@84_poly-right##26 B2#17pmos@84_poly-right##27 9.854
R3347 B2#17pmos@84_poly-right##27 B2#17pmos@84_poly-right##28 9.854
R3348 B2#17pmos@84_poly-right##28 B2#17pmos@84_poly-right##29 9.854
R3349 B2#17pmos@84_poly-right##29 B2#17pmos@84_poly-right##30 9.854
R3350 B2#17pmos@84_poly-right##30 B2#17pmos@84_poly-right##31 9.854
R3351 B2#17pmos@84_poly-right##31 B2#17pmos@84_poly-right##32 9.854
R3352 B2#17pmos@84_poly-right##32 B2#17pmos@84_poly-right##33 9.854
R3353 B2#17pmos@84_poly-right##33 B2#17pmos@84_poly-right##34 9.854
R3354 B2#17pmos@84_poly-right##34 B2#17pmos@84_poly-right##35 9.854
R3355 B2#17pmos@84_poly-right##35 B2#17pmos@84_poly-right##36 9.854
R3356 B2#17pmos@84_poly-right##36 B2#17pmos@84_poly-right##37 9.854
R3357 B2#17pmos@84_poly-right##37 B2#17pmos@84_poly-right##38 9.854
R3358 B2#17pmos@84_poly-right##38 B2#17pmos@84_poly-right##39 9.854
R3359 B2#17pmos@84_poly-right##39 B2#17pmos@84_poly-right##40 9.854
R3360 B2#17pmos@84_poly-right##40 B2#17pmos@84_poly-right##41 9.854
R3361 B2#17pmos@84_poly-right##41 B2#17pmos@84_poly-right##42 9.854
R3362 B2#17pmos@84_poly-right##42 B2#17pmos@84_poly-right##43 9.854
R3363 B2#17pmos@84_poly-right##43 B2#17pmos@84_poly-right##44 9.854
R3364 B2#17pmos@84_poly-right##44 B2#17pmos@84_poly-right##45 9.854
R3365 B2#17pmos@84_poly-right##45 B2#17pmos@84_poly-right##46 9.854
R3366 B2#17pmos@84_poly-right##46 B2#17pmos@84_poly-right##47 9.854
R3367 B2#17pmos@84_poly-right##47 B2#17pmos@84_poly-right##48 9.854
R3368 B2#17pmos@84_poly-right##48 B2#17pmos@84_poly-right##49 9.854
R3369 B2#17pmos@84_poly-right##49 B2#17pmos@84_poly-right##50 9.854
R3370 B2#17pmos@84_poly-right##50 B2#17pmos@84_poly-right##51 9.854
R3371 B2#17pmos@84_poly-right##51 B2#17pmos@84_poly-right##52 9.854
R3372 B2#17pmos@84_poly-right##52 B2#17pmos@84_poly-right##53 9.854
R3373 B2#17pmos@84_poly-right##53 B2#17pmos@84_poly-right##54 9.854
R3374 B2#17pmos@84_poly-right##54 B2#12pin@537_polysilicon-1 9.854
R3375 net@1914 net@1914#2contact@579_metal-1-metal-2 4.797
R3376 A2#17nmos@80_poly-right A2#17nmos@80_poly-right##0 9.871
R3377 A2#17nmos@80_poly-right##0 A2#17nmos@80_poly-right##1 9.871
R3378 A2#17nmos@80_poly-right##1 A2#17nmos@80_poly-right##2 9.871
R3379 A2#17nmos@80_poly-right##2 A2#17nmos@80_poly-right##3 9.871
R3380 A2#17nmos@80_poly-right##3 A2#17nmos@80_poly-right##4 9.871
R3381 A2#17nmos@80_poly-right##4 A2#17nmos@80_poly-right##5 9.871
R3382 A2#17nmos@80_poly-right##5 A2#17nmos@80_poly-right##6 9.871
R3383 A2#17nmos@80_poly-right##6 A2#17nmos@80_poly-right##7 9.871
R3384 A2#17nmos@80_poly-right##7 A2#17nmos@80_poly-right##8 9.871
R3385 A2#17nmos@80_poly-right##8 A2#17nmos@80_poly-right##9 9.871
R3386 A2#17nmos@80_poly-right##9 A2#17nmos@80_poly-right##10 9.871
R3387 A2#17nmos@80_poly-right##10 A2#17nmos@80_poly-right##11 9.871
R3388 A2#17nmos@80_poly-right##11 A2#17nmos@80_poly-right##12 9.871
R3389 A2#17nmos@80_poly-right##12 A2#17nmos@80_poly-right##13 9.871
R3390 A2#17nmos@80_poly-right##13 A2#17nmos@80_poly-right##14 9.871
R3391 A2#17nmos@80_poly-right##14 A2#17nmos@80_poly-right##15 9.871
R3392 A2#17nmos@80_poly-right##15 A2#17nmos@80_poly-right##16 9.871
R3393 A2#17nmos@80_poly-right##16 A2#17nmos@80_poly-right##17 9.871
R3394 A2#17nmos@80_poly-right##17 A2#17nmos@80_poly-right##18 9.871
R3395 A2#17nmos@80_poly-right##18 A2#17nmos@80_poly-right##19 9.871
R3396 A2#17nmos@80_poly-right##19 A2#17nmos@80_poly-right##20 9.871
R3397 A2#17nmos@80_poly-right##20 A2#17nmos@80_poly-right##21 9.871
R3398 A2#17nmos@80_poly-right##21 A2#17nmos@80_poly-right##22 9.871
R3399 A2#17nmos@80_poly-right##22 A2#17nmos@80_poly-right##23 9.871
R3400 A2#17nmos@80_poly-right##23 A2#17nmos@80_poly-right##24 9.871
R3401 A2#17nmos@80_poly-right##24 A2#17nmos@80_poly-right##25 9.871
R3402 A2#17nmos@80_poly-right##25 A2#17nmos@80_poly-right##26 9.871
R3403 A2#17nmos@80_poly-right##26 A2#17nmos@80_poly-right##27 9.871
R3404 A2#17nmos@80_poly-right##27 A2#17nmos@80_poly-right##28 9.871
R3405 A2#17nmos@80_poly-right##28 A2#17nmos@80_poly-right##29 9.871
R3406 A2#17nmos@80_poly-right##29 A2#17nmos@80_poly-right##30 9.871
R3407 A2#17nmos@80_poly-right##30 A2#17nmos@80_poly-right##31 9.871
R3408 A2#17nmos@80_poly-right##31 A2#17nmos@80_poly-right##32 9.871
R3409 A2#17nmos@80_poly-right##32 A2#17nmos@80_poly-right##33 9.871
R3410 A2#17nmos@80_poly-right##33 A2#17nmos@80_poly-right##34 9.871
R3411 A2#17nmos@80_poly-right##34 A2#17nmos@80_poly-right##35 9.871
R3412 A2#17nmos@80_poly-right##35 A2#17nmos@80_poly-right##36 9.871
R3413 A2#17nmos@80_poly-right##36 A2#17nmos@80_poly-right##37 9.871
R3414 A2#17nmos@80_poly-right##37 A2#17nmos@80_poly-right##38 9.871
R3415 A2#17nmos@80_poly-right##38 A2#17nmos@80_poly-right##39 9.871
R3416 A2#17nmos@80_poly-right##39 A2#17nmos@80_poly-right##40 9.871
R3417 A2#17nmos@80_poly-right##40 A2#17nmos@80_poly-right##41 9.871
R3418 A2#17nmos@80_poly-right##41 A2#17nmos@80_poly-right##42 9.871
R3419 A2#17nmos@80_poly-right##42 A2#17nmos@80_poly-right##43 9.871
R3420 A2#17nmos@80_poly-right##43 A2#17nmos@80_poly-right##44 9.871
R3421 A2#17nmos@80_poly-right##44 A2#17nmos@80_poly-right##45 9.871
R3422 A2#17nmos@80_poly-right##45 A2#17nmos@80_poly-right##46 9.871
R3423 A2#17nmos@80_poly-right##46 A2#17nmos@80_poly-right##47 9.871
R3424 A2#17nmos@80_poly-right##47 A2#17nmos@80_poly-right##48 9.871
R3425 A2#17nmos@80_poly-right##48 A2#17nmos@80_poly-right##49 9.871
R3426 A2#17nmos@80_poly-right##49 A2#17nmos@80_poly-right##50 9.871
R3427 A2#17nmos@80_poly-right##50 A2#17nmos@80_poly-right##51 9.871
R3428 A2#17nmos@80_poly-right##51 A2#17nmos@80_poly-right##52 9.871
R3429 A2#17nmos@80_poly-right##52 A2#17nmos@80_poly-right##53 9.871
R3430 A2#17nmos@80_poly-right##53 A2#17nmos@80_poly-right##54 9.871
R3431 A2#17nmos@80_poly-right##54 A2#17nmos@80_poly-right##55 9.871
R3432 A2#17nmos@80_poly-right##55 A2#12pmos@80_poly-left 9.871
R3433 net@1809#7pmos@81_poly-left net@1809#7pmos@81_poly-left##0 9.871
R3434 net@1809#7pmos@81_poly-left##0 net@1809#7pmos@81_poly-left##1 9.871
R3435 net@1809#7pmos@81_poly-left##1 net@1809#7pmos@81_poly-left##2 9.871
R3436 net@1809#7pmos@81_poly-left##2 net@1809#7pmos@81_poly-left##3 9.871
R3437 net@1809#7pmos@81_poly-left##3 net@1809#7pmos@81_poly-left##4 9.871
R3438 net@1809#7pmos@81_poly-left##4 net@1809#7pmos@81_poly-left##5 9.871
R3439 net@1809#7pmos@81_poly-left##5 net@1809#7pmos@81_poly-left##6 9.871
R3440 net@1809#7pmos@81_poly-left##6 net@1809#7pmos@81_poly-left##7 9.871
R3441 net@1809#7pmos@81_poly-left##7 net@1809#7pmos@81_poly-left##8 9.871
R3442 net@1809#7pmos@81_poly-left##8 net@1809#7pmos@81_poly-left##9 9.871
R3443 net@1809#7pmos@81_poly-left##9 net@1809#7pmos@81_poly-left##10 9.871
R3444 net@1809#7pmos@81_poly-left##10 net@1809#7pmos@81_poly-left##11 9.871
R3445 net@1809#7pmos@81_poly-left##11 net@1809#7pmos@81_poly-left##12 9.871
R3446 net@1809#7pmos@81_poly-left##12 net@1809#7pmos@81_poly-left##13 9.871
R3447 net@1809#7pmos@81_poly-left##13 net@1809#7pmos@81_poly-left##14 9.871
R3448 net@1809#7pmos@81_poly-left##14 net@1809#7pmos@81_poly-left##15 9.871
R3449 net@1809#7pmos@81_poly-left##15 net@1809#7pmos@81_poly-left##16 9.871
R3450 net@1809#7pmos@81_poly-left##16 net@1809#7pmos@81_poly-left##17 9.871
R3451 net@1809#7pmos@81_poly-left##17 net@1809#7pmos@81_poly-left##18 9.871
R3452 net@1809#7pmos@81_poly-left##18 net@1809#7pmos@81_poly-left##19 9.871
R3453 net@1809#7pmos@81_poly-left##19 net@1809#7pmos@81_poly-left##20 9.871
R3454 net@1809#7pmos@81_poly-left##20 net@1809#7pmos@81_poly-left##21 9.871
R3455 net@1809#7pmos@81_poly-left##21 net@1809#7pmos@81_poly-left##22 9.871
R3456 net@1809#7pmos@81_poly-left##22 net@1809#7pmos@81_poly-left##23 9.871
R3457 net@1809#7pmos@81_poly-left##23 net@1809#7pmos@81_poly-left##24 9.871
R3458 net@1809#7pmos@81_poly-left##24 net@1809#7pmos@81_poly-left##25 9.871
R3459 net@1809#7pmos@81_poly-left##25 net@1809#7pmos@81_poly-left##26 9.871
R3460 net@1809#7pmos@81_poly-left##26 net@1809#7pmos@81_poly-left##27 9.871
R3461 net@1809#7pmos@81_poly-left##27 net@1809#7pmos@81_poly-left##28 9.871
R3462 net@1809#7pmos@81_poly-left##28 net@1809#7pmos@81_poly-left##29 9.871
R3463 net@1809#7pmos@81_poly-left##29 net@1809#7pmos@81_poly-left##30 9.871
R3464 net@1809#7pmos@81_poly-left##30 net@1809#7pmos@81_poly-left##31 9.871
R3465 net@1809#7pmos@81_poly-left##31 net@1809#7pmos@81_poly-left##32 9.871
R3466 net@1809#7pmos@81_poly-left##32 net@1809#7pmos@81_poly-left##33 9.871
R3467 net@1809#7pmos@81_poly-left##33 net@1809#7pmos@81_poly-left##34 9.871
R3468 net@1809#7pmos@81_poly-left##34 net@1809#7pmos@81_poly-left##35 9.871
R3469 net@1809#7pmos@81_poly-left##35 net@1809#7pmos@81_poly-left##36 9.871
R3470 net@1809#7pmos@81_poly-left##36 net@1809#7pmos@81_poly-left##37 9.871
R3471 net@1809#7pmos@81_poly-left##37 net@1809#7pmos@81_poly-left##38 9.871
R3472 net@1809#7pmos@81_poly-left##38 net@1809#7pmos@81_poly-left##39 9.871
R3473 net@1809#7pmos@81_poly-left##39 net@1809#7pmos@81_poly-left##40 9.871
R3474 net@1809#7pmos@81_poly-left##40 net@1809#7pmos@81_poly-left##41 9.871
R3475 net@1809#7pmos@81_poly-left##41 net@1809#7pmos@81_poly-left##42 9.871
R3476 net@1809#7pmos@81_poly-left##42 net@1809#7pmos@81_poly-left##43 9.871
R3477 net@1809#7pmos@81_poly-left##43 net@1809#7pmos@81_poly-left##44 9.871
R3478 net@1809#7pmos@81_poly-left##44 net@1809#7pmos@81_poly-left##45 9.871
R3479 net@1809#7pmos@81_poly-left##45 net@1809#7pmos@81_poly-left##46 9.871
R3480 net@1809#7pmos@81_poly-left##46 net@1809#7pmos@81_poly-left##47 9.871
R3481 net@1809#7pmos@81_poly-left##47 net@1809#7pmos@81_poly-left##48 9.871
R3482 net@1809#7pmos@81_poly-left##48 net@1809#7pmos@81_poly-left##49 9.871
R3483 net@1809#7pmos@81_poly-left##49 net@1809#7pmos@81_poly-left##50 9.871
R3484 net@1809#7pmos@81_poly-left##50 net@1809#7pmos@81_poly-left##51 9.871
R3485 net@1809#7pmos@81_poly-left##51 net@1809#7pmos@81_poly-left##52 9.871
R3486 net@1809#7pmos@81_poly-left##52 net@1809#7pmos@81_poly-left##53 9.871
R3487 net@1809#7pmos@81_poly-left##53 net@1809#7pmos@81_poly-left##54 9.871
R3488 net@1809#7pmos@81_poly-left##54 net@1809#7pmos@81_poly-left##55 9.871
R3489 net@1809#7pmos@81_poly-left##55 net@1809#11nmos@81_poly-right 9.871
R3490 B2#18pmos@82_poly-right B2#18pmos@82_poly-right##0 9.871
R3491 B2#18pmos@82_poly-right##0 B2#18pmos@82_poly-right##1 9.871
R3492 B2#18pmos@82_poly-right##1 B2#18pmos@82_poly-right##2 9.871
R3493 B2#18pmos@82_poly-right##2 B2#18pmos@82_poly-right##3 9.871
R3494 B2#18pmos@82_poly-right##3 B2#18pmos@82_poly-right##4 9.871
R3495 B2#18pmos@82_poly-right##4 B2#18pmos@82_poly-right##5 9.871
R3496 B2#18pmos@82_poly-right##5 B2#18pmos@82_poly-right##6 9.871
R3497 B2#18pmos@82_poly-right##6 B2#18pmos@82_poly-right##7 9.871
R3498 B2#18pmos@82_poly-right##7 B2#18pmos@82_poly-right##8 9.871
R3499 B2#18pmos@82_poly-right##8 B2#18pmos@82_poly-right##9 9.871
R3500 B2#18pmos@82_poly-right##9 B2#18pmos@82_poly-right##10 9.871
R3501 B2#18pmos@82_poly-right##10 B2#18pmos@82_poly-right##11 9.871
R3502 B2#18pmos@82_poly-right##11 B2#18pmos@82_poly-right##12 9.871
R3503 B2#18pmos@82_poly-right##12 B2#18pmos@82_poly-right##13 9.871
R3504 B2#18pmos@82_poly-right##13 B2#18pmos@82_poly-right##14 9.871
R3505 B2#18pmos@82_poly-right##14 B2#18pmos@82_poly-right##15 9.871
R3506 B2#18pmos@82_poly-right##15 B2#18pmos@82_poly-right##16 9.871
R3507 B2#18pmos@82_poly-right##16 B2#18pmos@82_poly-right##17 9.871
R3508 B2#18pmos@82_poly-right##17 B2#18pmos@82_poly-right##18 9.871
R3509 B2#18pmos@82_poly-right##18 B2#18pmos@82_poly-right##19 9.871
R3510 B2#18pmos@82_poly-right##19 B2#18pmos@82_poly-right##20 9.871
R3511 B2#18pmos@82_poly-right##20 B2#18pmos@82_poly-right##21 9.871
R3512 B2#18pmos@82_poly-right##21 B2#18pmos@82_poly-right##22 9.871
R3513 B2#18pmos@82_poly-right##22 B2#18pmos@82_poly-right##23 9.871
R3514 B2#18pmos@82_poly-right##23 B2#18pmos@82_poly-right##24 9.871
R3515 B2#18pmos@82_poly-right##24 B2#18pmos@82_poly-right##25 9.871
R3516 B2#18pmos@82_poly-right##25 B2#18pmos@82_poly-right##26 9.871
R3517 B2#18pmos@82_poly-right##26 B2#18pmos@82_poly-right##27 9.871
R3518 B2#18pmos@82_poly-right##27 B2#18pmos@82_poly-right##28 9.871
R3519 B2#18pmos@82_poly-right##28 B2#18pmos@82_poly-right##29 9.871
R3520 B2#18pmos@82_poly-right##29 B2#18pmos@82_poly-right##30 9.871
R3521 B2#18pmos@82_poly-right##30 B2#18pmos@82_poly-right##31 9.871
R3522 B2#18pmos@82_poly-right##31 B2#18pmos@82_poly-right##32 9.871
R3523 B2#18pmos@82_poly-right##32 B2#18pmos@82_poly-right##33 9.871
R3524 B2#18pmos@82_poly-right##33 B2#18pmos@82_poly-right##34 9.871
R3525 B2#18pmos@82_poly-right##34 B2#18pmos@82_poly-right##35 9.871
R3526 B2#18pmos@82_poly-right##35 B2#18pmos@82_poly-right##36 9.871
R3527 B2#18pmos@82_poly-right##36 B2#18pmos@82_poly-right##37 9.871
R3528 B2#18pmos@82_poly-right##37 B2#18pmos@82_poly-right##38 9.871
R3529 B2#18pmos@82_poly-right##38 B2#18pmos@82_poly-right##39 9.871
R3530 B2#18pmos@82_poly-right##39 B2#18pmos@82_poly-right##40 9.871
R3531 B2#18pmos@82_poly-right##40 B2#18pmos@82_poly-right##41 9.871
R3532 B2#18pmos@82_poly-right##41 B2#18pmos@82_poly-right##42 9.871
R3533 B2#18pmos@82_poly-right##42 B2#18pmos@82_poly-right##43 9.871
R3534 B2#18pmos@82_poly-right##43 B2#18pmos@82_poly-right##44 9.871
R3535 B2#18pmos@82_poly-right##44 B2#18pmos@82_poly-right##45 9.871
R3536 B2#18pmos@82_poly-right##45 B2#18pmos@82_poly-right##46 9.871
R3537 B2#18pmos@82_poly-right##46 B2#18pmos@82_poly-right##47 9.871
R3538 B2#18pmos@82_poly-right##47 B2#18pmos@82_poly-right##48 9.871
R3539 B2#18pmos@82_poly-right##48 B2#18pmos@82_poly-right##49 9.871
R3540 B2#18pmos@82_poly-right##49 B2#18pmos@82_poly-right##50 9.871
R3541 B2#18pmos@82_poly-right##50 B2#18pmos@82_poly-right##51 9.871
R3542 B2#18pmos@82_poly-right##51 B2#18pmos@82_poly-right##52 9.871
R3543 B2#18pmos@82_poly-right##52 B2#18pmos@82_poly-right##53 9.871
R3544 B2#18pmos@82_poly-right##53 B2#18pmos@82_poly-right##54 9.871
R3545 B2#18pmos@82_poly-right##54 B2#18pmos@82_poly-right##55 9.871
R3546 B2#18pmos@82_poly-right##55 B2#16nmos@82_poly-left 9.871
R3547 net@1914#14pmos@83_poly-right net@1914#14pmos@83_poly-right##0 9.871
R3548 net@1914#14pmos@83_poly-right##0 net@1914#14pmos@83_poly-right##1 9.871
R3549 net@1914#14pmos@83_poly-right##1 net@1914#14pmos@83_poly-right##2 9.871
R3550 net@1914#14pmos@83_poly-right##2 net@1914#14pmos@83_poly-right##3 9.871
R3551 net@1914#14pmos@83_poly-right##3 net@1914#14pmos@83_poly-right##4 9.871
R3552 net@1914#14pmos@83_poly-right##4 net@1914#14pmos@83_poly-right##5 9.871
R3553 net@1914#14pmos@83_poly-right##5 net@1914#14pmos@83_poly-right##6 9.871
R3554 net@1914#14pmos@83_poly-right##6 net@1914#14pmos@83_poly-right##7 9.871
R3555 net@1914#14pmos@83_poly-right##7 net@1914#14pmos@83_poly-right##8 9.871
R3556 net@1914#14pmos@83_poly-right##8 net@1914#14pmos@83_poly-right##9 9.871
R3557 net@1914#14pmos@83_poly-right##9 net@1914#14pmos@83_poly-right##10 9.871
R3558 net@1914#14pmos@83_poly-right##10 net@1914#14pmos@83_poly-right##11 9.871
R3559 net@1914#14pmos@83_poly-right##11 net@1914#14pmos@83_poly-right##12 9.871
R3560 net@1914#14pmos@83_poly-right##12 net@1914#14pmos@83_poly-right##13 9.871
R3561 net@1914#14pmos@83_poly-right##13 net@1914#14pmos@83_poly-right##14 9.871
R3562 net@1914#14pmos@83_poly-right##14 net@1914#14pmos@83_poly-right##15 9.871
R3563 net@1914#14pmos@83_poly-right##15 net@1914#14pmos@83_poly-right##16 9.871
R3564 net@1914#14pmos@83_poly-right##16 net@1914#14pmos@83_poly-right##17 9.871
R3565 net@1914#14pmos@83_poly-right##17 net@1914#14pmos@83_poly-right##18 9.871
R3566 net@1914#14pmos@83_poly-right##18 net@1914#14pmos@83_poly-right##19 9.871
R3567 net@1914#14pmos@83_poly-right##19 net@1914#14pmos@83_poly-right##20 9.871
R3568 net@1914#14pmos@83_poly-right##20 net@1914#14pmos@83_poly-right##21 9.871
R3569 net@1914#14pmos@83_poly-right##21 net@1914#14pmos@83_poly-right##22 9.871
R3570 net@1914#14pmos@83_poly-right##22 net@1914#14pmos@83_poly-right##23 9.871
R3571 net@1914#14pmos@83_poly-right##23 net@1914#14pmos@83_poly-right##24 9.871
R3572 net@1914#14pmos@83_poly-right##24 net@1914#14pmos@83_poly-right##25 9.871
R3573 net@1914#14pmos@83_poly-right##25 net@1914#14pmos@83_poly-right##26 9.871
R3574 net@1914#14pmos@83_poly-right##26 net@1914#14pmos@83_poly-right##27 9.871
R3575 net@1914#14pmos@83_poly-right##27 net@1914#14pmos@83_poly-right##28 9.871
R3576 net@1914#14pmos@83_poly-right##28 net@1914#14pmos@83_poly-right##29 9.871
R3577 net@1914#14pmos@83_poly-right##29 net@1914#14pmos@83_poly-right##30 9.871
R3578 net@1914#14pmos@83_poly-right##30 net@1914#14pmos@83_poly-right##31 9.871
R3579 net@1914#14pmos@83_poly-right##31 net@1914#14pmos@83_poly-right##32 9.871
R3580 net@1914#14pmos@83_poly-right##32 net@1914#14pmos@83_poly-right##33 9.871
R3581 net@1914#14pmos@83_poly-right##33 net@1914#14pmos@83_poly-right##34 9.871
R3582 net@1914#14pmos@83_poly-right##34 net@1914#14pmos@83_poly-right##35 9.871
R3583 net@1914#14pmos@83_poly-right##35 net@1914#14pmos@83_poly-right##36 9.871
R3584 net@1914#14pmos@83_poly-right##36 net@1914#14pmos@83_poly-right##37 9.871
R3585 net@1914#14pmos@83_poly-right##37 net@1914#14pmos@83_poly-right##38 9.871
R3586 net@1914#14pmos@83_poly-right##38 net@1914#14pmos@83_poly-right##39 9.871
R3587 net@1914#14pmos@83_poly-right##39 net@1914#14pmos@83_poly-right##40 9.871
R3588 net@1914#14pmos@83_poly-right##40 net@1914#14pmos@83_poly-right##41 9.871
R3589 net@1914#14pmos@83_poly-right##41 net@1914#14pmos@83_poly-right##42 9.871
R3590 net@1914#14pmos@83_poly-right##42 net@1914#14pmos@83_poly-right##43 9.871
R3591 net@1914#14pmos@83_poly-right##43 net@1914#14pmos@83_poly-right##44 9.871
R3592 net@1914#14pmos@83_poly-right##44 net@1914#14pmos@83_poly-right##45 9.871
R3593 net@1914#14pmos@83_poly-right##45 net@1914#14pmos@83_poly-right##46 9.871
R3594 net@1914#14pmos@83_poly-right##46 net@1914#14pmos@83_poly-right##47 9.871
R3595 net@1914#14pmos@83_poly-right##47 net@1914#14pmos@83_poly-right##48 9.871
R3596 net@1914#14pmos@83_poly-right##48 net@1914#14pmos@83_poly-right##49 9.871
R3597 net@1914#14pmos@83_poly-right##49 net@1914#14pmos@83_poly-right##50 9.871
R3598 net@1914#14pmos@83_poly-right##50 net@1914#14pmos@83_poly-right##51 9.871
R3599 net@1914#14pmos@83_poly-right##51 net@1914#14pmos@83_poly-right##52 9.871
R3600 net@1914#14pmos@83_poly-right##52 net@1914#14pmos@83_poly-right##53 9.871
R3601 net@1914#14pmos@83_poly-right##53 net@1914#14pmos@83_poly-right##54 9.871
R3602 net@1914#14pmos@83_poly-right##54 net@1914#14pmos@83_poly-right##55 9.871
R3603 net@1914#14pmos@83_poly-right##55 net@1914#9nmos@83_poly-left 9.871
R3604 net@1907#2contact@603_metal-1-polysilicon-1 net@1907 4.706
R3605 net@1907#12pmos@86_poly-right net@1907#12pmos@86_poly-right##0 9.864
R3606 net@1907#12pmos@86_poly-right##0 net@1907#12pmos@86_poly-right##1 9.864
R3607 net@1907#12pmos@86_poly-right##1 net@1907#12pmos@86_poly-right##2 9.864
R3608 net@1907#12pmos@86_poly-right##2 net@1907#12pmos@86_poly-right##3 9.864
R3609 net@1907#12pmos@86_poly-right##3 net@1907#12pmos@86_poly-right##4 9.864
R3610 net@1907#12pmos@86_poly-right##4 net@1907#12pmos@86_poly-right##5 9.864
R3611 net@1907#12pmos@86_poly-right##5 net@1907#12pmos@86_poly-right##6 9.864
R3612 net@1907#12pmos@86_poly-right##6 net@1907#12pmos@86_poly-right##7 9.864
R3613 net@1907#12pmos@86_poly-right##7 net@1907#12pmos@86_poly-right##8 9.864
R3614 net@1907#12pmos@86_poly-right##8 net@1907#12pmos@86_poly-right##9 9.864
R3615 net@1907#12pmos@86_poly-right##9 net@1907#12pmos@86_poly-right##10 9.864
R3616 net@1907#12pmos@86_poly-right##10 net@1907#12pmos@86_poly-right##11 9.864
R3617 net@1907#12pmos@86_poly-right##11 net@1907#12pmos@86_poly-right##12 9.864
R3618 net@1907#12pmos@86_poly-right##12 net@1907#12pmos@86_poly-right##13 9.864
R3619 net@1907#12pmos@86_poly-right##13 net@1907#12pmos@86_poly-right##14 9.864
R3620 net@1907#12pmos@86_poly-right##14 net@1907#12pmos@86_poly-right##15 9.864
R3621 net@1907#12pmos@86_poly-right##15 net@1907#12pmos@86_poly-right##16 9.864
R3622 net@1907#12pmos@86_poly-right##16 net@1907#12pmos@86_poly-right##17 9.864
R3623 net@1907#12pmos@86_poly-right##17 net@1907#12pmos@86_poly-right##18 9.864
R3624 net@1907#12pmos@86_poly-right##18 net@1907#12pmos@86_poly-right##19 9.864
R3625 net@1907#12pmos@86_poly-right##19 net@1907#12pmos@86_poly-right##20 9.864
R3626 net@1907#12pmos@86_poly-right##20 net@1907#12pmos@86_poly-right##21 9.864
R3627 net@1907#12pmos@86_poly-right##21 net@1907#12pmos@86_poly-right##22 9.864
R3628 net@1907#12pmos@86_poly-right##22 net@1907#12pmos@86_poly-right##23 9.864
R3629 net@1907#12pmos@86_poly-right##23 net@1907#12pmos@86_poly-right##24 9.864
R3630 net@1907#12pmos@86_poly-right##24 net@1907#12pmos@86_poly-right##25 9.864
R3631 net@1907#12pmos@86_poly-right##25 net@1907#12pmos@86_poly-right##26 9.864
R3632 net@1907#12pmos@86_poly-right##26 net@1907#12pmos@86_poly-right##27 9.864
R3633 net@1907#12pmos@86_poly-right##27 net@1907#12pmos@86_poly-right##28 9.864
R3634 net@1907#12pmos@86_poly-right##28 net@1907#12pmos@86_poly-right##29 9.864
R3635 net@1907#12pmos@86_poly-right##29 net@1907#12pmos@86_poly-right##30 9.864
R3636 net@1907#12pmos@86_poly-right##30 net@1907#12pmos@86_poly-right##31 9.864
R3637 net@1907#12pmos@86_poly-right##31 net@1907#12pmos@86_poly-right##32 9.864
R3638 net@1907#12pmos@86_poly-right##32 net@1907#12pmos@86_poly-right##33 9.864
R3639 net@1907#12pmos@86_poly-right##33 net@1907#12pmos@86_poly-right##34 9.864
R3640 net@1907#12pmos@86_poly-right##34 net@1907#12pmos@86_poly-right##35 9.864
R3641 net@1907#12pmos@86_poly-right##35 net@1907#12pmos@86_poly-right##36 9.864
R3642 net@1907#12pmos@86_poly-right##36 net@1907#12pmos@86_poly-right##37 9.864
R3643 net@1907#12pmos@86_poly-right##37 net@1907#12pmos@86_poly-right##38 9.864
R3644 net@1907#12pmos@86_poly-right##38 net@1907#12pmos@86_poly-right##39 9.864
R3645 net@1907#12pmos@86_poly-right##39 net@1907#12pmos@86_poly-right##40 9.864
R3646 net@1907#12pmos@86_poly-right##40 net@1907#12pmos@86_poly-right##41 9.864
R3647 net@1907#12pmos@86_poly-right##41 net@1907#12pmos@86_poly-right##42 9.864
R3648 net@1907#12pmos@86_poly-right##42 net@1907#12pmos@86_poly-right##43 9.864
R3649 net@1907#12pmos@86_poly-right##43 net@1907#12pmos@86_poly-right##44 9.864
R3650 net@1907#12pmos@86_poly-right##44 net@1907#12pmos@86_poly-right##45 9.864
R3651 net@1907#12pmos@86_poly-right##45 net@1907#12pmos@86_poly-right##46 9.864
R3652 net@1907#12pmos@86_poly-right##46 net@1907#12pmos@86_poly-right##47 9.864
R3653 net@1907#12pmos@86_poly-right##47 net@1907#12pmos@86_poly-right##48 9.864
R3654 net@1907#12pmos@86_poly-right##48 net@1907#12pmos@86_poly-right##49 9.864
R3655 net@1907#12pmos@86_poly-right##49 net@1907#12pmos@86_poly-right##50 9.864
R3656 net@1907#12pmos@86_poly-right##50 net@1907#12pmos@86_poly-right##51 9.864
R3657 net@1907#12pmos@86_poly-right##51 net@1907#12pmos@86_poly-right##52 9.864
R3658 net@1907#12pmos@86_poly-right##52 net@1907#12pmos@86_poly-right##53 9.864
R3659 net@1907#12pmos@86_poly-right##53 net@1907#5pin@539_polysilicon-1 9.864
R3660 XOR1_to_NAND3#22pmos@86_diff-top XOR1_to_NAND3#1contact@656_metal-1-metal-2 4.862
R3661 XOR1_to_NAND3#3pin@572_polysilicon-1 XOR1_to_NAND3#3pin@572_polysilicon-1##0 9.881
R3662 XOR1_to_NAND3#3pin@572_polysilicon-1##0 XOR1_to_NAND3#3pin@572_polysilicon-1##1 9.881
R3663 XOR1_to_NAND3#3pin@572_polysilicon-1##1 XOR1_to_NAND3#3pin@572_polysilicon-1##2 9.881
R3664 XOR1_to_NAND3#3pin@572_polysilicon-1##2 XOR1_to_NAND3#3pin@572_polysilicon-1##3 9.881
R3665 XOR1_to_NAND3#3pin@572_polysilicon-1##3 XOR1_to_NAND3#3pin@572_polysilicon-1##4 9.881
R3666 XOR1_to_NAND3#3pin@572_polysilicon-1##4 XOR1_to_NAND3#3pin@572_polysilicon-1##5 9.881
R3667 XOR1_to_NAND3#3pin@572_polysilicon-1##5 XOR1_to_NAND3#3pin@572_polysilicon-1##6 9.881
R3668 XOR1_to_NAND3#3pin@572_polysilicon-1##6 XOR1_to_NAND3#3pin@572_polysilicon-1##7 9.881
R3669 XOR1_to_NAND3#3pin@572_polysilicon-1##7 XOR1_to_NAND3#3pin@572_polysilicon-1##8 9.881
R3670 XOR1_to_NAND3#3pin@572_polysilicon-1##8 XOR1_to_NAND3#3pin@572_polysilicon-1##9 9.881
R3671 XOR1_to_NAND3#3pin@572_polysilicon-1##9 XOR1_to_NAND3#3pin@572_polysilicon-1##10 9.881
R3672 XOR1_to_NAND3#3pin@572_polysilicon-1##10 XOR1_to_NAND3#3pin@572_polysilicon-1##11 9.881
R3673 XOR1_to_NAND3#3pin@572_polysilicon-1##11 XOR1_to_NAND3#3pin@572_polysilicon-1##12 9.881
R3674 XOR1_to_NAND3#3pin@572_polysilicon-1##12 XOR1_to_NAND3#3pin@572_polysilicon-1##13 9.881
R3675 XOR1_to_NAND3#3pin@572_polysilicon-1##13 XOR1_to_NAND3#3pin@572_polysilicon-1##14 9.881
R3676 XOR1_to_NAND3#3pin@572_polysilicon-1##14 XOR1_to_NAND3#3pin@572_polysilicon-1##15 9.881
R3677 XOR1_to_NAND3#3pin@572_polysilicon-1##15 XOR1_to_NAND3#3pin@572_polysilicon-1##16 9.881
R3678 XOR1_to_NAND3#3pin@572_polysilicon-1##16 XOR1_to_NAND3#3pin@572_polysilicon-1##17 9.881
R3679 XOR1_to_NAND3#3pin@572_polysilicon-1##17 XOR1_to_NAND3#3pin@572_polysilicon-1##18 9.881
R3680 XOR1_to_NAND3#3pin@572_polysilicon-1##18 XOR1_to_NAND3#3pin@572_polysilicon-1##19 9.881
R3681 XOR1_to_NAND3#3pin@572_polysilicon-1##19 XOR1_to_NAND3#3pin@572_polysilicon-1##20 9.881
R3682 XOR1_to_NAND3#3pin@572_polysilicon-1##20 XOR1_to_NAND3#3pin@572_polysilicon-1##21 9.881
R3683 XOR1_to_NAND3#3pin@572_polysilicon-1##21 XOR1_to_NAND3#3pin@572_polysilicon-1##22 9.881
R3684 XOR1_to_NAND3#3pin@572_polysilicon-1##22 XOR1_to_NAND3#3pin@572_polysilicon-1##23 9.881
R3685 XOR1_to_NAND3#3pin@572_polysilicon-1##23 XOR1_to_NAND3#3pin@572_polysilicon-1##24 9.881
R3686 XOR1_to_NAND3#3pin@572_polysilicon-1##24 XOR1_to_NAND3#3pin@572_polysilicon-1##25 9.881
R3687 XOR1_to_NAND3#3pin@572_polysilicon-1##25 XOR1_to_NAND3#3pin@572_polysilicon-1##26 9.881
R3688 XOR1_to_NAND3#3pin@572_polysilicon-1##26 XOR1_to_NAND3#3pin@572_polysilicon-1##27 9.881
R3689 XOR1_to_NAND3#3pin@572_polysilicon-1##27 XOR1_to_NAND3#3pin@572_polysilicon-1##28 9.881
R3690 XOR1_to_NAND3#3pin@572_polysilicon-1##28 XOR1_to_NAND3#3pin@572_polysilicon-1##29 9.881
R3691 XOR1_to_NAND3#3pin@572_polysilicon-1##29 XOR1_to_NAND3#3pin@572_polysilicon-1##30 9.881
R3692 XOR1_to_NAND3#3pin@572_polysilicon-1##30 XOR1_to_NAND3#3pin@572_polysilicon-1##31 9.881
R3693 XOR1_to_NAND3#3pin@572_polysilicon-1##31 XOR1_to_NAND3#3pin@572_polysilicon-1##32 9.881
R3694 XOR1_to_NAND3#3pin@572_polysilicon-1##32 XOR1_to_NAND3#3pin@572_polysilicon-1##33 9.881
R3695 XOR1_to_NAND3#3pin@572_polysilicon-1##33 XOR1_to_NAND3#3pin@572_polysilicon-1##34 9.881
R3696 XOR1_to_NAND3#3pin@572_polysilicon-1##34 XOR1_to_NAND3#3pin@572_polysilicon-1##35 9.881
R3697 XOR1_to_NAND3#3pin@572_polysilicon-1##35 XOR1_to_NAND3#3pin@572_polysilicon-1##36 9.881
R3698 XOR1_to_NAND3#3pin@572_polysilicon-1##36 XOR1_to_NAND3#3pin@572_polysilicon-1##37 9.881
R3699 XOR1_to_NAND3#3pin@572_polysilicon-1##37 XOR1_to_NAND3#3pin@572_polysilicon-1##38 9.881
R3700 XOR1_to_NAND3#3pin@572_polysilicon-1##38 XOR1_to_NAND3#3pin@572_polysilicon-1##39 9.881
R3701 XOR1_to_NAND3#3pin@572_polysilicon-1##39 XOR1_to_NAND3#3pin@572_polysilicon-1##40 9.881
R3702 XOR1_to_NAND3#3pin@572_polysilicon-1##40 XOR1_to_NAND3#3pin@572_polysilicon-1##41 9.881
R3703 XOR1_to_NAND3#3pin@572_polysilicon-1##41 XOR1_to_NAND3#3pin@572_polysilicon-1##42 9.881
R3704 XOR1_to_NAND3#3pin@572_polysilicon-1##42 XOR1_to_NAND3#3pin@572_polysilicon-1##43 9.881
R3705 XOR1_to_NAND3#3pin@572_polysilicon-1##43 XOR1_to_NAND3#3pin@572_polysilicon-1##44 9.881
R3706 XOR1_to_NAND3#3pin@572_polysilicon-1##44 XOR1_to_NAND3#3pin@572_polysilicon-1##45 9.881
R3707 XOR1_to_NAND3#3pin@572_polysilicon-1##45 XOR1_to_NAND3#3pin@572_polysilicon-1##46 9.881
R3708 XOR1_to_NAND3#3pin@572_polysilicon-1##46 XOR1_to_NAND3#3pin@572_polysilicon-1##47 9.881
R3709 XOR1_to_NAND3#3pin@572_polysilicon-1##47 XOR1_to_NAND3#3pin@572_polysilicon-1##48 9.881
R3710 XOR1_to_NAND3#3pin@572_polysilicon-1##48 XOR1_to_NAND3#3pin@572_polysilicon-1##49 9.881
R3711 XOR1_to_NAND3#3pin@572_polysilicon-1##49 XOR1_to_NAND3#3pin@572_polysilicon-1##50 9.881
R3712 XOR1_to_NAND3#3pin@572_polysilicon-1##50 XOR1_to_NAND3#3pin@572_polysilicon-1##51 9.881
R3713 XOR1_to_NAND3#3pin@572_polysilicon-1##51 XOR1_to_NAND3#3pin@572_polysilicon-1##52 9.881
R3714 XOR1_to_NAND3#3pin@572_polysilicon-1##52 XOR1_to_NAND3#3pin@572_polysilicon-1##53 9.881
R3715 XOR1_to_NAND3#3pin@572_polysilicon-1##53 XOR1_to_NAND3#3pin@572_polysilicon-1##54 9.881
R3716 XOR1_to_NAND3#3pin@572_polysilicon-1##54 XOR1_to_NAND3#24nmos@92_poly-right 9.881
R3717 net@1811#5pmos@92_diff-top net@1811#2pin@561_metal-1 4.81
R3718 net@1811#1pin@571_polysilicon-1 net@1811#1pin@571_polysilicon-1##0 9.85
R3719 net@1811#1pin@571_polysilicon-1##0 net@1811#1pin@571_polysilicon-1##1 9.85
R3720 net@1811#1pin@571_polysilicon-1##1 net@1811#1pin@571_polysilicon-1##2 9.85
R3721 net@1811#1pin@571_polysilicon-1##2 net@1811#1pin@571_polysilicon-1##3 9.85
R3722 net@1811#1pin@571_polysilicon-1##3 net@1811#1pin@571_polysilicon-1##4 9.85
R3723 net@1811#1pin@571_polysilicon-1##4 net@1811#1pin@571_polysilicon-1##5 9.85
R3724 net@1811#1pin@571_polysilicon-1##5 net@1811#1pin@571_polysilicon-1##6 9.85
R3725 net@1811#1pin@571_polysilicon-1##6 net@1811#1pin@571_polysilicon-1##7 9.85
R3726 net@1811#1pin@571_polysilicon-1##7 net@1811#1pin@571_polysilicon-1##8 9.85
R3727 net@1811#1pin@571_polysilicon-1##8 net@1811#1pin@571_polysilicon-1##9 9.85
R3728 net@1811#1pin@571_polysilicon-1##9 net@1811#1pin@571_polysilicon-1##10 9.85
R3729 net@1811#1pin@571_polysilicon-1##10 net@1811#1pin@571_polysilicon-1##11 9.85
R3730 net@1811#1pin@571_polysilicon-1##11 net@1811#1pin@571_polysilicon-1##12 9.85
R3731 net@1811#1pin@571_polysilicon-1##12 net@1811#1pin@571_polysilicon-1##13 9.85
R3732 net@1811#1pin@571_polysilicon-1##13 net@1811#1pin@571_polysilicon-1##14 9.85
R3733 net@1811#1pin@571_polysilicon-1##14 net@1811#1pin@571_polysilicon-1##15 9.85
R3734 net@1811#1pin@571_polysilicon-1##15 net@1811#1pin@571_polysilicon-1##16 9.85
R3735 net@1811#1pin@571_polysilicon-1##16 net@1811#1pin@571_polysilicon-1##17 9.85
R3736 net@1811#1pin@571_polysilicon-1##17 net@1811#1pin@571_polysilicon-1##18 9.85
R3737 net@1811#1pin@571_polysilicon-1##18 net@1811#1pin@571_polysilicon-1##19 9.85
R3738 net@1811#1pin@571_polysilicon-1##19 net@1811#1pin@571_polysilicon-1##20 9.85
R3739 net@1811#1pin@571_polysilicon-1##20 net@1811#1pin@571_polysilicon-1##21 9.85
R3740 net@1811#1pin@571_polysilicon-1##21 net@1811#1pin@571_polysilicon-1##22 9.85
R3741 net@1811#1pin@571_polysilicon-1##22 net@1811#1pin@571_polysilicon-1##23 9.85
R3742 net@1811#1pin@571_polysilicon-1##23 net@1811#1pin@571_polysilicon-1##24 9.85
R3743 net@1811#1pin@571_polysilicon-1##24 net@1811#1pin@571_polysilicon-1##25 9.85
R3744 net@1811#1pin@571_polysilicon-1##25 net@1811#1pin@571_polysilicon-1##26 9.85
R3745 net@1811#1pin@571_polysilicon-1##26 net@1811#1pin@571_polysilicon-1##27 9.85
R3746 net@1811#1pin@571_polysilicon-1##27 net@1811#1pin@571_polysilicon-1##28 9.85
R3747 net@1811#1pin@571_polysilicon-1##28 net@1811#1pin@571_polysilicon-1##29 9.85
R3748 net@1811#1pin@571_polysilicon-1##29 net@1811#1pin@571_polysilicon-1##30 9.85
R3749 net@1811#1pin@571_polysilicon-1##30 net@1811#1pin@571_polysilicon-1##31 9.85
R3750 net@1811#1pin@571_polysilicon-1##31 net@1811#1pin@571_polysilicon-1##32 9.85
R3751 net@1811#1pin@571_polysilicon-1##32 net@1811#1pin@571_polysilicon-1##33 9.85
R3752 net@1811#1pin@571_polysilicon-1##33 net@1811#1pin@571_polysilicon-1##34 9.85
R3753 net@1811#1pin@571_polysilicon-1##34 net@1811#1pin@571_polysilicon-1##35 9.85
R3754 net@1811#1pin@571_polysilicon-1##35 net@1811#1pin@571_polysilicon-1##36 9.85
R3755 net@1811#1pin@571_polysilicon-1##36 net@1811#1pin@571_polysilicon-1##37 9.85
R3756 net@1811#1pin@571_polysilicon-1##37 net@1811#1pin@571_polysilicon-1##38 9.85
R3757 net@1811#1pin@571_polysilicon-1##38 net@1811#1pin@571_polysilicon-1##39 9.85
R3758 net@1811#1pin@571_polysilicon-1##39 net@1811#1pin@571_polysilicon-1##40 9.85
R3759 net@1811#1pin@571_polysilicon-1##40 net@1811#1pin@571_polysilicon-1##41 9.85
R3760 net@1811#1pin@571_polysilicon-1##41 net@1811#1pin@571_polysilicon-1##42 9.85
R3761 net@1811#1pin@571_polysilicon-1##42 net@1811#1pin@571_polysilicon-1##43 9.85
R3762 net@1811#1pin@571_polysilicon-1##43 net@1811#1pin@571_polysilicon-1##44 9.85
R3763 net@1811#1pin@571_polysilicon-1##44 net@1811#1pin@571_polysilicon-1##45 9.85
R3764 net@1811#1pin@571_polysilicon-1##45 net@1811#1pin@571_polysilicon-1##46 9.85
R3765 net@1811#1pin@571_polysilicon-1##46 net@1811#1pin@571_polysilicon-1##47 9.85
R3766 net@1811#1pin@571_polysilicon-1##47 net@1811#1pin@571_polysilicon-1##48 9.85
R3767 net@1811#1pin@571_polysilicon-1##48 net@1811#1pin@571_polysilicon-1##49 9.85
R3768 net@1811#1pin@571_polysilicon-1##49 net@1811#1pin@571_polysilicon-1##50 9.85
R3769 net@1811#1pin@571_polysilicon-1##50 net@1811#1pin@571_polysilicon-1##51 9.85
R3770 net@1811#1pin@571_polysilicon-1##51 net@1811#1pin@571_polysilicon-1##52 9.85
R3771 net@1811#1pin@571_polysilicon-1##52 net@1811#1pin@571_polysilicon-1##53 9.85
R3772 net@1811#1pin@571_polysilicon-1##53 net@1811#1pin@571_polysilicon-1##54 9.85
R3773 net@1811#1pin@571_polysilicon-1##54 net@1811#1pin@571_polysilicon-1##55 9.85
R3774 net@1811#1pin@571_polysilicon-1##55 net@1811#1pin@571_polysilicon-1##56 9.85
R3775 net@1811#1pin@571_polysilicon-1##56 net@1811#1pin@571_polysilicon-1##57 9.85
R3776 net@1811#1pin@571_polysilicon-1##57 net@1811#1pin@571_polysilicon-1##58 9.85
R3777 net@1811#1pin@571_polysilicon-1##58 net@1811#1pin@571_polysilicon-1##59 9.85
R3778 net@1811#1pin@571_polysilicon-1##59 net@1811#1pin@571_polysilicon-1##60 9.85
R3779 net@1811#1pin@571_polysilicon-1##60 net@1811#2pin@561_metal-1 9.85
R3780 Cin_to_XOR2___NAND3#26pmos@91_poly-right Cin_to_XOR2___NAND3#26pmos@91_poly-right##0 9.854
R3781 Cin_to_XOR2___NAND3#26pmos@91_poly-right##0 Cin_to_XOR2___NAND3#26pmos@91_poly-right##1 9.854
R3782 Cin_to_XOR2___NAND3#26pmos@91_poly-right##1 Cin_to_XOR2___NAND3#26pmos@91_poly-right##2 9.854
R3783 Cin_to_XOR2___NAND3#26pmos@91_poly-right##2 Cin_to_XOR2___NAND3#26pmos@91_poly-right##3 9.854
R3784 Cin_to_XOR2___NAND3#26pmos@91_poly-right##3 Cin_to_XOR2___NAND3#26pmos@91_poly-right##4 9.854
R3785 Cin_to_XOR2___NAND3#26pmos@91_poly-right##4 Cin_to_XOR2___NAND3#26pmos@91_poly-right##5 9.854
R3786 Cin_to_XOR2___NAND3#26pmos@91_poly-right##5 Cin_to_XOR2___NAND3#26pmos@91_poly-right##6 9.854
R3787 Cin_to_XOR2___NAND3#26pmos@91_poly-right##6 Cin_to_XOR2___NAND3#26pmos@91_poly-right##7 9.854
R3788 Cin_to_XOR2___NAND3#26pmos@91_poly-right##7 Cin_to_XOR2___NAND3#26pmos@91_poly-right##8 9.854
R3789 Cin_to_XOR2___NAND3#26pmos@91_poly-right##8 Cin_to_XOR2___NAND3#26pmos@91_poly-right##9 9.854
R3790 Cin_to_XOR2___NAND3#26pmos@91_poly-right##9 Cin_to_XOR2___NAND3#26pmos@91_poly-right##10 9.854
R3791 Cin_to_XOR2___NAND3#26pmos@91_poly-right##10 Cin_to_XOR2___NAND3#26pmos@91_poly-right##11 9.854
R3792 Cin_to_XOR2___NAND3#26pmos@91_poly-right##11 Cin_to_XOR2___NAND3#26pmos@91_poly-right##12 9.854
R3793 Cin_to_XOR2___NAND3#26pmos@91_poly-right##12 Cin_to_XOR2___NAND3#26pmos@91_poly-right##13 9.854
R3794 Cin_to_XOR2___NAND3#26pmos@91_poly-right##13 Cin_to_XOR2___NAND3#26pmos@91_poly-right##14 9.854
R3795 Cin_to_XOR2___NAND3#26pmos@91_poly-right##14 Cin_to_XOR2___NAND3#26pmos@91_poly-right##15 9.854
R3796 Cin_to_XOR2___NAND3#26pmos@91_poly-right##15 Cin_to_XOR2___NAND3#26pmos@91_poly-right##16 9.854
R3797 Cin_to_XOR2___NAND3#26pmos@91_poly-right##16 Cin_to_XOR2___NAND3#26pmos@91_poly-right##17 9.854
R3798 Cin_to_XOR2___NAND3#26pmos@91_poly-right##17 Cin_to_XOR2___NAND3#26pmos@91_poly-right##18 9.854
R3799 Cin_to_XOR2___NAND3#26pmos@91_poly-right##18 Cin_to_XOR2___NAND3#26pmos@91_poly-right##19 9.854
R3800 Cin_to_XOR2___NAND3#26pmos@91_poly-right##19 Cin_to_XOR2___NAND3#26pmos@91_poly-right##20 9.854
R3801 Cin_to_XOR2___NAND3#26pmos@91_poly-right##20 Cin_to_XOR2___NAND3#26pmos@91_poly-right##21 9.854
R3802 Cin_to_XOR2___NAND3#26pmos@91_poly-right##21 Cin_to_XOR2___NAND3#26pmos@91_poly-right##22 9.854
R3803 Cin_to_XOR2___NAND3#26pmos@91_poly-right##22 Cin_to_XOR2___NAND3#26pmos@91_poly-right##23 9.854
R3804 Cin_to_XOR2___NAND3#26pmos@91_poly-right##23 Cin_to_XOR2___NAND3#26pmos@91_poly-right##24 9.854
R3805 Cin_to_XOR2___NAND3#26pmos@91_poly-right##24 Cin_to_XOR2___NAND3#26pmos@91_poly-right##25 9.854
R3806 Cin_to_XOR2___NAND3#26pmos@91_poly-right##25 Cin_to_XOR2___NAND3#26pmos@91_poly-right##26 9.854
R3807 Cin_to_XOR2___NAND3#26pmos@91_poly-right##26 Cin_to_XOR2___NAND3#26pmos@91_poly-right##27 9.854
R3808 Cin_to_XOR2___NAND3#26pmos@91_poly-right##27 Cin_to_XOR2___NAND3#26pmos@91_poly-right##28 9.854
R3809 Cin_to_XOR2___NAND3#26pmos@91_poly-right##28 Cin_to_XOR2___NAND3#26pmos@91_poly-right##29 9.854
R3810 Cin_to_XOR2___NAND3#26pmos@91_poly-right##29 Cin_to_XOR2___NAND3#26pmos@91_poly-right##30 9.854
R3811 Cin_to_XOR2___NAND3#26pmos@91_poly-right##30 Cin_to_XOR2___NAND3#26pmos@91_poly-right##31 9.854
R3812 Cin_to_XOR2___NAND3#26pmos@91_poly-right##31 Cin_to_XOR2___NAND3#26pmos@91_poly-right##32 9.854
R3813 Cin_to_XOR2___NAND3#26pmos@91_poly-right##32 Cin_to_XOR2___NAND3#26pmos@91_poly-right##33 9.854
R3814 Cin_to_XOR2___NAND3#26pmos@91_poly-right##33 Cin_to_XOR2___NAND3#26pmos@91_poly-right##34 9.854
R3815 Cin_to_XOR2___NAND3#26pmos@91_poly-right##34 Cin_to_XOR2___NAND3#26pmos@91_poly-right##35 9.854
R3816 Cin_to_XOR2___NAND3#26pmos@91_poly-right##35 Cin_to_XOR2___NAND3#26pmos@91_poly-right##36 9.854
R3817 Cin_to_XOR2___NAND3#26pmos@91_poly-right##36 Cin_to_XOR2___NAND3#26pmos@91_poly-right##37 9.854
R3818 Cin_to_XOR2___NAND3#26pmos@91_poly-right##37 Cin_to_XOR2___NAND3#26pmos@91_poly-right##38 9.854
R3819 Cin_to_XOR2___NAND3#26pmos@91_poly-right##38 Cin_to_XOR2___NAND3#26pmos@91_poly-right##39 9.854
R3820 Cin_to_XOR2___NAND3#26pmos@91_poly-right##39 Cin_to_XOR2___NAND3#26pmos@91_poly-right##40 9.854
R3821 Cin_to_XOR2___NAND3#26pmos@91_poly-right##40 Cin_to_XOR2___NAND3#26pmos@91_poly-right##41 9.854
R3822 Cin_to_XOR2___NAND3#26pmos@91_poly-right##41 Cin_to_XOR2___NAND3#26pmos@91_poly-right##42 9.854
R3823 Cin_to_XOR2___NAND3#26pmos@91_poly-right##42 Cin_to_XOR2___NAND3#26pmos@91_poly-right##43 9.854
R3824 Cin_to_XOR2___NAND3#26pmos@91_poly-right##43 Cin_to_XOR2___NAND3#26pmos@91_poly-right##44 9.854
R3825 Cin_to_XOR2___NAND3#26pmos@91_poly-right##44 Cin_to_XOR2___NAND3#26pmos@91_poly-right##45 9.854
R3826 Cin_to_XOR2___NAND3#26pmos@91_poly-right##45 Cin_to_XOR2___NAND3#26pmos@91_poly-right##46 9.854
R3827 Cin_to_XOR2___NAND3#26pmos@91_poly-right##46 Cin_to_XOR2___NAND3#26pmos@91_poly-right##47 9.854
R3828 Cin_to_XOR2___NAND3#26pmos@91_poly-right##47 Cin_to_XOR2___NAND3#26pmos@91_poly-right##48 9.854
R3829 Cin_to_XOR2___NAND3#26pmos@91_poly-right##48 Cin_to_XOR2___NAND3#26pmos@91_poly-right##49 9.854
R3830 Cin_to_XOR2___NAND3#26pmos@91_poly-right##49 Cin_to_XOR2___NAND3#26pmos@91_poly-right##50 9.854
R3831 Cin_to_XOR2___NAND3#26pmos@91_poly-right##50 Cin_to_XOR2___NAND3#26pmos@91_poly-right##51 9.854
R3832 Cin_to_XOR2___NAND3#26pmos@91_poly-right##51 Cin_to_XOR2___NAND3#26pmos@91_poly-right##52 9.854
R3833 Cin_to_XOR2___NAND3#26pmos@91_poly-right##52 Cin_to_XOR2___NAND3#26pmos@91_poly-right##53 9.854
R3834 Cin_to_XOR2___NAND3#26pmos@91_poly-right##53 Cin_to_XOR2___NAND3#26pmos@91_poly-right##54 9.854
R3835 Cin_to_XOR2___NAND3#26pmos@91_poly-right##54 Cin_to_XOR2___NAND3#15pin@562_polysilicon-1 9.854
R3836 net@1821 net@1821#2contact@617_metal-1-metal-2 4.797
R3837 XOR1_to_NAND3#9pmos@87_poly-left XOR1_to_NAND3#9pmos@87_poly-left##0 9.871
R3838 XOR1_to_NAND3#9pmos@87_poly-left##0 XOR1_to_NAND3#9pmos@87_poly-left##1 9.871
R3839 XOR1_to_NAND3#9pmos@87_poly-left##1 XOR1_to_NAND3#9pmos@87_poly-left##2 9.871
R3840 XOR1_to_NAND3#9pmos@87_poly-left##2 XOR1_to_NAND3#9pmos@87_poly-left##3 9.871
R3841 XOR1_to_NAND3#9pmos@87_poly-left##3 XOR1_to_NAND3#9pmos@87_poly-left##4 9.871
R3842 XOR1_to_NAND3#9pmos@87_poly-left##4 XOR1_to_NAND3#9pmos@87_poly-left##5 9.871
R3843 XOR1_to_NAND3#9pmos@87_poly-left##5 XOR1_to_NAND3#9pmos@87_poly-left##6 9.871
R3844 XOR1_to_NAND3#9pmos@87_poly-left##6 XOR1_to_NAND3#9pmos@87_poly-left##7 9.871
R3845 XOR1_to_NAND3#9pmos@87_poly-left##7 XOR1_to_NAND3#9pmos@87_poly-left##8 9.871
R3846 XOR1_to_NAND3#9pmos@87_poly-left##8 XOR1_to_NAND3#9pmos@87_poly-left##9 9.871
R3847 XOR1_to_NAND3#9pmos@87_poly-left##9 XOR1_to_NAND3#9pmos@87_poly-left##10 9.871
R3848 XOR1_to_NAND3#9pmos@87_poly-left##10 XOR1_to_NAND3#9pmos@87_poly-left##11 9.871
R3849 XOR1_to_NAND3#9pmos@87_poly-left##11 XOR1_to_NAND3#9pmos@87_poly-left##12 9.871
R3850 XOR1_to_NAND3#9pmos@87_poly-left##12 XOR1_to_NAND3#9pmos@87_poly-left##13 9.871
R3851 XOR1_to_NAND3#9pmos@87_poly-left##13 XOR1_to_NAND3#9pmos@87_poly-left##14 9.871
R3852 XOR1_to_NAND3#9pmos@87_poly-left##14 XOR1_to_NAND3#9pmos@87_poly-left##15 9.871
R3853 XOR1_to_NAND3#9pmos@87_poly-left##15 XOR1_to_NAND3#9pmos@87_poly-left##16 9.871
R3854 XOR1_to_NAND3#9pmos@87_poly-left##16 XOR1_to_NAND3#9pmos@87_poly-left##17 9.871
R3855 XOR1_to_NAND3#9pmos@87_poly-left##17 XOR1_to_NAND3#9pmos@87_poly-left##18 9.871
R3856 XOR1_to_NAND3#9pmos@87_poly-left##18 XOR1_to_NAND3#9pmos@87_poly-left##19 9.871
R3857 XOR1_to_NAND3#9pmos@87_poly-left##19 XOR1_to_NAND3#9pmos@87_poly-left##20 9.871
R3858 XOR1_to_NAND3#9pmos@87_poly-left##20 XOR1_to_NAND3#9pmos@87_poly-left##21 9.871
R3859 XOR1_to_NAND3#9pmos@87_poly-left##21 XOR1_to_NAND3#9pmos@87_poly-left##22 9.871
R3860 XOR1_to_NAND3#9pmos@87_poly-left##22 XOR1_to_NAND3#9pmos@87_poly-left##23 9.871
R3861 XOR1_to_NAND3#9pmos@87_poly-left##23 XOR1_to_NAND3#9pmos@87_poly-left##24 9.871
R3862 XOR1_to_NAND3#9pmos@87_poly-left##24 XOR1_to_NAND3#9pmos@87_poly-left##25 9.871
R3863 XOR1_to_NAND3#9pmos@87_poly-left##25 XOR1_to_NAND3#9pmos@87_poly-left##26 9.871
R3864 XOR1_to_NAND3#9pmos@87_poly-left##26 XOR1_to_NAND3#9pmos@87_poly-left##27 9.871
R3865 XOR1_to_NAND3#9pmos@87_poly-left##27 XOR1_to_NAND3#9pmos@87_poly-left##28 9.871
R3866 XOR1_to_NAND3#9pmos@87_poly-left##28 XOR1_to_NAND3#9pmos@87_poly-left##29 9.871
R3867 XOR1_to_NAND3#9pmos@87_poly-left##29 XOR1_to_NAND3#9pmos@87_poly-left##30 9.871
R3868 XOR1_to_NAND3#9pmos@87_poly-left##30 XOR1_to_NAND3#9pmos@87_poly-left##31 9.871
R3869 XOR1_to_NAND3#9pmos@87_poly-left##31 XOR1_to_NAND3#9pmos@87_poly-left##32 9.871
R3870 XOR1_to_NAND3#9pmos@87_poly-left##32 XOR1_to_NAND3#9pmos@87_poly-left##33 9.871
R3871 XOR1_to_NAND3#9pmos@87_poly-left##33 XOR1_to_NAND3#9pmos@87_poly-left##34 9.871
R3872 XOR1_to_NAND3#9pmos@87_poly-left##34 XOR1_to_NAND3#9pmos@87_poly-left##35 9.871
R3873 XOR1_to_NAND3#9pmos@87_poly-left##35 XOR1_to_NAND3#9pmos@87_poly-left##36 9.871
R3874 XOR1_to_NAND3#9pmos@87_poly-left##36 XOR1_to_NAND3#9pmos@87_poly-left##37 9.871
R3875 XOR1_to_NAND3#9pmos@87_poly-left##37 XOR1_to_NAND3#9pmos@87_poly-left##38 9.871
R3876 XOR1_to_NAND3#9pmos@87_poly-left##38 XOR1_to_NAND3#9pmos@87_poly-left##39 9.871
R3877 XOR1_to_NAND3#9pmos@87_poly-left##39 XOR1_to_NAND3#9pmos@87_poly-left##40 9.871
R3878 XOR1_to_NAND3#9pmos@87_poly-left##40 XOR1_to_NAND3#9pmos@87_poly-left##41 9.871
R3879 XOR1_to_NAND3#9pmos@87_poly-left##41 XOR1_to_NAND3#9pmos@87_poly-left##42 9.871
R3880 XOR1_to_NAND3#9pmos@87_poly-left##42 XOR1_to_NAND3#9pmos@87_poly-left##43 9.871
R3881 XOR1_to_NAND3#9pmos@87_poly-left##43 XOR1_to_NAND3#9pmos@87_poly-left##44 9.871
R3882 XOR1_to_NAND3#9pmos@87_poly-left##44 XOR1_to_NAND3#9pmos@87_poly-left##45 9.871
R3883 XOR1_to_NAND3#9pmos@87_poly-left##45 XOR1_to_NAND3#9pmos@87_poly-left##46 9.871
R3884 XOR1_to_NAND3#9pmos@87_poly-left##46 XOR1_to_NAND3#9pmos@87_poly-left##47 9.871
R3885 XOR1_to_NAND3#9pmos@87_poly-left##47 XOR1_to_NAND3#9pmos@87_poly-left##48 9.871
R3886 XOR1_to_NAND3#9pmos@87_poly-left##48 XOR1_to_NAND3#9pmos@87_poly-left##49 9.871
R3887 XOR1_to_NAND3#9pmos@87_poly-left##49 XOR1_to_NAND3#9pmos@87_poly-left##50 9.871
R3888 XOR1_to_NAND3#9pmos@87_poly-left##50 XOR1_to_NAND3#9pmos@87_poly-left##51 9.871
R3889 XOR1_to_NAND3#9pmos@87_poly-left##51 XOR1_to_NAND3#9pmos@87_poly-left##52 9.871
R3890 XOR1_to_NAND3#9pmos@87_poly-left##52 XOR1_to_NAND3#9pmos@87_poly-left##53 9.871
R3891 XOR1_to_NAND3#9pmos@87_poly-left##53 XOR1_to_NAND3#9pmos@87_poly-left##54 9.871
R3892 XOR1_to_NAND3#9pmos@87_poly-left##54 XOR1_to_NAND3#9pmos@87_poly-left##55 9.871
R3893 XOR1_to_NAND3#9pmos@87_poly-left##55 XOR1_to_NAND3#26nmos@87_poly-right 9.871
R3894 net@1811#7pmos@88_poly-left net@1811#7pmos@88_poly-left##0 9.871
R3895 net@1811#7pmos@88_poly-left##0 net@1811#7pmos@88_poly-left##1 9.871
R3896 net@1811#7pmos@88_poly-left##1 net@1811#7pmos@88_poly-left##2 9.871
R3897 net@1811#7pmos@88_poly-left##2 net@1811#7pmos@88_poly-left##3 9.871
R3898 net@1811#7pmos@88_poly-left##3 net@1811#7pmos@88_poly-left##4 9.871
R3899 net@1811#7pmos@88_poly-left##4 net@1811#7pmos@88_poly-left##5 9.871
R3900 net@1811#7pmos@88_poly-left##5 net@1811#7pmos@88_poly-left##6 9.871
R3901 net@1811#7pmos@88_poly-left##6 net@1811#7pmos@88_poly-left##7 9.871
R3902 net@1811#7pmos@88_poly-left##7 net@1811#7pmos@88_poly-left##8 9.871
R3903 net@1811#7pmos@88_poly-left##8 net@1811#7pmos@88_poly-left##9 9.871
R3904 net@1811#7pmos@88_poly-left##9 net@1811#7pmos@88_poly-left##10 9.871
R3905 net@1811#7pmos@88_poly-left##10 net@1811#7pmos@88_poly-left##11 9.871
R3906 net@1811#7pmos@88_poly-left##11 net@1811#7pmos@88_poly-left##12 9.871
R3907 net@1811#7pmos@88_poly-left##12 net@1811#7pmos@88_poly-left##13 9.871
R3908 net@1811#7pmos@88_poly-left##13 net@1811#7pmos@88_poly-left##14 9.871
R3909 net@1811#7pmos@88_poly-left##14 net@1811#7pmos@88_poly-left##15 9.871
R3910 net@1811#7pmos@88_poly-left##15 net@1811#7pmos@88_poly-left##16 9.871
R3911 net@1811#7pmos@88_poly-left##16 net@1811#7pmos@88_poly-left##17 9.871
R3912 net@1811#7pmos@88_poly-left##17 net@1811#7pmos@88_poly-left##18 9.871
R3913 net@1811#7pmos@88_poly-left##18 net@1811#7pmos@88_poly-left##19 9.871
R3914 net@1811#7pmos@88_poly-left##19 net@1811#7pmos@88_poly-left##20 9.871
R3915 net@1811#7pmos@88_poly-left##20 net@1811#7pmos@88_poly-left##21 9.871
R3916 net@1811#7pmos@88_poly-left##21 net@1811#7pmos@88_poly-left##22 9.871
R3917 net@1811#7pmos@88_poly-left##22 net@1811#7pmos@88_poly-left##23 9.871
R3918 net@1811#7pmos@88_poly-left##23 net@1811#7pmos@88_poly-left##24 9.871
R3919 net@1811#7pmos@88_poly-left##24 net@1811#7pmos@88_poly-left##25 9.871
R3920 net@1811#7pmos@88_poly-left##25 net@1811#7pmos@88_poly-left##26 9.871
R3921 net@1811#7pmos@88_poly-left##26 net@1811#7pmos@88_poly-left##27 9.871
R3922 net@1811#7pmos@88_poly-left##27 net@1811#7pmos@88_poly-left##28 9.871
R3923 net@1811#7pmos@88_poly-left##28 net@1811#7pmos@88_poly-left##29 9.871
R3924 net@1811#7pmos@88_poly-left##29 net@1811#7pmos@88_poly-left##30 9.871
R3925 net@1811#7pmos@88_poly-left##30 net@1811#7pmos@88_poly-left##31 9.871
R3926 net@1811#7pmos@88_poly-left##31 net@1811#7pmos@88_poly-left##32 9.871
R3927 net@1811#7pmos@88_poly-left##32 net@1811#7pmos@88_poly-left##33 9.871
R3928 net@1811#7pmos@88_poly-left##33 net@1811#7pmos@88_poly-left##34 9.871
R3929 net@1811#7pmos@88_poly-left##34 net@1811#7pmos@88_poly-left##35 9.871
R3930 net@1811#7pmos@88_poly-left##35 net@1811#7pmos@88_poly-left##36 9.871
R3931 net@1811#7pmos@88_poly-left##36 net@1811#7pmos@88_poly-left##37 9.871
R3932 net@1811#7pmos@88_poly-left##37 net@1811#7pmos@88_poly-left##38 9.871
R3933 net@1811#7pmos@88_poly-left##38 net@1811#7pmos@88_poly-left##39 9.871
R3934 net@1811#7pmos@88_poly-left##39 net@1811#7pmos@88_poly-left##40 9.871
R3935 net@1811#7pmos@88_poly-left##40 net@1811#7pmos@88_poly-left##41 9.871
R3936 net@1811#7pmos@88_poly-left##41 net@1811#7pmos@88_poly-left##42 9.871
R3937 net@1811#7pmos@88_poly-left##42 net@1811#7pmos@88_poly-left##43 9.871
R3938 net@1811#7pmos@88_poly-left##43 net@1811#7pmos@88_poly-left##44 9.871
R3939 net@1811#7pmos@88_poly-left##44 net@1811#7pmos@88_poly-left##45 9.871
R3940 net@1811#7pmos@88_poly-left##45 net@1811#7pmos@88_poly-left##46 9.871
R3941 net@1811#7pmos@88_poly-left##46 net@1811#7pmos@88_poly-left##47 9.871
R3942 net@1811#7pmos@88_poly-left##47 net@1811#7pmos@88_poly-left##48 9.871
R3943 net@1811#7pmos@88_poly-left##48 net@1811#7pmos@88_poly-left##49 9.871
R3944 net@1811#7pmos@88_poly-left##49 net@1811#7pmos@88_poly-left##50 9.871
R3945 net@1811#7pmos@88_poly-left##50 net@1811#7pmos@88_poly-left##51 9.871
R3946 net@1811#7pmos@88_poly-left##51 net@1811#7pmos@88_poly-left##52 9.871
R3947 net@1811#7pmos@88_poly-left##52 net@1811#7pmos@88_poly-left##53 9.871
R3948 net@1811#7pmos@88_poly-left##53 net@1811#7pmos@88_poly-left##54 9.871
R3949 net@1811#7pmos@88_poly-left##54 net@1811#7pmos@88_poly-left##55 9.871
R3950 net@1811#7pmos@88_poly-left##55 net@1811#11nmos@88_poly-right 9.871
R3951 Cin_to_XOR2___NAND3#27pmos@89_poly-right Cin_to_XOR2___NAND3#27pmos@89_poly-right##0 9.871
R3952 Cin_to_XOR2___NAND3#27pmos@89_poly-right##0 Cin_to_XOR2___NAND3#27pmos@89_poly-right##1 9.871
R3953 Cin_to_XOR2___NAND3#27pmos@89_poly-right##1 Cin_to_XOR2___NAND3#27pmos@89_poly-right##2 9.871
R3954 Cin_to_XOR2___NAND3#27pmos@89_poly-right##2 Cin_to_XOR2___NAND3#27pmos@89_poly-right##3 9.871
R3955 Cin_to_XOR2___NAND3#27pmos@89_poly-right##3 Cin_to_XOR2___NAND3#27pmos@89_poly-right##4 9.871
R3956 Cin_to_XOR2___NAND3#27pmos@89_poly-right##4 Cin_to_XOR2___NAND3#27pmos@89_poly-right##5 9.871
R3957 Cin_to_XOR2___NAND3#27pmos@89_poly-right##5 Cin_to_XOR2___NAND3#27pmos@89_poly-right##6 9.871
R3958 Cin_to_XOR2___NAND3#27pmos@89_poly-right##6 Cin_to_XOR2___NAND3#27pmos@89_poly-right##7 9.871
R3959 Cin_to_XOR2___NAND3#27pmos@89_poly-right##7 Cin_to_XOR2___NAND3#27pmos@89_poly-right##8 9.871
R3960 Cin_to_XOR2___NAND3#27pmos@89_poly-right##8 Cin_to_XOR2___NAND3#27pmos@89_poly-right##9 9.871
R3961 Cin_to_XOR2___NAND3#27pmos@89_poly-right##9 Cin_to_XOR2___NAND3#27pmos@89_poly-right##10 9.871
R3962 Cin_to_XOR2___NAND3#27pmos@89_poly-right##10 Cin_to_XOR2___NAND3#27pmos@89_poly-right##11 9.871
R3963 Cin_to_XOR2___NAND3#27pmos@89_poly-right##11 Cin_to_XOR2___NAND3#27pmos@89_poly-right##12 9.871
R3964 Cin_to_XOR2___NAND3#27pmos@89_poly-right##12 Cin_to_XOR2___NAND3#27pmos@89_poly-right##13 9.871
R3965 Cin_to_XOR2___NAND3#27pmos@89_poly-right##13 Cin_to_XOR2___NAND3#27pmos@89_poly-right##14 9.871
R3966 Cin_to_XOR2___NAND3#27pmos@89_poly-right##14 Cin_to_XOR2___NAND3#27pmos@89_poly-right##15 9.871
R3967 Cin_to_XOR2___NAND3#27pmos@89_poly-right##15 Cin_to_XOR2___NAND3#27pmos@89_poly-right##16 9.871
R3968 Cin_to_XOR2___NAND3#27pmos@89_poly-right##16 Cin_to_XOR2___NAND3#27pmos@89_poly-right##17 9.871
R3969 Cin_to_XOR2___NAND3#27pmos@89_poly-right##17 Cin_to_XOR2___NAND3#27pmos@89_poly-right##18 9.871
R3970 Cin_to_XOR2___NAND3#27pmos@89_poly-right##18 Cin_to_XOR2___NAND3#27pmos@89_poly-right##19 9.871
R3971 Cin_to_XOR2___NAND3#27pmos@89_poly-right##19 Cin_to_XOR2___NAND3#27pmos@89_poly-right##20 9.871
R3972 Cin_to_XOR2___NAND3#27pmos@89_poly-right##20 Cin_to_XOR2___NAND3#27pmos@89_poly-right##21 9.871
R3973 Cin_to_XOR2___NAND3#27pmos@89_poly-right##21 Cin_to_XOR2___NAND3#27pmos@89_poly-right##22 9.871
R3974 Cin_to_XOR2___NAND3#27pmos@89_poly-right##22 Cin_to_XOR2___NAND3#27pmos@89_poly-right##23 9.871
R3975 Cin_to_XOR2___NAND3#27pmos@89_poly-right##23 Cin_to_XOR2___NAND3#27pmos@89_poly-right##24 9.871
R3976 Cin_to_XOR2___NAND3#27pmos@89_poly-right##24 Cin_to_XOR2___NAND3#27pmos@89_poly-right##25 9.871
R3977 Cin_to_XOR2___NAND3#27pmos@89_poly-right##25 Cin_to_XOR2___NAND3#27pmos@89_poly-right##26 9.871
R3978 Cin_to_XOR2___NAND3#27pmos@89_poly-right##26 Cin_to_XOR2___NAND3#27pmos@89_poly-right##27 9.871
R3979 Cin_to_XOR2___NAND3#27pmos@89_poly-right##27 Cin_to_XOR2___NAND3#27pmos@89_poly-right##28 9.871
R3980 Cin_to_XOR2___NAND3#27pmos@89_poly-right##28 Cin_to_XOR2___NAND3#27pmos@89_poly-right##29 9.871
R3981 Cin_to_XOR2___NAND3#27pmos@89_poly-right##29 Cin_to_XOR2___NAND3#27pmos@89_poly-right##30 9.871
R3982 Cin_to_XOR2___NAND3#27pmos@89_poly-right##30 Cin_to_XOR2___NAND3#27pmos@89_poly-right##31 9.871
R3983 Cin_to_XOR2___NAND3#27pmos@89_poly-right##31 Cin_to_XOR2___NAND3#27pmos@89_poly-right##32 9.871
R3984 Cin_to_XOR2___NAND3#27pmos@89_poly-right##32 Cin_to_XOR2___NAND3#27pmos@89_poly-right##33 9.871
R3985 Cin_to_XOR2___NAND3#27pmos@89_poly-right##33 Cin_to_XOR2___NAND3#27pmos@89_poly-right##34 9.871
R3986 Cin_to_XOR2___NAND3#27pmos@89_poly-right##34 Cin_to_XOR2___NAND3#27pmos@89_poly-right##35 9.871
R3987 Cin_to_XOR2___NAND3#27pmos@89_poly-right##35 Cin_to_XOR2___NAND3#27pmos@89_poly-right##36 9.871
R3988 Cin_to_XOR2___NAND3#27pmos@89_poly-right##36 Cin_to_XOR2___NAND3#27pmos@89_poly-right##37 9.871
R3989 Cin_to_XOR2___NAND3#27pmos@89_poly-right##37 Cin_to_XOR2___NAND3#27pmos@89_poly-right##38 9.871
R3990 Cin_to_XOR2___NAND3#27pmos@89_poly-right##38 Cin_to_XOR2___NAND3#27pmos@89_poly-right##39 9.871
R3991 Cin_to_XOR2___NAND3#27pmos@89_poly-right##39 Cin_to_XOR2___NAND3#27pmos@89_poly-right##40 9.871
R3992 Cin_to_XOR2___NAND3#27pmos@89_poly-right##40 Cin_to_XOR2___NAND3#27pmos@89_poly-right##41 9.871
R3993 Cin_to_XOR2___NAND3#27pmos@89_poly-right##41 Cin_to_XOR2___NAND3#27pmos@89_poly-right##42 9.871
R3994 Cin_to_XOR2___NAND3#27pmos@89_poly-right##42 Cin_to_XOR2___NAND3#27pmos@89_poly-right##43 9.871
R3995 Cin_to_XOR2___NAND3#27pmos@89_poly-right##43 Cin_to_XOR2___NAND3#27pmos@89_poly-right##44 9.871
R3996 Cin_to_XOR2___NAND3#27pmos@89_poly-right##44 Cin_to_XOR2___NAND3#27pmos@89_poly-right##45 9.871
R3997 Cin_to_XOR2___NAND3#27pmos@89_poly-right##45 Cin_to_XOR2___NAND3#27pmos@89_poly-right##46 9.871
R3998 Cin_to_XOR2___NAND3#27pmos@89_poly-right##46 Cin_to_XOR2___NAND3#27pmos@89_poly-right##47 9.871
R3999 Cin_to_XOR2___NAND3#27pmos@89_poly-right##47 Cin_to_XOR2___NAND3#27pmos@89_poly-right##48 9.871
R4000 Cin_to_XOR2___NAND3#27pmos@89_poly-right##48 Cin_to_XOR2___NAND3#27pmos@89_poly-right##49 9.871
R4001 Cin_to_XOR2___NAND3#27pmos@89_poly-right##49 Cin_to_XOR2___NAND3#27pmos@89_poly-right##50 9.871
R4002 Cin_to_XOR2___NAND3#27pmos@89_poly-right##50 Cin_to_XOR2___NAND3#27pmos@89_poly-right##51 9.871
R4003 Cin_to_XOR2___NAND3#27pmos@89_poly-right##51 Cin_to_XOR2___NAND3#27pmos@89_poly-right##52 9.871
R4004 Cin_to_XOR2___NAND3#27pmos@89_poly-right##52 Cin_to_XOR2___NAND3#27pmos@89_poly-right##53 9.871
R4005 Cin_to_XOR2___NAND3#27pmos@89_poly-right##53 Cin_to_XOR2___NAND3#27pmos@89_poly-right##54 9.871
R4006 Cin_to_XOR2___NAND3#27pmos@89_poly-right##54 Cin_to_XOR2___NAND3#27pmos@89_poly-right##55 9.871
R4007 Cin_to_XOR2___NAND3#27pmos@89_poly-right##55 Cin_to_XOR2___NAND3#18nmos@89_poly-left 9.871
R4008 net@1821#14pmos@90_poly-right net@1821#14pmos@90_poly-right##0 9.871
R4009 net@1821#14pmos@90_poly-right##0 net@1821#14pmos@90_poly-right##1 9.871
R4010 net@1821#14pmos@90_poly-right##1 net@1821#14pmos@90_poly-right##2 9.871
R4011 net@1821#14pmos@90_poly-right##2 net@1821#14pmos@90_poly-right##3 9.871
R4012 net@1821#14pmos@90_poly-right##3 net@1821#14pmos@90_poly-right##4 9.871
R4013 net@1821#14pmos@90_poly-right##4 net@1821#14pmos@90_poly-right##5 9.871
R4014 net@1821#14pmos@90_poly-right##5 net@1821#14pmos@90_poly-right##6 9.871
R4015 net@1821#14pmos@90_poly-right##6 net@1821#14pmos@90_poly-right##7 9.871
R4016 net@1821#14pmos@90_poly-right##7 net@1821#14pmos@90_poly-right##8 9.871
R4017 net@1821#14pmos@90_poly-right##8 net@1821#14pmos@90_poly-right##9 9.871
R4018 net@1821#14pmos@90_poly-right##9 net@1821#14pmos@90_poly-right##10 9.871
R4019 net@1821#14pmos@90_poly-right##10 net@1821#14pmos@90_poly-right##11 9.871
R4020 net@1821#14pmos@90_poly-right##11 net@1821#14pmos@90_poly-right##12 9.871
R4021 net@1821#14pmos@90_poly-right##12 net@1821#14pmos@90_poly-right##13 9.871
R4022 net@1821#14pmos@90_poly-right##13 net@1821#14pmos@90_poly-right##14 9.871
R4023 net@1821#14pmos@90_poly-right##14 net@1821#14pmos@90_poly-right##15 9.871
R4024 net@1821#14pmos@90_poly-right##15 net@1821#14pmos@90_poly-right##16 9.871
R4025 net@1821#14pmos@90_poly-right##16 net@1821#14pmos@90_poly-right##17 9.871
R4026 net@1821#14pmos@90_poly-right##17 net@1821#14pmos@90_poly-right##18 9.871
R4027 net@1821#14pmos@90_poly-right##18 net@1821#14pmos@90_poly-right##19 9.871
R4028 net@1821#14pmos@90_poly-right##19 net@1821#14pmos@90_poly-right##20 9.871
R4029 net@1821#14pmos@90_poly-right##20 net@1821#14pmos@90_poly-right##21 9.871
R4030 net@1821#14pmos@90_poly-right##21 net@1821#14pmos@90_poly-right##22 9.871
R4031 net@1821#14pmos@90_poly-right##22 net@1821#14pmos@90_poly-right##23 9.871
R4032 net@1821#14pmos@90_poly-right##23 net@1821#14pmos@90_poly-right##24 9.871
R4033 net@1821#14pmos@90_poly-right##24 net@1821#14pmos@90_poly-right##25 9.871
R4034 net@1821#14pmos@90_poly-right##25 net@1821#14pmos@90_poly-right##26 9.871
R4035 net@1821#14pmos@90_poly-right##26 net@1821#14pmos@90_poly-right##27 9.871
R4036 net@1821#14pmos@90_poly-right##27 net@1821#14pmos@90_poly-right##28 9.871
R4037 net@1821#14pmos@90_poly-right##28 net@1821#14pmos@90_poly-right##29 9.871
R4038 net@1821#14pmos@90_poly-right##29 net@1821#14pmos@90_poly-right##30 9.871
R4039 net@1821#14pmos@90_poly-right##30 net@1821#14pmos@90_poly-right##31 9.871
R4040 net@1821#14pmos@90_poly-right##31 net@1821#14pmos@90_poly-right##32 9.871
R4041 net@1821#14pmos@90_poly-right##32 net@1821#14pmos@90_poly-right##33 9.871
R4042 net@1821#14pmos@90_poly-right##33 net@1821#14pmos@90_poly-right##34 9.871
R4043 net@1821#14pmos@90_poly-right##34 net@1821#14pmos@90_poly-right##35 9.871
R4044 net@1821#14pmos@90_poly-right##35 net@1821#14pmos@90_poly-right##36 9.871
R4045 net@1821#14pmos@90_poly-right##36 net@1821#14pmos@90_poly-right##37 9.871
R4046 net@1821#14pmos@90_poly-right##37 net@1821#14pmos@90_poly-right##38 9.871
R4047 net@1821#14pmos@90_poly-right##38 net@1821#14pmos@90_poly-right##39 9.871
R4048 net@1821#14pmos@90_poly-right##39 net@1821#14pmos@90_poly-right##40 9.871
R4049 net@1821#14pmos@90_poly-right##40 net@1821#14pmos@90_poly-right##41 9.871
R4050 net@1821#14pmos@90_poly-right##41 net@1821#14pmos@90_poly-right##42 9.871
R4051 net@1821#14pmos@90_poly-right##42 net@1821#14pmos@90_poly-right##43 9.871
R4052 net@1821#14pmos@90_poly-right##43 net@1821#14pmos@90_poly-right##44 9.871
R4053 net@1821#14pmos@90_poly-right##44 net@1821#14pmos@90_poly-right##45 9.871
R4054 net@1821#14pmos@90_poly-right##45 net@1821#14pmos@90_poly-right##46 9.871
R4055 net@1821#14pmos@90_poly-right##46 net@1821#14pmos@90_poly-right##47 9.871
R4056 net@1821#14pmos@90_poly-right##47 net@1821#14pmos@90_poly-right##48 9.871
R4057 net@1821#14pmos@90_poly-right##48 net@1821#14pmos@90_poly-right##49 9.871
R4058 net@1821#14pmos@90_poly-right##49 net@1821#14pmos@90_poly-right##50 9.871
R4059 net@1821#14pmos@90_poly-right##50 net@1821#14pmos@90_poly-right##51 9.871
R4060 net@1821#14pmos@90_poly-right##51 net@1821#14pmos@90_poly-right##52 9.871
R4061 net@1821#14pmos@90_poly-right##52 net@1821#14pmos@90_poly-right##53 9.871
R4062 net@1821#14pmos@90_poly-right##53 net@1821#14pmos@90_poly-right##54 9.871
R4063 net@1821#14pmos@90_poly-right##54 net@1821#14pmos@90_poly-right##55 9.871
R4064 net@1821#14pmos@90_poly-right##55 net@1821#9nmos@90_poly-left 9.871
R4065 net@1820#2contact@642_metal-1-polysilicon-1 net@1820 4.654
R4066 net@1820#12pmos@93_poly-right net@1820#12pmos@93_poly-right##0 9.931
R4067 net@1820#12pmos@93_poly-right##0 net@1820#12pmos@93_poly-right##1 9.931
R4068 net@1820#12pmos@93_poly-right##1 net@1820#12pmos@93_poly-right##2 9.931
R4069 net@1820#12pmos@93_poly-right##2 net@1820#12pmos@93_poly-right##3 9.931
R4070 net@1820#12pmos@93_poly-right##3 net@1820#12pmos@93_poly-right##4 9.931
R4071 net@1820#12pmos@93_poly-right##4 net@1820#12pmos@93_poly-right##5 9.931
R4072 net@1820#12pmos@93_poly-right##5 net@1820#12pmos@93_poly-right##6 9.931
R4073 net@1820#12pmos@93_poly-right##6 net@1820#12pmos@93_poly-right##7 9.931
R4074 net@1820#12pmos@93_poly-right##7 net@1820#12pmos@93_poly-right##8 9.931
R4075 net@1820#12pmos@93_poly-right##8 net@1820#12pmos@93_poly-right##9 9.931
R4076 net@1820#12pmos@93_poly-right##9 net@1820#12pmos@93_poly-right##10 9.931
R4077 net@1820#12pmos@93_poly-right##10 net@1820#12pmos@93_poly-right##11 9.931
R4078 net@1820#12pmos@93_poly-right##11 net@1820#12pmos@93_poly-right##12 9.931
R4079 net@1820#12pmos@93_poly-right##12 net@1820#12pmos@93_poly-right##13 9.931
R4080 net@1820#12pmos@93_poly-right##13 net@1820#12pmos@93_poly-right##14 9.931
R4081 net@1820#12pmos@93_poly-right##14 net@1820#12pmos@93_poly-right##15 9.931
R4082 net@1820#12pmos@93_poly-right##15 net@1820#12pmos@93_poly-right##16 9.931
R4083 net@1820#12pmos@93_poly-right##16 net@1820#12pmos@93_poly-right##17 9.931
R4084 net@1820#12pmos@93_poly-right##17 net@1820#12pmos@93_poly-right##18 9.931
R4085 net@1820#12pmos@93_poly-right##18 net@1820#12pmos@93_poly-right##19 9.931
R4086 net@1820#12pmos@93_poly-right##19 net@1820#12pmos@93_poly-right##20 9.931
R4087 net@1820#12pmos@93_poly-right##20 net@1820#12pmos@93_poly-right##21 9.931
R4088 net@1820#12pmos@93_poly-right##21 net@1820#12pmos@93_poly-right##22 9.931
R4089 net@1820#12pmos@93_poly-right##22 net@1820#12pmos@93_poly-right##23 9.931
R4090 net@1820#12pmos@93_poly-right##23 net@1820#12pmos@93_poly-right##24 9.931
R4091 net@1820#12pmos@93_poly-right##24 net@1820#12pmos@93_poly-right##25 9.931
R4092 net@1820#12pmos@93_poly-right##25 net@1820#12pmos@93_poly-right##26 9.931
R4093 net@1820#12pmos@93_poly-right##26 net@1820#12pmos@93_poly-right##27 9.931
R4094 net@1820#12pmos@93_poly-right##27 net@1820#12pmos@93_poly-right##28 9.931
R4095 net@1820#12pmos@93_poly-right##28 net@1820#12pmos@93_poly-right##29 9.931
R4096 net@1820#12pmos@93_poly-right##29 net@1820#12pmos@93_poly-right##30 9.931
R4097 net@1820#12pmos@93_poly-right##30 net@1820#12pmos@93_poly-right##31 9.931
R4098 net@1820#12pmos@93_poly-right##31 net@1820#12pmos@93_poly-right##32 9.931
R4099 net@1820#12pmos@93_poly-right##32 net@1820#12pmos@93_poly-right##33 9.931
R4100 net@1820#12pmos@93_poly-right##33 net@1820#12pmos@93_poly-right##34 9.931
R4101 net@1820#12pmos@93_poly-right##34 net@1820#12pmos@93_poly-right##35 9.931
R4102 net@1820#12pmos@93_poly-right##35 net@1820#12pmos@93_poly-right##36 9.931
R4103 net@1820#12pmos@93_poly-right##36 net@1820#12pmos@93_poly-right##37 9.931
R4104 net@1820#12pmos@93_poly-right##37 net@1820#12pmos@93_poly-right##38 9.931
R4105 net@1820#12pmos@93_poly-right##38 net@1820#12pmos@93_poly-right##39 9.931
R4106 net@1820#12pmos@93_poly-right##39 net@1820#12pmos@93_poly-right##40 9.931
R4107 net@1820#12pmos@93_poly-right##40 net@1820#12pmos@93_poly-right##41 9.931
R4108 net@1820#12pmos@93_poly-right##41 net@1820#12pmos@93_poly-right##42 9.931
R4109 net@1820#12pmos@93_poly-right##42 net@1820#12pmos@93_poly-right##43 9.931
R4110 net@1820#12pmos@93_poly-right##43 net@1820#12pmos@93_poly-right##44 9.931
R4111 net@1820#12pmos@93_poly-right##44 net@1820#12pmos@93_poly-right##45 9.931
R4112 net@1820#12pmos@93_poly-right##45 net@1820#12pmos@93_poly-right##46 9.931
R4113 net@1820#12pmos@93_poly-right##46 net@1820#12pmos@93_poly-right##47 9.931
R4114 net@1820#12pmos@93_poly-right##47 net@1820#12pmos@93_poly-right##48 9.931
R4115 net@1820#12pmos@93_poly-right##48 net@1820#12pmos@93_poly-right##49 9.931
R4116 net@1820#12pmos@93_poly-right##49 net@1820#12pmos@93_poly-right##50 9.931
R4117 net@1820#12pmos@93_poly-right##50 net@1820#12pmos@93_poly-right##51 9.931
R4118 net@1820#12pmos@93_poly-right##51 net@1820#12pmos@93_poly-right##52 9.931
R4119 net@1820#12pmos@93_poly-right##52 net@1820#5pin@564_polysilicon-1 9.931
R4120 Sum2#4pmos@93_diff-top Sum2 4.823
R4121 XOR1_to_NAND3#14pin@576_polysilicon-1 XOR1_to_NAND3#14pin@576_polysilicon-1##0 9.854
R4122 XOR1_to_NAND3#14pin@576_polysilicon-1##0 XOR1_to_NAND3#14pin@576_polysilicon-1##1 9.854
R4123 XOR1_to_NAND3#14pin@576_polysilicon-1##1 XOR1_to_NAND3#14pin@576_polysilicon-1##2 9.854
R4124 XOR1_to_NAND3#14pin@576_polysilicon-1##2 XOR1_to_NAND3#14pin@576_polysilicon-1##3 9.854
R4125 XOR1_to_NAND3#14pin@576_polysilicon-1##3 XOR1_to_NAND3#14pin@576_polysilicon-1##4 9.854
R4126 XOR1_to_NAND3#14pin@576_polysilicon-1##4 XOR1_to_NAND3#14pin@576_polysilicon-1##5 9.854
R4127 XOR1_to_NAND3#14pin@576_polysilicon-1##5 XOR1_to_NAND3#14pin@576_polysilicon-1##6 9.854
R4128 XOR1_to_NAND3#14pin@576_polysilicon-1##6 XOR1_to_NAND3#14pin@576_polysilicon-1##7 9.854
R4129 XOR1_to_NAND3#14pin@576_polysilicon-1##7 XOR1_to_NAND3#14pin@576_polysilicon-1##8 9.854
R4130 XOR1_to_NAND3#14pin@576_polysilicon-1##8 XOR1_to_NAND3#14pin@576_polysilicon-1##9 9.854
R4131 XOR1_to_NAND3#14pin@576_polysilicon-1##9 XOR1_to_NAND3#14pin@576_polysilicon-1##10 9.854
R4132 XOR1_to_NAND3#14pin@576_polysilicon-1##10 XOR1_to_NAND3#14pin@576_polysilicon-1##11 9.854
R4133 XOR1_to_NAND3#14pin@576_polysilicon-1##11 XOR1_to_NAND3#14pin@576_polysilicon-1##12 9.854
R4134 XOR1_to_NAND3#14pin@576_polysilicon-1##12 XOR1_to_NAND3#14pin@576_polysilicon-1##13 9.854
R4135 XOR1_to_NAND3#14pin@576_polysilicon-1##13 XOR1_to_NAND3#14pin@576_polysilicon-1##14 9.854
R4136 XOR1_to_NAND3#14pin@576_polysilicon-1##14 XOR1_to_NAND3#14pin@576_polysilicon-1##15 9.854
R4137 XOR1_to_NAND3#14pin@576_polysilicon-1##15 XOR1_to_NAND3#14pin@576_polysilicon-1##16 9.854
R4138 XOR1_to_NAND3#14pin@576_polysilicon-1##16 XOR1_to_NAND3#14pin@576_polysilicon-1##17 9.854
R4139 XOR1_to_NAND3#14pin@576_polysilicon-1##17 XOR1_to_NAND3#14pin@576_polysilicon-1##18 9.854
R4140 XOR1_to_NAND3#14pin@576_polysilicon-1##18 XOR1_to_NAND3#14pin@576_polysilicon-1##19 9.854
R4141 XOR1_to_NAND3#14pin@576_polysilicon-1##19 XOR1_to_NAND3#14pin@576_polysilicon-1##20 9.854
R4142 XOR1_to_NAND3#14pin@576_polysilicon-1##20 XOR1_to_NAND3#14pin@576_polysilicon-1##21 9.854
R4143 XOR1_to_NAND3#14pin@576_polysilicon-1##21 XOR1_to_NAND3#14pin@576_polysilicon-1##22 9.854
R4144 XOR1_to_NAND3#14pin@576_polysilicon-1##22 XOR1_to_NAND3#14pin@576_polysilicon-1##23 9.854
R4145 XOR1_to_NAND3#14pin@576_polysilicon-1##23 XOR1_to_NAND3#14pin@576_polysilicon-1##24 9.854
R4146 XOR1_to_NAND3#14pin@576_polysilicon-1##24 XOR1_to_NAND3#14pin@576_polysilicon-1##25 9.854
R4147 XOR1_to_NAND3#14pin@576_polysilicon-1##25 XOR1_to_NAND3#14pin@576_polysilicon-1##26 9.854
R4148 XOR1_to_NAND3#14pin@576_polysilicon-1##26 XOR1_to_NAND3#14pin@576_polysilicon-1##27 9.854
R4149 XOR1_to_NAND3#14pin@576_polysilicon-1##27 XOR1_to_NAND3#14pin@576_polysilicon-1##28 9.854
R4150 XOR1_to_NAND3#14pin@576_polysilicon-1##28 XOR1_to_NAND3#14pin@576_polysilicon-1##29 9.854
R4151 XOR1_to_NAND3#14pin@576_polysilicon-1##29 XOR1_to_NAND3#14pin@576_polysilicon-1##30 9.854
R4152 XOR1_to_NAND3#14pin@576_polysilicon-1##30 XOR1_to_NAND3#14pin@576_polysilicon-1##31 9.854
R4153 XOR1_to_NAND3#14pin@576_polysilicon-1##31 XOR1_to_NAND3#14pin@576_polysilicon-1##32 9.854
R4154 XOR1_to_NAND3#14pin@576_polysilicon-1##32 XOR1_to_NAND3#14pin@576_polysilicon-1##33 9.854
R4155 XOR1_to_NAND3#14pin@576_polysilicon-1##33 XOR1_to_NAND3#14pin@576_polysilicon-1##34 9.854
R4156 XOR1_to_NAND3#14pin@576_polysilicon-1##34 XOR1_to_NAND3#14pin@576_polysilicon-1##35 9.854
R4157 XOR1_to_NAND3#14pin@576_polysilicon-1##35 XOR1_to_NAND3#14pin@576_polysilicon-1##36 9.854
R4158 XOR1_to_NAND3#14pin@576_polysilicon-1##36 XOR1_to_NAND3#14pin@576_polysilicon-1##37 9.854
R4159 XOR1_to_NAND3#14pin@576_polysilicon-1##37 XOR1_to_NAND3#14pin@576_polysilicon-1##38 9.854
R4160 XOR1_to_NAND3#14pin@576_polysilicon-1##38 XOR1_to_NAND3#14pin@576_polysilicon-1##39 9.854
R4161 XOR1_to_NAND3#14pin@576_polysilicon-1##39 XOR1_to_NAND3#14pin@576_polysilicon-1##40 9.854
R4162 XOR1_to_NAND3#14pin@576_polysilicon-1##40 XOR1_to_NAND3#14pin@576_polysilicon-1##41 9.854
R4163 XOR1_to_NAND3#14pin@576_polysilicon-1##41 XOR1_to_NAND3#14pin@576_polysilicon-1##42 9.854
R4164 XOR1_to_NAND3#14pin@576_polysilicon-1##42 XOR1_to_NAND3#14pin@576_polysilicon-1##43 9.854
R4165 XOR1_to_NAND3#14pin@576_polysilicon-1##43 XOR1_to_NAND3#14pin@576_polysilicon-1##44 9.854
R4166 XOR1_to_NAND3#14pin@576_polysilicon-1##44 XOR1_to_NAND3#14pin@576_polysilicon-1##45 9.854
R4167 XOR1_to_NAND3#14pin@576_polysilicon-1##45 XOR1_to_NAND3#14pin@576_polysilicon-1##46 9.854
R4168 XOR1_to_NAND3#14pin@576_polysilicon-1##46 XOR1_to_NAND3#14pin@576_polysilicon-1##47 9.854
R4169 XOR1_to_NAND3#14pin@576_polysilicon-1##47 XOR1_to_NAND3#14pin@576_polysilicon-1##48 9.854
R4170 XOR1_to_NAND3#14pin@576_polysilicon-1##48 XOR1_to_NAND3#14pin@576_polysilicon-1##49 9.854
R4171 XOR1_to_NAND3#14pin@576_polysilicon-1##49 XOR1_to_NAND3#14pin@576_polysilicon-1##50 9.854
R4172 XOR1_to_NAND3#14pin@576_polysilicon-1##50 XOR1_to_NAND3#14pin@576_polysilicon-1##51 9.854
R4173 XOR1_to_NAND3#14pin@576_polysilicon-1##51 XOR1_to_NAND3#14pin@576_polysilicon-1##52 9.854
R4174 XOR1_to_NAND3#14pin@576_polysilicon-1##52 XOR1_to_NAND3#14pin@576_polysilicon-1##53 9.854
R4175 XOR1_to_NAND3#14pin@576_polysilicon-1##53 XOR1_to_NAND3#14pin@576_polysilicon-1##54 9.854
R4176 XOR1_to_NAND3#14pin@576_polysilicon-1##54 XOR1_to_NAND3#27nmos@94_poly-right 9.854
R4177 Cin_to_XOR2___NAND3#29pmos@95_poly-right Cin_to_XOR2___NAND3#29pmos@95_poly-right##0 9.877
R4178 Cin_to_XOR2___NAND3#29pmos@95_poly-right##0 Cin_to_XOR2___NAND3#29pmos@95_poly-right##1 9.877
R4179 Cin_to_XOR2___NAND3#29pmos@95_poly-right##1 Cin_to_XOR2___NAND3#29pmos@95_poly-right##2 9.877
R4180 Cin_to_XOR2___NAND3#29pmos@95_poly-right##2 Cin_to_XOR2___NAND3#29pmos@95_poly-right##3 9.877
R4181 Cin_to_XOR2___NAND3#29pmos@95_poly-right##3 Cin_to_XOR2___NAND3#29pmos@95_poly-right##4 9.877
R4182 Cin_to_XOR2___NAND3#29pmos@95_poly-right##4 Cin_to_XOR2___NAND3#29pmos@95_poly-right##5 9.877
R4183 Cin_to_XOR2___NAND3#29pmos@95_poly-right##5 Cin_to_XOR2___NAND3#29pmos@95_poly-right##6 9.877
R4184 Cin_to_XOR2___NAND3#29pmos@95_poly-right##6 Cin_to_XOR2___NAND3#29pmos@95_poly-right##7 9.877
R4185 Cin_to_XOR2___NAND3#29pmos@95_poly-right##7 Cin_to_XOR2___NAND3#29pmos@95_poly-right##8 9.877
R4186 Cin_to_XOR2___NAND3#29pmos@95_poly-right##8 Cin_to_XOR2___NAND3#29pmos@95_poly-right##9 9.877
R4187 Cin_to_XOR2___NAND3#29pmos@95_poly-right##9 Cin_to_XOR2___NAND3#29pmos@95_poly-right##10 9.877
R4188 Cin_to_XOR2___NAND3#29pmos@95_poly-right##10 Cin_to_XOR2___NAND3#29pmos@95_poly-right##11 9.877
R4189 Cin_to_XOR2___NAND3#29pmos@95_poly-right##11 Cin_to_XOR2___NAND3#29pmos@95_poly-right##12 9.877
R4190 Cin_to_XOR2___NAND3#29pmos@95_poly-right##12 Cin_to_XOR2___NAND3#29pmos@95_poly-right##13 9.877
R4191 Cin_to_XOR2___NAND3#29pmos@95_poly-right##13 Cin_to_XOR2___NAND3#29pmos@95_poly-right##14 9.877
R4192 Cin_to_XOR2___NAND3#29pmos@95_poly-right##14 Cin_to_XOR2___NAND3#29pmos@95_poly-right##15 9.877
R4193 Cin_to_XOR2___NAND3#29pmos@95_poly-right##15 Cin_to_XOR2___NAND3#29pmos@95_poly-right##16 9.877
R4194 Cin_to_XOR2___NAND3#29pmos@95_poly-right##16 Cin_to_XOR2___NAND3#29pmos@95_poly-right##17 9.877
R4195 Cin_to_XOR2___NAND3#29pmos@95_poly-right##17 Cin_to_XOR2___NAND3#29pmos@95_poly-right##18 9.877
R4196 Cin_to_XOR2___NAND3#29pmos@95_poly-right##18 Cin_to_XOR2___NAND3#29pmos@95_poly-right##19 9.877
R4197 Cin_to_XOR2___NAND3#29pmos@95_poly-right##19 Cin_to_XOR2___NAND3#29pmos@95_poly-right##20 9.877
R4198 Cin_to_XOR2___NAND3#29pmos@95_poly-right##20 Cin_to_XOR2___NAND3#29pmos@95_poly-right##21 9.877
R4199 Cin_to_XOR2___NAND3#29pmos@95_poly-right##21 Cin_to_XOR2___NAND3#29pmos@95_poly-right##22 9.877
R4200 Cin_to_XOR2___NAND3#29pmos@95_poly-right##22 Cin_to_XOR2___NAND3#29pmos@95_poly-right##23 9.877
R4201 Cin_to_XOR2___NAND3#29pmos@95_poly-right##23 Cin_to_XOR2___NAND3#29pmos@95_poly-right##24 9.877
R4202 Cin_to_XOR2___NAND3#29pmos@95_poly-right##24 Cin_to_XOR2___NAND3#29pmos@95_poly-right##25 9.877
R4203 Cin_to_XOR2___NAND3#29pmos@95_poly-right##25 Cin_to_XOR2___NAND3#29pmos@95_poly-right##26 9.877
R4204 Cin_to_XOR2___NAND3#29pmos@95_poly-right##26 Cin_to_XOR2___NAND3#29pmos@95_poly-right##27 9.877
R4205 Cin_to_XOR2___NAND3#29pmos@95_poly-right##27 Cin_to_XOR2___NAND3#29pmos@95_poly-right##28 9.877
R4206 Cin_to_XOR2___NAND3#29pmos@95_poly-right##28 Cin_to_XOR2___NAND3#29pmos@95_poly-right##29 9.877
R4207 Cin_to_XOR2___NAND3#29pmos@95_poly-right##29 Cin_to_XOR2___NAND3#29pmos@95_poly-right##30 9.877
R4208 Cin_to_XOR2___NAND3#29pmos@95_poly-right##30 Cin_to_XOR2___NAND3#29pmos@95_poly-right##31 9.877
R4209 Cin_to_XOR2___NAND3#29pmos@95_poly-right##31 Cin_to_XOR2___NAND3#29pmos@95_poly-right##32 9.877
R4210 Cin_to_XOR2___NAND3#29pmos@95_poly-right##32 Cin_to_XOR2___NAND3#29pmos@95_poly-right##33 9.877
R4211 Cin_to_XOR2___NAND3#29pmos@95_poly-right##33 Cin_to_XOR2___NAND3#29pmos@95_poly-right##34 9.877
R4212 Cin_to_XOR2___NAND3#29pmos@95_poly-right##34 Cin_to_XOR2___NAND3#29pmos@95_poly-right##35 9.877
R4213 Cin_to_XOR2___NAND3#29pmos@95_poly-right##35 Cin_to_XOR2___NAND3#29pmos@95_poly-right##36 9.877
R4214 Cin_to_XOR2___NAND3#29pmos@95_poly-right##36 Cin_to_XOR2___NAND3#29pmos@95_poly-right##37 9.877
R4215 Cin_to_XOR2___NAND3#29pmos@95_poly-right##37 Cin_to_XOR2___NAND3#29pmos@95_poly-right##38 9.877
R4216 Cin_to_XOR2___NAND3#29pmos@95_poly-right##38 Cin_to_XOR2___NAND3#29pmos@95_poly-right##39 9.877
R4217 Cin_to_XOR2___NAND3#29pmos@95_poly-right##39 Cin_to_XOR2___NAND3#29pmos@95_poly-right##40 9.877
R4218 Cin_to_XOR2___NAND3#29pmos@95_poly-right##40 Cin_to_XOR2___NAND3#29pmos@95_poly-right##41 9.877
R4219 Cin_to_XOR2___NAND3#29pmos@95_poly-right##41 Cin_to_XOR2___NAND3#29pmos@95_poly-right##42 9.877
R4220 Cin_to_XOR2___NAND3#29pmos@95_poly-right##42 Cin_to_XOR2___NAND3#29pmos@95_poly-right##43 9.877
R4221 Cin_to_XOR2___NAND3#29pmos@95_poly-right##43 Cin_to_XOR2___NAND3#29pmos@95_poly-right##44 9.877
R4222 Cin_to_XOR2___NAND3#29pmos@95_poly-right##44 Cin_to_XOR2___NAND3#29pmos@95_poly-right##45 9.877
R4223 Cin_to_XOR2___NAND3#29pmos@95_poly-right##45 Cin_to_XOR2___NAND3#29pmos@95_poly-right##46 9.877
R4224 Cin_to_XOR2___NAND3#29pmos@95_poly-right##46 Cin_to_XOR2___NAND3#29pmos@95_poly-right##47 9.877
R4225 Cin_to_XOR2___NAND3#29pmos@95_poly-right##47 Cin_to_XOR2___NAND3#29pmos@95_poly-right##48 9.877
R4226 Cin_to_XOR2___NAND3#29pmos@95_poly-right##48 Cin_to_XOR2___NAND3#29pmos@95_poly-right##49 9.877
R4227 Cin_to_XOR2___NAND3#29pmos@95_poly-right##49 Cin_to_XOR2___NAND3#23pin@580_polysilicon-1 9.877
R4228 NAND1_to_NAND5 NAND1_to_NAND5#4nmos@95_diff-bottom 4.823
R4229 A2#10pin@583_polysilicon-1 A2#10pin@583_polysilicon-1##0 9.938
R4230 A2#10pin@583_polysilicon-1##0 A2#10pin@583_polysilicon-1##1 9.938
R4231 A2#10pin@583_polysilicon-1##1 A2#10pin@583_polysilicon-1##2 9.938
R4232 A2#10pin@583_polysilicon-1##2 A2#10pin@583_polysilicon-1##3 9.938
R4233 A2#10pin@583_polysilicon-1##3 A2#10pin@583_polysilicon-1##4 9.938
R4234 A2#10pin@583_polysilicon-1##4 A2#10pin@583_polysilicon-1##5 9.938
R4235 A2#10pin@583_polysilicon-1##5 A2#10pin@583_polysilicon-1##6 9.938
R4236 A2#10pin@583_polysilicon-1##6 A2#10pin@583_polysilicon-1##7 9.938
R4237 A2#10pin@583_polysilicon-1##7 A2#10pin@583_polysilicon-1##8 9.938
R4238 A2#10pin@583_polysilicon-1##8 A2#10pin@583_polysilicon-1##9 9.938
R4239 A2#10pin@583_polysilicon-1##9 A2#10pin@583_polysilicon-1##10 9.938
R4240 A2#10pin@583_polysilicon-1##10 A2#10pin@583_polysilicon-1##11 9.938
R4241 A2#10pin@583_polysilicon-1##11 A2#10pin@583_polysilicon-1##12 9.938
R4242 A2#10pin@583_polysilicon-1##12 A2#10pin@583_polysilicon-1##13 9.938
R4243 A2#10pin@583_polysilicon-1##13 A2#10pin@583_polysilicon-1##14 9.938
R4244 A2#10pin@583_polysilicon-1##14 A2#10pin@583_polysilicon-1##15 9.938
R4245 A2#10pin@583_polysilicon-1##15 A2#10pin@583_polysilicon-1##16 9.938
R4246 A2#10pin@583_polysilicon-1##16 A2#10pin@583_polysilicon-1##17 9.938
R4247 A2#10pin@583_polysilicon-1##17 A2#10pin@583_polysilicon-1##18 9.938
R4248 A2#10pin@583_polysilicon-1##18 A2#10pin@583_polysilicon-1##19 9.938
R4249 A2#10pin@583_polysilicon-1##19 A2#10pin@583_polysilicon-1##20 9.938
R4250 A2#10pin@583_polysilicon-1##20 A2#10pin@583_polysilicon-1##21 9.938
R4251 A2#10pin@583_polysilicon-1##21 A2#10pin@583_polysilicon-1##22 9.938
R4252 A2#10pin@583_polysilicon-1##22 A2#10pin@583_polysilicon-1##23 9.938
R4253 A2#10pin@583_polysilicon-1##23 A2#10pin@583_polysilicon-1##24 9.938
R4254 A2#10pin@583_polysilicon-1##24 A2#10pin@583_polysilicon-1##25 9.938
R4255 A2#10pin@583_polysilicon-1##25 A2#10pin@583_polysilicon-1##26 9.938
R4256 A2#10pin@583_polysilicon-1##26 A2#10pin@583_polysilicon-1##27 9.938
R4257 A2#10pin@583_polysilicon-1##27 A2#10pin@583_polysilicon-1##28 9.938
R4258 A2#10pin@583_polysilicon-1##28 A2#10pin@583_polysilicon-1##29 9.938
R4259 A2#10pin@583_polysilicon-1##29 A2#10pin@583_polysilicon-1##30 9.938
R4260 A2#10pin@583_polysilicon-1##30 A2#10pin@583_polysilicon-1##31 9.938
R4261 A2#10pin@583_polysilicon-1##31 A2#10pin@583_polysilicon-1##32 9.938
R4262 A2#10pin@583_polysilicon-1##32 A2#10pin@583_polysilicon-1##33 9.938
R4263 A2#10pin@583_polysilicon-1##33 A2#10pin@583_polysilicon-1##34 9.938
R4264 A2#10pin@583_polysilicon-1##34 A2#10pin@583_polysilicon-1##35 9.938
R4265 A2#10pin@583_polysilicon-1##35 A2#10pin@583_polysilicon-1##36 9.938
R4266 A2#10pin@583_polysilicon-1##36 A2#10pin@583_polysilicon-1##37 9.938
R4267 A2#10pin@583_polysilicon-1##37 A2#10pin@583_polysilicon-1##38 9.938
R4268 A2#10pin@583_polysilicon-1##38 A2#10pin@583_polysilicon-1##39 9.938
R4269 A2#10pin@583_polysilicon-1##39 A2#10pin@583_polysilicon-1##40 9.938
R4270 A2#10pin@583_polysilicon-1##40 A2#10pin@583_polysilicon-1##41 9.938
R4271 A2#10pin@583_polysilicon-1##41 A2#10pin@583_polysilicon-1##42 9.938
R4272 A2#10pin@583_polysilicon-1##42 A2#10pin@583_polysilicon-1##43 9.938
R4273 A2#10pin@583_polysilicon-1##43 A2#10pin@583_polysilicon-1##44 9.938
R4274 A2#10pin@583_polysilicon-1##44 A2#10pin@583_polysilicon-1##45 9.938
R4275 A2#10pin@583_polysilicon-1##45 A2#10pin@583_polysilicon-1##46 9.938
R4276 A2#10pin@583_polysilicon-1##46 A2#10pin@583_polysilicon-1##47 9.938
R4277 A2#10pin@583_polysilicon-1##47 A2#10pin@583_polysilicon-1##48 9.938
R4278 A2#10pin@583_polysilicon-1##48 A2#10pin@583_polysilicon-1##49 9.938
R4279 A2#10pin@583_polysilicon-1##49 A2#19nmos@96_poly-right 9.938
R4280 B2#20pmos@97_poly-right B2#20pmos@97_poly-right##0 9.869
R4281 B2#20pmos@97_poly-right##0 B2#20pmos@97_poly-right##1 9.869
R4282 B2#20pmos@97_poly-right##1 B2#20pmos@97_poly-right##2 9.869
R4283 B2#20pmos@97_poly-right##2 B2#20pmos@97_poly-right##3 9.869
R4284 B2#20pmos@97_poly-right##3 B2#20pmos@97_poly-right##4 9.869
R4285 B2#20pmos@97_poly-right##4 B2#20pmos@97_poly-right##5 9.869
R4286 B2#20pmos@97_poly-right##5 B2#20pmos@97_poly-right##6 9.869
R4287 B2#20pmos@97_poly-right##6 B2#20pmos@97_poly-right##7 9.869
R4288 B2#20pmos@97_poly-right##7 B2#20pmos@97_poly-right##8 9.869
R4289 B2#20pmos@97_poly-right##8 B2#20pmos@97_poly-right##9 9.869
R4290 B2#20pmos@97_poly-right##9 B2#20pmos@97_poly-right##10 9.869
R4291 B2#20pmos@97_poly-right##10 B2#20pmos@97_poly-right##11 9.869
R4292 B2#20pmos@97_poly-right##11 B2#20pmos@97_poly-right##12 9.869
R4293 B2#20pmos@97_poly-right##12 B2#20pmos@97_poly-right##13 9.869
R4294 B2#20pmos@97_poly-right##13 B2#20pmos@97_poly-right##14 9.869
R4295 B2#20pmos@97_poly-right##14 B2#20pmos@97_poly-right##15 9.869
R4296 B2#20pmos@97_poly-right##15 B2#20pmos@97_poly-right##16 9.869
R4297 B2#20pmos@97_poly-right##16 B2#20pmos@97_poly-right##17 9.869
R4298 B2#20pmos@97_poly-right##17 B2#20pmos@97_poly-right##18 9.869
R4299 B2#20pmos@97_poly-right##18 B2#20pmos@97_poly-right##19 9.869
R4300 B2#20pmos@97_poly-right##19 B2#20pmos@97_poly-right##20 9.869
R4301 B2#20pmos@97_poly-right##20 B2#20pmos@97_poly-right##21 9.869
R4302 B2#20pmos@97_poly-right##21 B2#20pmos@97_poly-right##22 9.869
R4303 B2#20pmos@97_poly-right##22 B2#20pmos@97_poly-right##23 9.869
R4304 B2#20pmos@97_poly-right##23 B2#20pmos@97_poly-right##24 9.869
R4305 B2#20pmos@97_poly-right##24 B2#20pmos@97_poly-right##25 9.869
R4306 B2#20pmos@97_poly-right##25 B2#20pmos@97_poly-right##26 9.869
R4307 B2#20pmos@97_poly-right##26 B2#20pmos@97_poly-right##27 9.869
R4308 B2#20pmos@97_poly-right##27 B2#20pmos@97_poly-right##28 9.869
R4309 B2#20pmos@97_poly-right##28 B2#20pmos@97_poly-right##29 9.869
R4310 B2#20pmos@97_poly-right##29 B2#20pmos@97_poly-right##30 9.869
R4311 B2#20pmos@97_poly-right##30 B2#20pmos@97_poly-right##31 9.869
R4312 B2#20pmos@97_poly-right##31 B2#20pmos@97_poly-right##32 9.869
R4313 B2#20pmos@97_poly-right##32 B2#20pmos@97_poly-right##33 9.869
R4314 B2#20pmos@97_poly-right##33 B2#20pmos@97_poly-right##34 9.869
R4315 B2#20pmos@97_poly-right##34 B2#20pmos@97_poly-right##35 9.869
R4316 B2#20pmos@97_poly-right##35 B2#20pmos@97_poly-right##36 9.869
R4317 B2#20pmos@97_poly-right##36 B2#20pmos@97_poly-right##37 9.869
R4318 B2#20pmos@97_poly-right##37 B2#20pmos@97_poly-right##38 9.869
R4319 B2#20pmos@97_poly-right##38 B2#20pmos@97_poly-right##39 9.869
R4320 B2#20pmos@97_poly-right##39 B2#20pmos@97_poly-right##40 9.869
R4321 B2#20pmos@97_poly-right##40 B2#20pmos@97_poly-right##41 9.869
R4322 B2#20pmos@97_poly-right##41 B2#20pmos@97_poly-right##42 9.869
R4323 B2#20pmos@97_poly-right##42 B2#20pmos@97_poly-right##43 9.869
R4324 B2#20pmos@97_poly-right##43 B2#20pmos@97_poly-right##44 9.869
R4325 B2#20pmos@97_poly-right##44 B2#20pmos@97_poly-right##45 9.869
R4326 B2#20pmos@97_poly-right##45 B2#20pmos@97_poly-right##46 9.869
R4327 B2#20pmos@97_poly-right##46 B2#20pmos@97_poly-right##47 9.869
R4328 B2#20pmos@97_poly-right##47 B2#10pin@587_polysilicon-1 9.869
R4329 NAND2_to_Nand5#9pin@589_polysilicon-1 NAND2_to_Nand5#9pin@589_polysilicon-1##0 9.938
R4330 NAND2_to_Nand5#9pin@589_polysilicon-1##0 NAND2_to_Nand5#9pin@589_polysilicon-1##1 9.938
R4331 NAND2_to_Nand5#9pin@589_polysilicon-1##1 NAND2_to_Nand5#9pin@589_polysilicon-1##2 9.938
R4332 NAND2_to_Nand5#9pin@589_polysilicon-1##2 NAND2_to_Nand5#9pin@589_polysilicon-1##3 9.938
R4333 NAND2_to_Nand5#9pin@589_polysilicon-1##3 NAND2_to_Nand5#9pin@589_polysilicon-1##4 9.938
R4334 NAND2_to_Nand5#9pin@589_polysilicon-1##4 NAND2_to_Nand5#9pin@589_polysilicon-1##5 9.938
R4335 NAND2_to_Nand5#9pin@589_polysilicon-1##5 NAND2_to_Nand5#9pin@589_polysilicon-1##6 9.938
R4336 NAND2_to_Nand5#9pin@589_polysilicon-1##6 NAND2_to_Nand5#9pin@589_polysilicon-1##7 9.938
R4337 NAND2_to_Nand5#9pin@589_polysilicon-1##7 NAND2_to_Nand5#9pin@589_polysilicon-1##8 9.938
R4338 NAND2_to_Nand5#9pin@589_polysilicon-1##8 NAND2_to_Nand5#9pin@589_polysilicon-1##9 9.938
R4339 NAND2_to_Nand5#9pin@589_polysilicon-1##9 NAND2_to_Nand5#9pin@589_polysilicon-1##10 9.938
R4340 NAND2_to_Nand5#9pin@589_polysilicon-1##10 NAND2_to_Nand5#9pin@589_polysilicon-1##11 9.938
R4341 NAND2_to_Nand5#9pin@589_polysilicon-1##11 NAND2_to_Nand5#9pin@589_polysilicon-1##12 9.938
R4342 NAND2_to_Nand5#9pin@589_polysilicon-1##12 NAND2_to_Nand5#9pin@589_polysilicon-1##13 9.938
R4343 NAND2_to_Nand5#9pin@589_polysilicon-1##13 NAND2_to_Nand5#9pin@589_polysilicon-1##14 9.938
R4344 NAND2_to_Nand5#9pin@589_polysilicon-1##14 NAND2_to_Nand5#9pin@589_polysilicon-1##15 9.938
R4345 NAND2_to_Nand5#9pin@589_polysilicon-1##15 NAND2_to_Nand5#9pin@589_polysilicon-1##16 9.938
R4346 NAND2_to_Nand5#9pin@589_polysilicon-1##16 NAND2_to_Nand5#9pin@589_polysilicon-1##17 9.938
R4347 NAND2_to_Nand5#9pin@589_polysilicon-1##17 NAND2_to_Nand5#9pin@589_polysilicon-1##18 9.938
R4348 NAND2_to_Nand5#9pin@589_polysilicon-1##18 NAND2_to_Nand5#9pin@589_polysilicon-1##19 9.938
R4349 NAND2_to_Nand5#9pin@589_polysilicon-1##19 NAND2_to_Nand5#9pin@589_polysilicon-1##20 9.938
R4350 NAND2_to_Nand5#9pin@589_polysilicon-1##20 NAND2_to_Nand5#9pin@589_polysilicon-1##21 9.938
R4351 NAND2_to_Nand5#9pin@589_polysilicon-1##21 NAND2_to_Nand5#9pin@589_polysilicon-1##22 9.938
R4352 NAND2_to_Nand5#9pin@589_polysilicon-1##22 NAND2_to_Nand5#9pin@589_polysilicon-1##23 9.938
R4353 NAND2_to_Nand5#9pin@589_polysilicon-1##23 NAND2_to_Nand5#9pin@589_polysilicon-1##24 9.938
R4354 NAND2_to_Nand5#9pin@589_polysilicon-1##24 NAND2_to_Nand5#9pin@589_polysilicon-1##25 9.938
R4355 NAND2_to_Nand5#9pin@589_polysilicon-1##25 NAND2_to_Nand5#9pin@589_polysilicon-1##26 9.938
R4356 NAND2_to_Nand5#9pin@589_polysilicon-1##26 NAND2_to_Nand5#9pin@589_polysilicon-1##27 9.938
R4357 NAND2_to_Nand5#9pin@589_polysilicon-1##27 NAND2_to_Nand5#9pin@589_polysilicon-1##28 9.938
R4358 NAND2_to_Nand5#9pin@589_polysilicon-1##28 NAND2_to_Nand5#9pin@589_polysilicon-1##29 9.938
R4359 NAND2_to_Nand5#9pin@589_polysilicon-1##29 NAND2_to_Nand5#9pin@589_polysilicon-1##30 9.938
R4360 NAND2_to_Nand5#9pin@589_polysilicon-1##30 NAND2_to_Nand5#9pin@589_polysilicon-1##31 9.938
R4361 NAND2_to_Nand5#9pin@589_polysilicon-1##31 NAND2_to_Nand5#9pin@589_polysilicon-1##32 9.938
R4362 NAND2_to_Nand5#9pin@589_polysilicon-1##32 NAND2_to_Nand5#9pin@589_polysilicon-1##33 9.938
R4363 NAND2_to_Nand5#9pin@589_polysilicon-1##33 NAND2_to_Nand5#9pin@589_polysilicon-1##34 9.938
R4364 NAND2_to_Nand5#9pin@589_polysilicon-1##34 NAND2_to_Nand5#9pin@589_polysilicon-1##35 9.938
R4365 NAND2_to_Nand5#9pin@589_polysilicon-1##35 NAND2_to_Nand5#9pin@589_polysilicon-1##36 9.938
R4366 NAND2_to_Nand5#9pin@589_polysilicon-1##36 NAND2_to_Nand5#9pin@589_polysilicon-1##37 9.938
R4367 NAND2_to_Nand5#9pin@589_polysilicon-1##37 NAND2_to_Nand5#9pin@589_polysilicon-1##38 9.938
R4368 NAND2_to_Nand5#9pin@589_polysilicon-1##38 NAND2_to_Nand5#9pin@589_polysilicon-1##39 9.938
R4369 NAND2_to_Nand5#9pin@589_polysilicon-1##39 NAND2_to_Nand5#9pin@589_polysilicon-1##40 9.938
R4370 NAND2_to_Nand5#9pin@589_polysilicon-1##40 NAND2_to_Nand5#9pin@589_polysilicon-1##41 9.938
R4371 NAND2_to_Nand5#9pin@589_polysilicon-1##41 NAND2_to_Nand5#9pin@589_polysilicon-1##42 9.938
R4372 NAND2_to_Nand5#9pin@589_polysilicon-1##42 NAND2_to_Nand5#9pin@589_polysilicon-1##43 9.938
R4373 NAND2_to_Nand5#9pin@589_polysilicon-1##43 NAND2_to_Nand5#9pin@589_polysilicon-1##44 9.938
R4374 NAND2_to_Nand5#9pin@589_polysilicon-1##44 NAND2_to_Nand5#9pin@589_polysilicon-1##45 9.938
R4375 NAND2_to_Nand5#9pin@589_polysilicon-1##45 NAND2_to_Nand5#9pin@589_polysilicon-1##46 9.938
R4376 NAND2_to_Nand5#9pin@589_polysilicon-1##46 NAND2_to_Nand5#9pin@589_polysilicon-1##47 9.938
R4377 NAND2_to_Nand5#9pin@589_polysilicon-1##47 NAND2_to_Nand5#9pin@589_polysilicon-1##48 9.938
R4378 NAND2_to_Nand5#9pin@589_polysilicon-1##48 NAND2_to_Nand5#9pin@589_polysilicon-1##49 9.938
R4379 NAND2_to_Nand5#9pin@589_polysilicon-1##49 NAND2_to_Nand5#11nmos@98_poly-right 9.938
R4380 NAND1_to_NAND5#14nmos@99_poly-right NAND1_to_NAND5#14nmos@99_poly-right##0 9.898
R4381 NAND1_to_NAND5#14nmos@99_poly-right##0 NAND1_to_NAND5#14nmos@99_poly-right##1 9.898
R4382 NAND1_to_NAND5#14nmos@99_poly-right##1 NAND1_to_NAND5#14nmos@99_poly-right##2 9.898
R4383 NAND1_to_NAND5#14nmos@99_poly-right##2 NAND1_to_NAND5#14nmos@99_poly-right##3 9.898
R4384 NAND1_to_NAND5#14nmos@99_poly-right##3 NAND1_to_NAND5#14nmos@99_poly-right##4 9.898
R4385 NAND1_to_NAND5#14nmos@99_poly-right##4 NAND1_to_NAND5#14nmos@99_poly-right##5 9.898
R4386 NAND1_to_NAND5#14nmos@99_poly-right##5 NAND1_to_NAND5#14nmos@99_poly-right##6 9.898
R4387 NAND1_to_NAND5#14nmos@99_poly-right##6 NAND1_to_NAND5#14nmos@99_poly-right##7 9.898
R4388 NAND1_to_NAND5#14nmos@99_poly-right##7 NAND1_to_NAND5#14nmos@99_poly-right##8 9.898
R4389 NAND1_to_NAND5#14nmos@99_poly-right##8 NAND1_to_NAND5#14nmos@99_poly-right##9 9.898
R4390 NAND1_to_NAND5#14nmos@99_poly-right##9 NAND1_to_NAND5#14nmos@99_poly-right##10 9.898
R4391 NAND1_to_NAND5#14nmos@99_poly-right##10 NAND1_to_NAND5#14nmos@99_poly-right##11 9.898
R4392 NAND1_to_NAND5#14nmos@99_poly-right##11 NAND1_to_NAND5#14nmos@99_poly-right##12 9.898
R4393 NAND1_to_NAND5#14nmos@99_poly-right##12 NAND1_to_NAND5#14nmos@99_poly-right##13 9.898
R4394 NAND1_to_NAND5#14nmos@99_poly-right##13 NAND1_to_NAND5#14nmos@99_poly-right##14 9.898
R4395 NAND1_to_NAND5#14nmos@99_poly-right##14 NAND1_to_NAND5#14nmos@99_poly-right##15 9.898
R4396 NAND1_to_NAND5#14nmos@99_poly-right##15 NAND1_to_NAND5#14nmos@99_poly-right##16 9.898
R4397 NAND1_to_NAND5#14nmos@99_poly-right##16 NAND1_to_NAND5#14nmos@99_poly-right##17 9.898
R4398 NAND1_to_NAND5#14nmos@99_poly-right##17 NAND1_to_NAND5#14nmos@99_poly-right##18 9.898
R4399 NAND1_to_NAND5#14nmos@99_poly-right##18 NAND1_to_NAND5#14nmos@99_poly-right##19 9.898
R4400 NAND1_to_NAND5#14nmos@99_poly-right##19 NAND1_to_NAND5#14nmos@99_poly-right##20 9.898
R4401 NAND1_to_NAND5#14nmos@99_poly-right##20 NAND1_to_NAND5#14nmos@99_poly-right##21 9.898
R4402 NAND1_to_NAND5#14nmos@99_poly-right##21 NAND1_to_NAND5#14nmos@99_poly-right##22 9.898
R4403 NAND1_to_NAND5#14nmos@99_poly-right##22 NAND1_to_NAND5#14nmos@99_poly-right##23 9.898
R4404 NAND1_to_NAND5#14nmos@99_poly-right##23 NAND1_to_NAND5#14nmos@99_poly-right##24 9.898
R4405 NAND1_to_NAND5#14nmos@99_poly-right##24 NAND1_to_NAND5#14nmos@99_poly-right##25 9.898
R4406 NAND1_to_NAND5#14nmos@99_poly-right##25 NAND1_to_NAND5#14nmos@99_poly-right##26 9.898
R4407 NAND1_to_NAND5#14nmos@99_poly-right##26 NAND1_to_NAND5#14nmos@99_poly-right##27 9.898
R4408 NAND1_to_NAND5#14nmos@99_poly-right##27 NAND1_to_NAND5#14nmos@99_poly-right##28 9.898
R4409 NAND1_to_NAND5#14nmos@99_poly-right##28 NAND1_to_NAND5#14nmos@99_poly-right##29 9.898
R4410 NAND1_to_NAND5#14nmos@99_poly-right##29 NAND1_to_NAND5#14nmos@99_poly-right##30 9.898
R4411 NAND1_to_NAND5#14nmos@99_poly-right##30 NAND1_to_NAND5#14nmos@99_poly-right##31 9.898
R4412 NAND1_to_NAND5#14nmos@99_poly-right##31 NAND1_to_NAND5#14nmos@99_poly-right##32 9.898
R4413 NAND1_to_NAND5#14nmos@99_poly-right##32 NAND1_to_NAND5#14nmos@99_poly-right##33 9.898
R4414 NAND1_to_NAND5#14nmos@99_poly-right##33 NAND1_to_NAND5#14nmos@99_poly-right##34 9.898
R4415 NAND1_to_NAND5#14nmos@99_poly-right##34 NAND1_to_NAND5#14nmos@99_poly-right##35 9.898
R4416 NAND1_to_NAND5#14nmos@99_poly-right##35 NAND1_to_NAND5#14nmos@99_poly-right##36 9.898
R4417 NAND1_to_NAND5#14nmos@99_poly-right##36 NAND1_to_NAND5#14nmos@99_poly-right##37 9.898
R4418 NAND1_to_NAND5#14nmos@99_poly-right##37 NAND1_to_NAND5#14nmos@99_poly-right##38 9.898
R4419 NAND1_to_NAND5#14nmos@99_poly-right##38 NAND1_to_NAND5#14nmos@99_poly-right##39 9.898
R4420 NAND1_to_NAND5#14nmos@99_poly-right##39 NAND1_to_NAND5#14nmos@99_poly-right##40 9.898
R4421 NAND1_to_NAND5#14nmos@99_poly-right##40 NAND1_to_NAND5#14nmos@99_poly-right##41 9.898
R4422 NAND1_to_NAND5#14nmos@99_poly-right##41 NAND1_to_NAND5#14nmos@99_poly-right##42 9.898
R4423 NAND1_to_NAND5#14nmos@99_poly-right##42 NAND1_to_NAND5#14nmos@99_poly-right##43 9.898
R4424 NAND1_to_NAND5#14nmos@99_poly-right##43 NAND1_to_NAND5#14nmos@99_poly-right##44 9.898
R4425 NAND1_to_NAND5#14nmos@99_poly-right##44 NAND1_to_NAND5#14nmos@99_poly-right##45 9.898
R4426 NAND1_to_NAND5#14nmos@99_poly-right##45 NAND1_to_NAND5#14nmos@99_poly-right##46 9.898
R4427 NAND1_to_NAND5#14nmos@99_poly-right##46 NAND1_to_NAND5#14nmos@99_poly-right##47 9.898
R4428 NAND1_to_NAND5#14nmos@99_poly-right##47 NAND1_to_NAND5#14nmos@99_poly-right##48 9.898
R4429 NAND1_to_NAND5#14nmos@99_poly-right##48 NAND1_to_NAND5#14nmos@99_poly-right##49 9.898
R4430 NAND1_to_NAND5#14nmos@99_poly-right##49 NAND1_to_NAND5#14nmos@99_poly-right##50 9.898
R4431 NAND1_to_NAND5#14nmos@99_poly-right##50 NAND1_to_NAND5#14nmos@99_poly-right##51 9.898
R4432 NAND1_to_NAND5#14nmos@99_poly-right##51 NAND1_to_NAND5#14nmos@99_poly-right##52 9.898
R4433 NAND1_to_NAND5#14nmos@99_poly-right##52 NAND1_to_NAND5#14nmos@99_poly-right##53 9.898
R4434 NAND1_to_NAND5#14nmos@99_poly-right##53 NAND1_to_NAND5#14nmos@99_poly-right##54 9.898
R4435 NAND1_to_NAND5#14nmos@99_poly-right##54 NAND1_to_NAND5#14nmos@99_poly-right##55 9.898
R4436 NAND1_to_NAND5#14nmos@99_poly-right##55 NAND1_to_NAND5#11pmos@99_poly-right 9.898
R4437 NAND2_to_Nand5 NAND2_to_Nand5#4nmos@97_diff-bottom 4.42
R4438 A2 A2##0 9.854
C548 A2##0 0 10.57fF
R4439 A2##0 A2#1pin@586_metal-2 9.854
R4440 B2 B2##0 9.756
C549 B2##0 0 10.466fF
R4441 B2##0 B2#1pin@588_metal-2 9.756
R4442 net@2106 net@2106##0 9.92
R4443 net@2106##0 net@2106##1 9.92
R4444 net@2106##1 net@2106##2 9.92
R4445 net@2106##2 net@2106##3 9.92
R4446 net@2106##3 net@2106##4 9.92
R4447 net@2106##4 net@2106##5 9.92
R4448 net@2106##5 net@2106##6 9.92
R4449 net@2106##6 net@2106##7 9.92
R4450 net@2106##7 net@2106##8 9.92
R4451 net@2106##8 net@2106##9 9.92
R4452 net@2106##9 net@2106##10 9.92
R4453 net@2106##10 net@2106##11 9.92
R4454 net@2106##11 net@2106##12 9.92
R4455 net@2106##12 net@2106##13 9.92
R4456 net@2106##13 net@2106##14 9.92
R4457 net@2106##14 net@2106##15 9.92
R4458 net@2106##15 net@2106##16 9.92
R4459 net@2106##16 net@2106##17 9.92
R4460 net@2106##17 net@2106##18 9.92
R4461 net@2106##18 net@2106#1pin@641_polysilicon-1 9.92
R4462 net@2108 net@2108##0 9.92
R4463 net@2108##0 net@2108##1 9.92
R4464 net@2108##1 net@2108##2 9.92
R4465 net@2108##2 net@2108##3 9.92
R4466 net@2108##3 net@2108##4 9.92
R4467 net@2108##4 net@2108##5 9.92
R4468 net@2108##5 net@2108##6 9.92
R4469 net@2108##6 net@2108##7 9.92
R4470 net@2108##7 net@2108##8 9.92
R4471 net@2108##8 net@2108##9 9.92
R4472 net@2108##9 net@2108##10 9.92
R4473 net@2108##10 net@2108##11 9.92
R4474 net@2108##11 net@2108##12 9.92
R4475 net@2108##12 net@2108##13 9.92
R4476 net@2108##13 net@2108##14 9.92
R4477 net@2108##14 net@2108##15 9.92
R4478 net@2108##15 net@2108##16 9.92
R4479 net@2108##16 net@2108##17 9.92
R4480 net@2108##17 net@2108##18 9.92
R4481 net@2108##18 net@2108#1pin@666_polysilicon-1 9.92
R4482 XOR1_to_NAND4#3pin@667_polysilicon-1 XOR1_to_NAND4#3pin@667_polysilicon-1##0 6.2
R4483 XOR1_to_NAND4#3pin@667_polysilicon-1##0 XOR1_to_NAND4#4pmos@112_poly-right 6.2
R4484 XOR1_to_NAND4#3pin@667_polysilicon-1 XOR1_to_NAND4#3pin@667_polysilicon-1##0 8.138
R4485 XOR1_to_NAND4#3pin@667_polysilicon-1##0 XOR1_to_NAND4#3pin@667_polysilicon-1##1 8.138
R4486 XOR1_to_NAND4#3pin@667_polysilicon-1##1 XOR1_to_NAND4#3pin@667_polysilicon-1##2 8.138
R4487 XOR1_to_NAND4#3pin@667_polysilicon-1##2 XOR1_to_NAND4#1contact@766_metal-1-metal-2 8.138
R4488 Cin_to_XOR2___NAND4#14nmos@111_poly-right Cin_to_XOR2___NAND4#14nmos@111_poly-right##0 5.425
R4489 Cin_to_XOR2___NAND4#14nmos@111_poly-right##0 Cin_to_XOR2___NAND4#15pin@657_polysilicon-1 5.425
R4490 Cin_to_XOR2___NAND4 Cin_to_XOR2___NAND4##0 8.99
R4491 Cin_to_XOR2___NAND4##0 Cin_to_XOR2___NAND4##1 8.99
R4492 Cin_to_XOR2___NAND4##1 Cin_to_XOR2___NAND4##2 8.99
R4493 Cin_to_XOR2___NAND4##2 Cin_to_XOR2___NAND4##3 8.99
R4494 Cin_to_XOR2___NAND4##3 Cin_to_XOR2___NAND4#15pin@657_polysilicon-1 8.99
R4495 A3#3pin@642_polysilicon-1 A3#3pin@642_polysilicon-1##0 6.2
R4496 A3#3pin@642_polysilicon-1##0 A3#4pmos@105_poly-right 6.2
R4497 XOR1_to_NAND4#9pmos@107_poly-left XOR1_to_NAND4#9pmos@107_poly-left##0 8.138
R4498 XOR1_to_NAND4#9pmos@107_poly-left##0 XOR1_to_NAND4#9pmos@107_poly-left##1 8.138
R4499 XOR1_to_NAND4#9pmos@107_poly-left##1 XOR1_to_NAND4#9pmos@107_poly-left##2 8.138
R4500 XOR1_to_NAND4#9pmos@107_poly-left##2 XOR1_to_NAND4#10pin@654_polysilicon-1 8.138
R4501 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##0 9.843
R4502 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##0 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##1 9.843
R4503 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##1 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##2 9.843
R4504 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##2 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##3 9.843
R4505 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##3 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##4 9.843
R4506 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##4 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##5 9.843
R4507 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##5 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##6 9.843
R4508 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##6 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##7 9.843
R4509 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##7 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##8 9.843
R4510 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##8 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##9 9.843
R4511 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##9 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##10 9.843
R4512 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##10 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##11 9.843
R4513 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##11 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##12 9.843
R4514 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##12 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##13 9.843
R4515 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##13 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##14 9.843
R4516 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##14 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##15 9.843
R4517 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##15 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##16 9.843
R4518 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##16 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##17 9.843
R4519 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##17 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##18 9.843
R4520 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1##18 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1 9.843
R4521 net@2117#4nmos@113_poly-right net@2117#4nmos@113_poly-right##0 9.3
R4522 net@2117#4nmos@113_poly-right##0 net@2117#4nmos@113_poly-right##1 9.3
R4523 net@2117#4nmos@113_poly-right##1 net@2117#5pin@659_polysilicon-1 9.3
R4524 net@2117#2contact@752_metal-1-polysilicon-1 net@2117#2contact@752_metal-1-polysilicon-1##0 8.99
R4525 net@2117#2contact@752_metal-1-polysilicon-1##0 net@2117#2contact@752_metal-1-polysilicon-1##1 8.99
R4526 net@2117#2contact@752_metal-1-polysilicon-1##1 net@2117#2contact@752_metal-1-polysilicon-1##2 8.99
R4527 net@2117#2contact@752_metal-1-polysilicon-1##2 net@2117#2contact@752_metal-1-polysilicon-1##3 8.99
R4528 net@2117#2contact@752_metal-1-polysilicon-1##3 net@2117#5pin@659_polysilicon-1 8.99
R4529 A3#3pin@642_polysilicon-1 A3#3pin@642_polysilicon-1##0 8.138
R4530 A3#3pin@642_polysilicon-1##0 A3#3pin@642_polysilicon-1##1 8.138
R4531 A3#3pin@642_polysilicon-1##1 A3#3pin@642_polysilicon-1##2 8.138
R4532 A3#3pin@642_polysilicon-1##2 A3#1pin@681_metal-2 8.138
R4533 XOR1_to_NAND4#1contact@766_metal-1-metal-2 XOR1_to_NAND4#1contact@766_metal-1-metal-2##0 6.717
R4534 XOR1_to_NAND4#1contact@766_metal-1-metal-2##0 XOR1_to_NAND4#1contact@766_metal-1-metal-2##1 6.717
R4535 XOR1_to_NAND4#1contact@766_metal-1-metal-2##1 XOR1_to_NAND4#12pin@655_polysilicon-1 6.717
R4536 XOR1_to_NAND4#10pin@654_polysilicon-1 XOR1_to_NAND4#10pin@654_polysilicon-1##0 7.75
R4537 XOR1_to_NAND4#10pin@654_polysilicon-1##0 XOR1_to_NAND4#10pin@654_polysilicon-1##1 7.75
R4538 XOR1_to_NAND4#10pin@654_polysilicon-1##1 XOR1_to_NAND4#12pin@655_polysilicon-1 7.75
R4539 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1##0 9.743
R4540 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1##0 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1##1 9.743
R4541 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1##1 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1##2 9.743
R4542 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1##2 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1##3 9.743
R4543 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1##3 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1##4 9.743
R4544 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1##4 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1##5 9.743
R4545 Cin_to_XOR2___NAND4#17pin@664_polysilicon-1##5 Cin_to_XOR2___NAND4 9.743
R4546 net@2108#7pmos@108_poly-left net@2108#7pmos@108_poly-left##0 7.75
R4547 net@2108#7pmos@108_poly-left##0 net@2108 7.75
R4548 Cin_to_XOR2___NAND4#18nmos@109_poly-left Cin_to_XOR2___NAND4#18nmos@109_poly-left##0 6.2
R4549 Cin_to_XOR2___NAND4#18nmos@109_poly-left##0 Cin_to_XOR2___NAND4#16pin@647_polysilicon-1 6.2
R4550 net@2118#9nmos@110_poly-left net@2118#9nmos@110_poly-left##0 8.37
R4551 net@2118#9nmos@110_poly-left##0 net@2118#9nmos@110_poly-left##1 8.37
R4552 net@2118#9nmos@110_poly-left##1 net@2118#9nmos@110_poly-left##2 8.37
R4553 net@2118#9nmos@110_poly-left##2 net@2118#9nmos@110_poly-left##3 8.37
R4554 net@2118#9nmos@110_poly-left##3 net@2118#2contact@727_metal-1-metal-2 8.37
R4555 XOR1_to_NAND4 XOR1_to_NAND4##0 6.717
R4556 XOR1_to_NAND4##0 XOR1_to_NAND4##1 6.717
R4557 XOR1_to_NAND4##1 XOR1_to_NAND4#14pin@671_polysilicon-1 6.717
R4558 XOR1_to_NAND4#16pmos@114_poly-right XOR1_to_NAND4#16pmos@114_poly-right##0 6.2
R4559 XOR1_to_NAND4#16pmos@114_poly-right##0 XOR1_to_NAND4#14pin@671_polysilicon-1 6.2
R4560 Cin_to_XOR2___NAND4#23pin@675_polysilicon-1 Cin_to_XOR2___NAND4#23pin@675_polysilicon-1##0 9.688
R4561 Cin_to_XOR2___NAND4#23pin@675_polysilicon-1##0 Cin_to_XOR2___NAND4#23pin@675_polysilicon-1##1 9.688
R4562 Cin_to_XOR2___NAND4#23pin@675_polysilicon-1##1 Cin_to_XOR2___NAND4#23pin@675_polysilicon-1##2 9.688
R4563 Cin_to_XOR2___NAND4#23pin@675_polysilicon-1##2 Cin_to_XOR2___NAND4#20contact@765_metal-1-metal-2 9.688
R4564 Cin_to_XOR2___NAND4#20contact@765_metal-1-metal-2 Cin_to_XOR2___NAND4 4.953
R4565 A3#0contact@774_metal-1-metal-2 A3#0contact@774_metal-1-metal-2##0 6.717
R4566 A3#0contact@774_metal-1-metal-2##0 A3#0contact@774_metal-1-metal-2##1 6.717
R4567 A3#0contact@774_metal-1-metal-2##1 A3#10pin@678_polysilicon-1 6.717
R4568 A3#11pmos@116_poly-right A3#11pmos@116_poly-right##0 9.558
R4569 A3#11pmos@116_poly-right##0 A3#11pmos@116_poly-right##1 9.558
R4570 A3#11pmos@116_poly-right##1 A3#11pmos@116_poly-right##2 9.558
R4571 A3#11pmos@116_poly-right##2 A3#11pmos@116_poly-right##3 9.558
R4572 A3#11pmos@116_poly-right##3 A3#11pmos@116_poly-right##4 9.558
R4573 A3#11pmos@116_poly-right##4 A3#10pin@678_polysilicon-1 9.558
R4574 B3#10pin@682_polysilicon-1 B3#10pin@682_polysilicon-1##0 8.138
R4575 B3#10pin@682_polysilicon-1##0 B3#10pin@682_polysilicon-1##1 8.138
R4576 B3#10pin@682_polysilicon-1##1 B3#10pin@682_polysilicon-1##2 8.138
R4577 B3#10pin@682_polysilicon-1##2 B3#0contact@775_metal-1-metal-2 8.138
R4578 B3#11nmos@104_poly-right B3#11nmos@104_poly-right##0 5.425
R4579 B3#11nmos@104_poly-right##0 B3#12pin@632_polysilicon-1 5.425
R4580 NAND2_to_Nand6 NAND2_to_Nand6##0 6.717
R4581 NAND2_to_Nand6##0 NAND2_to_Nand6##1 6.717
R4582 NAND2_to_Nand6##1 NAND2_to_Nand6#9pin@684_polysilicon-1 6.717
R4583 NAND2_to_Nand6#10pmos@118_poly-right NAND2_to_Nand6#10pmos@118_poly-right##0 9.558
R4584 NAND2_to_Nand6#10pmos@118_poly-right##0 NAND2_to_Nand6#10pmos@118_poly-right##1 9.558
R4585 NAND2_to_Nand6#10pmos@118_poly-right##1 NAND2_to_Nand6#10pmos@118_poly-right##2 9.558
R4586 NAND2_to_Nand6#10pmos@118_poly-right##2 NAND2_to_Nand6#10pmos@118_poly-right##3 9.558
R4587 NAND2_to_Nand6#10pmos@118_poly-right##3 NAND2_to_Nand6#10pmos@118_poly-right##4 9.558
R4588 NAND2_to_Nand6#10pmos@118_poly-right##4 NAND2_to_Nand6#9pin@684_polysilicon-1 9.558
R4589 B3#1pin@683_metal-2 B3#1pin@683_metal-2##0 8.99
R4590 B3#1pin@683_metal-2##0 B3#1pin@683_metal-2##1 8.99
R4591 B3#1pin@683_metal-2##1 B3#1pin@683_metal-2##2 8.99
R4592 B3#1pin@683_metal-2##2 B3#1pin@683_metal-2##3 8.99
R4593 B3#1pin@683_metal-2##3 B3#12pin@632_polysilicon-1 8.99
R4594 NAND1_to_NAND6#11pmos@119_poly-right NAND1_to_NAND6#11pmos@119_poly-right##0 5.425
R4595 NAND1_to_NAND6#11pmos@119_poly-right##0 NAND1_to_NAND6#12pin@688_polysilicon-1 5.425
R4596 NAND1_to_NAND6#12pin@688_polysilicon-1 NAND1_to_NAND6#12pin@688_polysilicon-1##0 9.3
R4597 NAND1_to_NAND6#12pin@688_polysilicon-1##0 NAND1_to_NAND6#12pin@688_polysilicon-1##1 9.3
R4598 NAND1_to_NAND6#12pin@688_polysilicon-1##1 NAND1_to_NAND6 9.3
R4599 Cin_to_XOR2___NAND4#25nmos@115_poly-right Cin_to_XOR2___NAND4#25nmos@115_poly-right##0 8.636
R4600 Cin_to_XOR2___NAND4#25nmos@115_poly-right##0 Cin_to_XOR2___NAND4#25nmos@115_poly-right##1 8.636
R4601 Cin_to_XOR2___NAND4#25nmos@115_poly-right##1 Cin_to_XOR2___NAND4#25nmos@115_poly-right##2 8.636
R4602 Cin_to_XOR2___NAND4#25nmos@115_poly-right##2 Cin_to_XOR2___NAND4#25nmos@115_poly-right##3 8.636
R4603 Cin_to_XOR2___NAND4#25nmos@115_poly-right##3 Cin_to_XOR2___NAND4#25nmos@115_poly-right##4 8.636
R4604 Cin_to_XOR2___NAND4#25nmos@115_poly-right##4 Cin_to_XOR2___NAND4#25nmos@115_poly-right##5 8.636
R4605 Cin_to_XOR2___NAND4#25nmos@115_poly-right##5 Cin_to_XOR2___NAND4#23pin@675_polysilicon-1 8.636
R4606 B3#13nmos@117_poly-right B3#13nmos@117_poly-right##0 8.956
R4607 B3#13nmos@117_poly-right##0 B3#13nmos@117_poly-right##1 8.956
R4608 B3#13nmos@117_poly-right##1 B3#13nmos@117_poly-right##2 8.956
R4609 B3#13nmos@117_poly-right##2 B3#13nmos@117_poly-right##3 8.956
R4610 B3#13nmos@117_poly-right##3 B3#13nmos@117_poly-right##4 8.956
R4611 B3#13nmos@117_poly-right##4 B3#13nmos@117_poly-right##5 8.956
R4612 B3#13nmos@117_poly-right##5 B3#13nmos@117_poly-right##6 8.956
R4613 B3#13nmos@117_poly-right##6 B3#13nmos@117_poly-right##7 8.956
R4614 B3#13nmos@117_poly-right##7 B3#10pin@682_polysilicon-1 8.956
R4615 A3#12pmos@100_poly-left A3#12pmos@100_poly-left##0 8.138
R4616 A3#12pmos@100_poly-left##0 A3#12pmos@100_poly-left##1 8.138
R4617 A3#12pmos@100_poly-left##1 A3#12pmos@100_poly-left##2 8.138
R4618 A3#12pmos@100_poly-left##2 A3#13pin@629_polysilicon-1 8.138
R4619 B3#14pin@622_polysilicon-1 B3#14pin@622_polysilicon-1##0 9.843
R4620 B3#14pin@622_polysilicon-1##0 B3#14pin@622_polysilicon-1##1 9.843
R4621 B3#14pin@622_polysilicon-1##1 B3#14pin@622_polysilicon-1##2 9.843
R4622 B3#14pin@622_polysilicon-1##2 B3#14pin@622_polysilicon-1##3 9.843
R4623 B3#14pin@622_polysilicon-1##3 B3#14pin@622_polysilicon-1##4 9.843
R4624 B3#14pin@622_polysilicon-1##4 B3#14pin@622_polysilicon-1##5 9.843
R4625 B3#14pin@622_polysilicon-1##5 B3#14pin@622_polysilicon-1##6 9.843
R4626 B3#14pin@622_polysilicon-1##6 B3#14pin@622_polysilicon-1##7 9.843
R4627 B3#14pin@622_polysilicon-1##7 B3#14pin@622_polysilicon-1##8 9.843
R4628 B3#14pin@622_polysilicon-1##8 B3#14pin@622_polysilicon-1##9 9.843
R4629 B3#14pin@622_polysilicon-1##9 B3#14pin@622_polysilicon-1##10 9.843
R4630 B3#14pin@622_polysilicon-1##10 B3#14pin@622_polysilicon-1##11 9.843
R4631 B3#14pin@622_polysilicon-1##11 B3#14pin@622_polysilicon-1##12 9.843
R4632 B3#14pin@622_polysilicon-1##12 B3#14pin@622_polysilicon-1##13 9.843
R4633 B3#14pin@622_polysilicon-1##13 B3#14pin@622_polysilicon-1##14 9.843
R4634 B3#14pin@622_polysilicon-1##14 B3#14pin@622_polysilicon-1##15 9.843
R4635 B3#14pin@622_polysilicon-1##15 B3#14pin@622_polysilicon-1##16 9.843
R4636 B3#14pin@622_polysilicon-1##16 B3#14pin@622_polysilicon-1##17 9.843
R4637 B3#14pin@622_polysilicon-1##17 B3#14pin@622_polysilicon-1##18 9.843
R4638 B3#14pin@622_polysilicon-1##18 B3#15pin@639_polysilicon-1 9.843
R4639 net@2204#4nmos@106_poly-right net@2204#4nmos@106_poly-right##0 7.233
R4640 net@2204#4nmos@106_poly-right##0 net@2204#4nmos@106_poly-right##1 7.233
R4641 net@2204#4nmos@106_poly-right##1 net@2204#5pin@634_polysilicon-1 7.233
R4642 net@2204#2contact@713_metal-1-polysilicon-1 net@2204#2contact@713_metal-1-polysilicon-1##0 8.99
R4643 net@2204#2contact@713_metal-1-polysilicon-1##0 net@2204#2contact@713_metal-1-polysilicon-1##1 8.99
R4644 net@2204#2contact@713_metal-1-polysilicon-1##1 net@2204#2contact@713_metal-1-polysilicon-1##2 8.99
R4645 net@2204#2contact@713_metal-1-polysilicon-1##2 net@2204#2contact@713_metal-1-polysilicon-1##3 8.99
R4646 net@2204#2contact@713_metal-1-polysilicon-1##3 net@2204#5pin@634_polysilicon-1 8.99
R4647 A3#1pin@681_metal-2 A3#1pin@681_metal-2##0 6.717
R4648 A3#1pin@681_metal-2##0 A3#1pin@681_metal-2##1 6.717
R4649 A3#1pin@681_metal-2##1 A3#15pin@630_polysilicon-1 6.717
R4650 A3#13pin@629_polysilicon-1 A3#13pin@629_polysilicon-1##0 7.75
R4651 A3#13pin@629_polysilicon-1##0 A3#13pin@629_polysilicon-1##1 7.75
R4652 A3#13pin@629_polysilicon-1##1 A3#15pin@630_polysilicon-1 7.75
R4653 B3#15pin@639_polysilicon-1 B3#15pin@639_polysilicon-1##0 9.743
R4654 B3#15pin@639_polysilicon-1##0 B3#15pin@639_polysilicon-1##1 9.743
R4655 B3#15pin@639_polysilicon-1##1 B3#15pin@639_polysilicon-1##2 9.743
R4656 B3#15pin@639_polysilicon-1##2 B3#15pin@639_polysilicon-1##3 9.743
R4657 B3#15pin@639_polysilicon-1##3 B3#15pin@639_polysilicon-1##4 9.743
R4658 B3#15pin@639_polysilicon-1##4 B3#15pin@639_polysilicon-1##5 9.743
R4659 B3#15pin@639_polysilicon-1##5 B3#1pin@683_metal-2 9.743
R4660 net@2106#7pmos@101_poly-left net@2106#7pmos@101_poly-left##0 7.75
R4661 net@2106#7pmos@101_poly-left##0 net@2106 7.75
R4662 B3#16nmos@102_poly-left B3#16nmos@102_poly-left##0 6.2
R4663 B3#16nmos@102_poly-left##0 B3#14pin@622_polysilicon-1 6.2
R4664 net@2211#9nmos@103_poly-left net@2211#9nmos@103_poly-left##0 8.37
R4665 net@2211#9nmos@103_poly-left##0 net@2211#9nmos@103_poly-left##1 8.37
R4666 net@2211#9nmos@103_poly-left##1 net@2211#9nmos@103_poly-left##2 8.37
R4667 net@2211#9nmos@103_poly-left##2 net@2211#9nmos@103_poly-left##3 8.37
R4668 net@2211#9nmos@103_poly-left##3 net@2211#2contact@689_metal-1-metal-2 8.37
R4669 A3#3pin@642_polysilicon-1 A3#3pin@642_polysilicon-1##0 9.881
R4670 A3#3pin@642_polysilicon-1##0 A3#3pin@642_polysilicon-1##1 9.881
R4671 A3#3pin@642_polysilicon-1##1 A3#3pin@642_polysilicon-1##2 9.881
R4672 A3#3pin@642_polysilicon-1##2 A3#3pin@642_polysilicon-1##3 9.881
R4673 A3#3pin@642_polysilicon-1##3 A3#3pin@642_polysilicon-1##4 9.881
R4674 A3#3pin@642_polysilicon-1##4 A3#3pin@642_polysilicon-1##5 9.881
R4675 A3#3pin@642_polysilicon-1##5 A3#3pin@642_polysilicon-1##6 9.881
R4676 A3#3pin@642_polysilicon-1##6 A3#3pin@642_polysilicon-1##7 9.881
R4677 A3#3pin@642_polysilicon-1##7 A3#3pin@642_polysilicon-1##8 9.881
R4678 A3#3pin@642_polysilicon-1##8 A3#3pin@642_polysilicon-1##9 9.881
R4679 A3#3pin@642_polysilicon-1##9 A3#3pin@642_polysilicon-1##10 9.881
R4680 A3#3pin@642_polysilicon-1##10 A3#3pin@642_polysilicon-1##11 9.881
R4681 A3#3pin@642_polysilicon-1##11 A3#3pin@642_polysilicon-1##12 9.881
R4682 A3#3pin@642_polysilicon-1##12 A3#3pin@642_polysilicon-1##13 9.881
R4683 A3#3pin@642_polysilicon-1##13 A3#3pin@642_polysilicon-1##14 9.881
R4684 A3#3pin@642_polysilicon-1##14 A3#3pin@642_polysilicon-1##15 9.881
R4685 A3#3pin@642_polysilicon-1##15 A3#3pin@642_polysilicon-1##16 9.881
R4686 A3#3pin@642_polysilicon-1##16 A3#3pin@642_polysilicon-1##17 9.881
R4687 A3#3pin@642_polysilicon-1##17 A3#3pin@642_polysilicon-1##18 9.881
R4688 A3#3pin@642_polysilicon-1##18 A3#3pin@642_polysilicon-1##19 9.881
R4689 A3#3pin@642_polysilicon-1##19 A3#3pin@642_polysilicon-1##20 9.881
R4690 A3#3pin@642_polysilicon-1##20 A3#3pin@642_polysilicon-1##21 9.881
R4691 A3#3pin@642_polysilicon-1##21 A3#3pin@642_polysilicon-1##22 9.881
R4692 A3#3pin@642_polysilicon-1##22 A3#3pin@642_polysilicon-1##23 9.881
R4693 A3#3pin@642_polysilicon-1##23 A3#3pin@642_polysilicon-1##24 9.881
R4694 A3#3pin@642_polysilicon-1##24 A3#3pin@642_polysilicon-1##25 9.881
R4695 A3#3pin@642_polysilicon-1##25 A3#3pin@642_polysilicon-1##26 9.881
R4696 A3#3pin@642_polysilicon-1##26 A3#3pin@642_polysilicon-1##27 9.881
R4697 A3#3pin@642_polysilicon-1##27 A3#3pin@642_polysilicon-1##28 9.881
R4698 A3#3pin@642_polysilicon-1##28 A3#3pin@642_polysilicon-1##29 9.881
R4699 A3#3pin@642_polysilicon-1##29 A3#3pin@642_polysilicon-1##30 9.881
R4700 A3#3pin@642_polysilicon-1##30 A3#3pin@642_polysilicon-1##31 9.881
R4701 A3#3pin@642_polysilicon-1##31 A3#3pin@642_polysilicon-1##32 9.881
R4702 A3#3pin@642_polysilicon-1##32 A3#3pin@642_polysilicon-1##33 9.881
R4703 A3#3pin@642_polysilicon-1##33 A3#3pin@642_polysilicon-1##34 9.881
R4704 A3#3pin@642_polysilicon-1##34 A3#3pin@642_polysilicon-1##35 9.881
R4705 A3#3pin@642_polysilicon-1##35 A3#3pin@642_polysilicon-1##36 9.881
R4706 A3#3pin@642_polysilicon-1##36 A3#3pin@642_polysilicon-1##37 9.881
R4707 A3#3pin@642_polysilicon-1##37 A3#3pin@642_polysilicon-1##38 9.881
R4708 A3#3pin@642_polysilicon-1##38 A3#3pin@642_polysilicon-1##39 9.881
R4709 A3#3pin@642_polysilicon-1##39 A3#3pin@642_polysilicon-1##40 9.881
R4710 A3#3pin@642_polysilicon-1##40 A3#3pin@642_polysilicon-1##41 9.881
R4711 A3#3pin@642_polysilicon-1##41 A3#3pin@642_polysilicon-1##42 9.881
R4712 A3#3pin@642_polysilicon-1##42 A3#3pin@642_polysilicon-1##43 9.881
R4713 A3#3pin@642_polysilicon-1##43 A3#3pin@642_polysilicon-1##44 9.881
R4714 A3#3pin@642_polysilicon-1##44 A3#3pin@642_polysilicon-1##45 9.881
R4715 A3#3pin@642_polysilicon-1##45 A3#3pin@642_polysilicon-1##46 9.881
R4716 A3#3pin@642_polysilicon-1##46 A3#3pin@642_polysilicon-1##47 9.881
R4717 A3#3pin@642_polysilicon-1##47 A3#3pin@642_polysilicon-1##48 9.881
R4718 A3#3pin@642_polysilicon-1##48 A3#3pin@642_polysilicon-1##49 9.881
R4719 A3#3pin@642_polysilicon-1##49 A3#3pin@642_polysilicon-1##50 9.881
R4720 A3#3pin@642_polysilicon-1##50 A3#3pin@642_polysilicon-1##51 9.881
R4721 A3#3pin@642_polysilicon-1##51 A3#3pin@642_polysilicon-1##52 9.881
R4722 A3#3pin@642_polysilicon-1##52 A3#3pin@642_polysilicon-1##53 9.881
R4723 A3#3pin@642_polysilicon-1##53 A3#3pin@642_polysilicon-1##54 9.881
R4724 A3#3pin@642_polysilicon-1##54 A3#16nmos@105_poly-right 9.881
R4725 net@2106#5pmos@105_diff-top net@2106#2pin@631_metal-1 4.81
R4726 net@2106#1pin@641_polysilicon-1 net@2106#1pin@641_polysilicon-1##0 9.85
R4727 net@2106#1pin@641_polysilicon-1##0 net@2106#1pin@641_polysilicon-1##1 9.85
R4728 net@2106#1pin@641_polysilicon-1##1 net@2106#1pin@641_polysilicon-1##2 9.85
R4729 net@2106#1pin@641_polysilicon-1##2 net@2106#1pin@641_polysilicon-1##3 9.85
R4730 net@2106#1pin@641_polysilicon-1##3 net@2106#1pin@641_polysilicon-1##4 9.85
R4731 net@2106#1pin@641_polysilicon-1##4 net@2106#1pin@641_polysilicon-1##5 9.85
R4732 net@2106#1pin@641_polysilicon-1##5 net@2106#1pin@641_polysilicon-1##6 9.85
R4733 net@2106#1pin@641_polysilicon-1##6 net@2106#1pin@641_polysilicon-1##7 9.85
R4734 net@2106#1pin@641_polysilicon-1##7 net@2106#1pin@641_polysilicon-1##8 9.85
R4735 net@2106#1pin@641_polysilicon-1##8 net@2106#1pin@641_polysilicon-1##9 9.85
R4736 net@2106#1pin@641_polysilicon-1##9 net@2106#1pin@641_polysilicon-1##10 9.85
R4737 net@2106#1pin@641_polysilicon-1##10 net@2106#1pin@641_polysilicon-1##11 9.85
R4738 net@2106#1pin@641_polysilicon-1##11 net@2106#1pin@641_polysilicon-1##12 9.85
R4739 net@2106#1pin@641_polysilicon-1##12 net@2106#1pin@641_polysilicon-1##13 9.85
R4740 net@2106#1pin@641_polysilicon-1##13 net@2106#1pin@641_polysilicon-1##14 9.85
R4741 net@2106#1pin@641_polysilicon-1##14 net@2106#1pin@641_polysilicon-1##15 9.85
R4742 net@2106#1pin@641_polysilicon-1##15 net@2106#1pin@641_polysilicon-1##16 9.85
R4743 net@2106#1pin@641_polysilicon-1##16 net@2106#1pin@641_polysilicon-1##17 9.85
R4744 net@2106#1pin@641_polysilicon-1##17 net@2106#1pin@641_polysilicon-1##18 9.85
R4745 net@2106#1pin@641_polysilicon-1##18 net@2106#1pin@641_polysilicon-1##19 9.85
R4746 net@2106#1pin@641_polysilicon-1##19 net@2106#1pin@641_polysilicon-1##20 9.85
R4747 net@2106#1pin@641_polysilicon-1##20 net@2106#1pin@641_polysilicon-1##21 9.85
R4748 net@2106#1pin@641_polysilicon-1##21 net@2106#1pin@641_polysilicon-1##22 9.85
R4749 net@2106#1pin@641_polysilicon-1##22 net@2106#1pin@641_polysilicon-1##23 9.85
R4750 net@2106#1pin@641_polysilicon-1##23 net@2106#1pin@641_polysilicon-1##24 9.85
R4751 net@2106#1pin@641_polysilicon-1##24 net@2106#1pin@641_polysilicon-1##25 9.85
R4752 net@2106#1pin@641_polysilicon-1##25 net@2106#1pin@641_polysilicon-1##26 9.85
R4753 net@2106#1pin@641_polysilicon-1##26 net@2106#1pin@641_polysilicon-1##27 9.85
R4754 net@2106#1pin@641_polysilicon-1##27 net@2106#1pin@641_polysilicon-1##28 9.85
R4755 net@2106#1pin@641_polysilicon-1##28 net@2106#1pin@641_polysilicon-1##29 9.85
R4756 net@2106#1pin@641_polysilicon-1##29 net@2106#1pin@641_polysilicon-1##30 9.85
R4757 net@2106#1pin@641_polysilicon-1##30 net@2106#1pin@641_polysilicon-1##31 9.85
R4758 net@2106#1pin@641_polysilicon-1##31 net@2106#1pin@641_polysilicon-1##32 9.85
R4759 net@2106#1pin@641_polysilicon-1##32 net@2106#1pin@641_polysilicon-1##33 9.85
R4760 net@2106#1pin@641_polysilicon-1##33 net@2106#1pin@641_polysilicon-1##34 9.85
R4761 net@2106#1pin@641_polysilicon-1##34 net@2106#1pin@641_polysilicon-1##35 9.85
R4762 net@2106#1pin@641_polysilicon-1##35 net@2106#1pin@641_polysilicon-1##36 9.85
R4763 net@2106#1pin@641_polysilicon-1##36 net@2106#1pin@641_polysilicon-1##37 9.85
R4764 net@2106#1pin@641_polysilicon-1##37 net@2106#1pin@641_polysilicon-1##38 9.85
R4765 net@2106#1pin@641_polysilicon-1##38 net@2106#1pin@641_polysilicon-1##39 9.85
R4766 net@2106#1pin@641_polysilicon-1##39 net@2106#1pin@641_polysilicon-1##40 9.85
R4767 net@2106#1pin@641_polysilicon-1##40 net@2106#1pin@641_polysilicon-1##41 9.85
R4768 net@2106#1pin@641_polysilicon-1##41 net@2106#1pin@641_polysilicon-1##42 9.85
R4769 net@2106#1pin@641_polysilicon-1##42 net@2106#1pin@641_polysilicon-1##43 9.85
R4770 net@2106#1pin@641_polysilicon-1##43 net@2106#1pin@641_polysilicon-1##44 9.85
R4771 net@2106#1pin@641_polysilicon-1##44 net@2106#1pin@641_polysilicon-1##45 9.85
R4772 net@2106#1pin@641_polysilicon-1##45 net@2106#1pin@641_polysilicon-1##46 9.85
R4773 net@2106#1pin@641_polysilicon-1##46 net@2106#1pin@641_polysilicon-1##47 9.85
R4774 net@2106#1pin@641_polysilicon-1##47 net@2106#1pin@641_polysilicon-1##48 9.85
R4775 net@2106#1pin@641_polysilicon-1##48 net@2106#1pin@641_polysilicon-1##49 9.85
R4776 net@2106#1pin@641_polysilicon-1##49 net@2106#1pin@641_polysilicon-1##50 9.85
R4777 net@2106#1pin@641_polysilicon-1##50 net@2106#1pin@641_polysilicon-1##51 9.85
R4778 net@2106#1pin@641_polysilicon-1##51 net@2106#1pin@641_polysilicon-1##52 9.85
R4779 net@2106#1pin@641_polysilicon-1##52 net@2106#1pin@641_polysilicon-1##53 9.85
R4780 net@2106#1pin@641_polysilicon-1##53 net@2106#1pin@641_polysilicon-1##54 9.85
R4781 net@2106#1pin@641_polysilicon-1##54 net@2106#1pin@641_polysilicon-1##55 9.85
R4782 net@2106#1pin@641_polysilicon-1##55 net@2106#1pin@641_polysilicon-1##56 9.85
R4783 net@2106#1pin@641_polysilicon-1##56 net@2106#1pin@641_polysilicon-1##57 9.85
R4784 net@2106#1pin@641_polysilicon-1##57 net@2106#1pin@641_polysilicon-1##58 9.85
R4785 net@2106#1pin@641_polysilicon-1##58 net@2106#1pin@641_polysilicon-1##59 9.85
R4786 net@2106#1pin@641_polysilicon-1##59 net@2106#1pin@641_polysilicon-1##60 9.85
R4787 net@2106#1pin@641_polysilicon-1##60 net@2106#2pin@631_metal-1 9.85
R4788 B3#17pmos@104_poly-right B3#17pmos@104_poly-right##0 9.854
R4789 B3#17pmos@104_poly-right##0 B3#17pmos@104_poly-right##1 9.854
R4790 B3#17pmos@104_poly-right##1 B3#17pmos@104_poly-right##2 9.854
R4791 B3#17pmos@104_poly-right##2 B3#17pmos@104_poly-right##3 9.854
R4792 B3#17pmos@104_poly-right##3 B3#17pmos@104_poly-right##4 9.854
R4793 B3#17pmos@104_poly-right##4 B3#17pmos@104_poly-right##5 9.854
R4794 B3#17pmos@104_poly-right##5 B3#17pmos@104_poly-right##6 9.854
R4795 B3#17pmos@104_poly-right##6 B3#17pmos@104_poly-right##7 9.854
R4796 B3#17pmos@104_poly-right##7 B3#17pmos@104_poly-right##8 9.854
R4797 B3#17pmos@104_poly-right##8 B3#17pmos@104_poly-right##9 9.854
R4798 B3#17pmos@104_poly-right##9 B3#17pmos@104_poly-right##10 9.854
R4799 B3#17pmos@104_poly-right##10 B3#17pmos@104_poly-right##11 9.854
R4800 B3#17pmos@104_poly-right##11 B3#17pmos@104_poly-right##12 9.854
R4801 B3#17pmos@104_poly-right##12 B3#17pmos@104_poly-right##13 9.854
R4802 B3#17pmos@104_poly-right##13 B3#17pmos@104_poly-right##14 9.854
R4803 B3#17pmos@104_poly-right##14 B3#17pmos@104_poly-right##15 9.854
R4804 B3#17pmos@104_poly-right##15 B3#17pmos@104_poly-right##16 9.854
R4805 B3#17pmos@104_poly-right##16 B3#17pmos@104_poly-right##17 9.854
R4806 B3#17pmos@104_poly-right##17 B3#17pmos@104_poly-right##18 9.854
R4807 B3#17pmos@104_poly-right##18 B3#17pmos@104_poly-right##19 9.854
R4808 B3#17pmos@104_poly-right##19 B3#17pmos@104_poly-right##20 9.854
R4809 B3#17pmos@104_poly-right##20 B3#17pmos@104_poly-right##21 9.854
R4810 B3#17pmos@104_poly-right##21 B3#17pmos@104_poly-right##22 9.854
R4811 B3#17pmos@104_poly-right##22 B3#17pmos@104_poly-right##23 9.854
R4812 B3#17pmos@104_poly-right##23 B3#17pmos@104_poly-right##24 9.854
R4813 B3#17pmos@104_poly-right##24 B3#17pmos@104_poly-right##25 9.854
R4814 B3#17pmos@104_poly-right##25 B3#17pmos@104_poly-right##26 9.854
R4815 B3#17pmos@104_poly-right##26 B3#17pmos@104_poly-right##27 9.854
R4816 B3#17pmos@104_poly-right##27 B3#17pmos@104_poly-right##28 9.854
R4817 B3#17pmos@104_poly-right##28 B3#17pmos@104_poly-right##29 9.854
R4818 B3#17pmos@104_poly-right##29 B3#17pmos@104_poly-right##30 9.854
R4819 B3#17pmos@104_poly-right##30 B3#17pmos@104_poly-right##31 9.854
R4820 B3#17pmos@104_poly-right##31 B3#17pmos@104_poly-right##32 9.854
R4821 B3#17pmos@104_poly-right##32 B3#17pmos@104_poly-right##33 9.854
R4822 B3#17pmos@104_poly-right##33 B3#17pmos@104_poly-right##34 9.854
R4823 B3#17pmos@104_poly-right##34 B3#17pmos@104_poly-right##35 9.854
R4824 B3#17pmos@104_poly-right##35 B3#17pmos@104_poly-right##36 9.854
R4825 B3#17pmos@104_poly-right##36 B3#17pmos@104_poly-right##37 9.854
R4826 B3#17pmos@104_poly-right##37 B3#17pmos@104_poly-right##38 9.854
R4827 B3#17pmos@104_poly-right##38 B3#17pmos@104_poly-right##39 9.854
R4828 B3#17pmos@104_poly-right##39 B3#17pmos@104_poly-right##40 9.854
R4829 B3#17pmos@104_poly-right##40 B3#17pmos@104_poly-right##41 9.854
R4830 B3#17pmos@104_poly-right##41 B3#17pmos@104_poly-right##42 9.854
R4831 B3#17pmos@104_poly-right##42 B3#17pmos@104_poly-right##43 9.854
R4832 B3#17pmos@104_poly-right##43 B3#17pmos@104_poly-right##44 9.854
R4833 B3#17pmos@104_poly-right##44 B3#17pmos@104_poly-right##45 9.854
R4834 B3#17pmos@104_poly-right##45 B3#17pmos@104_poly-right##46 9.854
R4835 B3#17pmos@104_poly-right##46 B3#17pmos@104_poly-right##47 9.854
R4836 B3#17pmos@104_poly-right##47 B3#17pmos@104_poly-right##48 9.854
R4837 B3#17pmos@104_poly-right##48 B3#17pmos@104_poly-right##49 9.854
R4838 B3#17pmos@104_poly-right##49 B3#17pmos@104_poly-right##50 9.854
R4839 B3#17pmos@104_poly-right##50 B3#17pmos@104_poly-right##51 9.854
R4840 B3#17pmos@104_poly-right##51 B3#17pmos@104_poly-right##52 9.854
R4841 B3#17pmos@104_poly-right##52 B3#17pmos@104_poly-right##53 9.854
R4842 B3#17pmos@104_poly-right##53 B3#17pmos@104_poly-right##54 9.854
R4843 B3#17pmos@104_poly-right##54 B3#12pin@632_polysilicon-1 9.854
R4844 net@2211 net@2211#2contact@689_metal-1-metal-2 4.797
R4845 A3#17nmos@100_poly-right A3#17nmos@100_poly-right##0 9.871
R4846 A3#17nmos@100_poly-right##0 A3#17nmos@100_poly-right##1 9.871
R4847 A3#17nmos@100_poly-right##1 A3#17nmos@100_poly-right##2 9.871
R4848 A3#17nmos@100_poly-right##2 A3#17nmos@100_poly-right##3 9.871
R4849 A3#17nmos@100_poly-right##3 A3#17nmos@100_poly-right##4 9.871
R4850 A3#17nmos@100_poly-right##4 A3#17nmos@100_poly-right##5 9.871
R4851 A3#17nmos@100_poly-right##5 A3#17nmos@100_poly-right##6 9.871
R4852 A3#17nmos@100_poly-right##6 A3#17nmos@100_poly-right##7 9.871
R4853 A3#17nmos@100_poly-right##7 A3#17nmos@100_poly-right##8 9.871
R4854 A3#17nmos@100_poly-right##8 A3#17nmos@100_poly-right##9 9.871
R4855 A3#17nmos@100_poly-right##9 A3#17nmos@100_poly-right##10 9.871
R4856 A3#17nmos@100_poly-right##10 A3#17nmos@100_poly-right##11 9.871
R4857 A3#17nmos@100_poly-right##11 A3#17nmos@100_poly-right##12 9.871
R4858 A3#17nmos@100_poly-right##12 A3#17nmos@100_poly-right##13 9.871
R4859 A3#17nmos@100_poly-right##13 A3#17nmos@100_poly-right##14 9.871
R4860 A3#17nmos@100_poly-right##14 A3#17nmos@100_poly-right##15 9.871
R4861 A3#17nmos@100_poly-right##15 A3#17nmos@100_poly-right##16 9.871
R4862 A3#17nmos@100_poly-right##16 A3#17nmos@100_poly-right##17 9.871
R4863 A3#17nmos@100_poly-right##17 A3#17nmos@100_poly-right##18 9.871
R4864 A3#17nmos@100_poly-right##18 A3#17nmos@100_poly-right##19 9.871
R4865 A3#17nmos@100_poly-right##19 A3#17nmos@100_poly-right##20 9.871
R4866 A3#17nmos@100_poly-right##20 A3#17nmos@100_poly-right##21 9.871
R4867 A3#17nmos@100_poly-right##21 A3#17nmos@100_poly-right##22 9.871
R4868 A3#17nmos@100_poly-right##22 A3#17nmos@100_poly-right##23 9.871
R4869 A3#17nmos@100_poly-right##23 A3#17nmos@100_poly-right##24 9.871
R4870 A3#17nmos@100_poly-right##24 A3#17nmos@100_poly-right##25 9.871
R4871 A3#17nmos@100_poly-right##25 A3#17nmos@100_poly-right##26 9.871
R4872 A3#17nmos@100_poly-right##26 A3#17nmos@100_poly-right##27 9.871
R4873 A3#17nmos@100_poly-right##27 A3#17nmos@100_poly-right##28 9.871
R4874 A3#17nmos@100_poly-right##28 A3#17nmos@100_poly-right##29 9.871
R4875 A3#17nmos@100_poly-right##29 A3#17nmos@100_poly-right##30 9.871
R4876 A3#17nmos@100_poly-right##30 A3#17nmos@100_poly-right##31 9.871
R4877 A3#17nmos@100_poly-right##31 A3#17nmos@100_poly-right##32 9.871
R4878 A3#17nmos@100_poly-right##32 A3#17nmos@100_poly-right##33 9.871
R4879 A3#17nmos@100_poly-right##33 A3#17nmos@100_poly-right##34 9.871
R4880 A3#17nmos@100_poly-right##34 A3#17nmos@100_poly-right##35 9.871
R4881 A3#17nmos@100_poly-right##35 A3#17nmos@100_poly-right##36 9.871
R4882 A3#17nmos@100_poly-right##36 A3#17nmos@100_poly-right##37 9.871
R4883 A3#17nmos@100_poly-right##37 A3#17nmos@100_poly-right##38 9.871
R4884 A3#17nmos@100_poly-right##38 A3#17nmos@100_poly-right##39 9.871
R4885 A3#17nmos@100_poly-right##39 A3#17nmos@100_poly-right##40 9.871
R4886 A3#17nmos@100_poly-right##40 A3#17nmos@100_poly-right##41 9.871
R4887 A3#17nmos@100_poly-right##41 A3#17nmos@100_poly-right##42 9.871
R4888 A3#17nmos@100_poly-right##42 A3#17nmos@100_poly-right##43 9.871
R4889 A3#17nmos@100_poly-right##43 A3#17nmos@100_poly-right##44 9.871
R4890 A3#17nmos@100_poly-right##44 A3#17nmos@100_poly-right##45 9.871
R4891 A3#17nmos@100_poly-right##45 A3#17nmos@100_poly-right##46 9.871
R4892 A3#17nmos@100_poly-right##46 A3#17nmos@100_poly-right##47 9.871
R4893 A3#17nmos@100_poly-right##47 A3#17nmos@100_poly-right##48 9.871
R4894 A3#17nmos@100_poly-right##48 A3#17nmos@100_poly-right##49 9.871
R4895 A3#17nmos@100_poly-right##49 A3#17nmos@100_poly-right##50 9.871
R4896 A3#17nmos@100_poly-right##50 A3#17nmos@100_poly-right##51 9.871
R4897 A3#17nmos@100_poly-right##51 A3#17nmos@100_poly-right##52 9.871
R4898 A3#17nmos@100_poly-right##52 A3#17nmos@100_poly-right##53 9.871
R4899 A3#17nmos@100_poly-right##53 A3#17nmos@100_poly-right##54 9.871
R4900 A3#17nmos@100_poly-right##54 A3#17nmos@100_poly-right##55 9.871
R4901 A3#17nmos@100_poly-right##55 A3#12pmos@100_poly-left 9.871
R4902 net@2106#7pmos@101_poly-left net@2106#7pmos@101_poly-left##0 9.871
R4903 net@2106#7pmos@101_poly-left##0 net@2106#7pmos@101_poly-left##1 9.871
R4904 net@2106#7pmos@101_poly-left##1 net@2106#7pmos@101_poly-left##2 9.871
R4905 net@2106#7pmos@101_poly-left##2 net@2106#7pmos@101_poly-left##3 9.871
R4906 net@2106#7pmos@101_poly-left##3 net@2106#7pmos@101_poly-left##4 9.871
R4907 net@2106#7pmos@101_poly-left##4 net@2106#7pmos@101_poly-left##5 9.871
R4908 net@2106#7pmos@101_poly-left##5 net@2106#7pmos@101_poly-left##6 9.871
R4909 net@2106#7pmos@101_poly-left##6 net@2106#7pmos@101_poly-left##7 9.871
R4910 net@2106#7pmos@101_poly-left##7 net@2106#7pmos@101_poly-left##8 9.871
R4911 net@2106#7pmos@101_poly-left##8 net@2106#7pmos@101_poly-left##9 9.871
R4912 net@2106#7pmos@101_poly-left##9 net@2106#7pmos@101_poly-left##10 9.871
R4913 net@2106#7pmos@101_poly-left##10 net@2106#7pmos@101_poly-left##11 9.871
R4914 net@2106#7pmos@101_poly-left##11 net@2106#7pmos@101_poly-left##12 9.871
R4915 net@2106#7pmos@101_poly-left##12 net@2106#7pmos@101_poly-left##13 9.871
R4916 net@2106#7pmos@101_poly-left##13 net@2106#7pmos@101_poly-left##14 9.871
R4917 net@2106#7pmos@101_poly-left##14 net@2106#7pmos@101_poly-left##15 9.871
R4918 net@2106#7pmos@101_poly-left##15 net@2106#7pmos@101_poly-left##16 9.871
R4919 net@2106#7pmos@101_poly-left##16 net@2106#7pmos@101_poly-left##17 9.871
R4920 net@2106#7pmos@101_poly-left##17 net@2106#7pmos@101_poly-left##18 9.871
R4921 net@2106#7pmos@101_poly-left##18 net@2106#7pmos@101_poly-left##19 9.871
R4922 net@2106#7pmos@101_poly-left##19 net@2106#7pmos@101_poly-left##20 9.871
R4923 net@2106#7pmos@101_poly-left##20 net@2106#7pmos@101_poly-left##21 9.871
R4924 net@2106#7pmos@101_poly-left##21 net@2106#7pmos@101_poly-left##22 9.871
R4925 net@2106#7pmos@101_poly-left##22 net@2106#7pmos@101_poly-left##23 9.871
R4926 net@2106#7pmos@101_poly-left##23 net@2106#7pmos@101_poly-left##24 9.871
R4927 net@2106#7pmos@101_poly-left##24 net@2106#7pmos@101_poly-left##25 9.871
R4928 net@2106#7pmos@101_poly-left##25 net@2106#7pmos@101_poly-left##26 9.871
R4929 net@2106#7pmos@101_poly-left##26 net@2106#7pmos@101_poly-left##27 9.871
R4930 net@2106#7pmos@101_poly-left##27 net@2106#7pmos@101_poly-left##28 9.871
R4931 net@2106#7pmos@101_poly-left##28 net@2106#7pmos@101_poly-left##29 9.871
R4932 net@2106#7pmos@101_poly-left##29 net@2106#7pmos@101_poly-left##30 9.871
R4933 net@2106#7pmos@101_poly-left##30 net@2106#7pmos@101_poly-left##31 9.871
R4934 net@2106#7pmos@101_poly-left##31 net@2106#7pmos@101_poly-left##32 9.871
R4935 net@2106#7pmos@101_poly-left##32 net@2106#7pmos@101_poly-left##33 9.871
R4936 net@2106#7pmos@101_poly-left##33 net@2106#7pmos@101_poly-left##34 9.871
R4937 net@2106#7pmos@101_poly-left##34 net@2106#7pmos@101_poly-left##35 9.871
R4938 net@2106#7pmos@101_poly-left##35 net@2106#7pmos@101_poly-left##36 9.871
R4939 net@2106#7pmos@101_poly-left##36 net@2106#7pmos@101_poly-left##37 9.871
R4940 net@2106#7pmos@101_poly-left##37 net@2106#7pmos@101_poly-left##38 9.871
R4941 net@2106#7pmos@101_poly-left##38 net@2106#7pmos@101_poly-left##39 9.871
R4942 net@2106#7pmos@101_poly-left##39 net@2106#7pmos@101_poly-left##40 9.871
R4943 net@2106#7pmos@101_poly-left##40 net@2106#7pmos@101_poly-left##41 9.871
R4944 net@2106#7pmos@101_poly-left##41 net@2106#7pmos@101_poly-left##42 9.871
R4945 net@2106#7pmos@101_poly-left##42 net@2106#7pmos@101_poly-left##43 9.871
R4946 net@2106#7pmos@101_poly-left##43 net@2106#7pmos@101_poly-left##44 9.871
R4947 net@2106#7pmos@101_poly-left##44 net@2106#7pmos@101_poly-left##45 9.871
R4948 net@2106#7pmos@101_poly-left##45 net@2106#7pmos@101_poly-left##46 9.871
R4949 net@2106#7pmos@101_poly-left##46 net@2106#7pmos@101_poly-left##47 9.871
R4950 net@2106#7pmos@101_poly-left##47 net@2106#7pmos@101_poly-left##48 9.871
R4951 net@2106#7pmos@101_poly-left##48 net@2106#7pmos@101_poly-left##49 9.871
R4952 net@2106#7pmos@101_poly-left##49 net@2106#7pmos@101_poly-left##50 9.871
R4953 net@2106#7pmos@101_poly-left##50 net@2106#7pmos@101_poly-left##51 9.871
R4954 net@2106#7pmos@101_poly-left##51 net@2106#7pmos@101_poly-left##52 9.871
R4955 net@2106#7pmos@101_poly-left##52 net@2106#7pmos@101_poly-left##53 9.871
R4956 net@2106#7pmos@101_poly-left##53 net@2106#7pmos@101_poly-left##54 9.871
R4957 net@2106#7pmos@101_poly-left##54 net@2106#7pmos@101_poly-left##55 9.871
R4958 net@2106#7pmos@101_poly-left##55 net@2106#11nmos@101_poly-right 9.871
R4959 B3#18pmos@102_poly-right B3#18pmos@102_poly-right##0 9.871
R4960 B3#18pmos@102_poly-right##0 B3#18pmos@102_poly-right##1 9.871
R4961 B3#18pmos@102_poly-right##1 B3#18pmos@102_poly-right##2 9.871
R4962 B3#18pmos@102_poly-right##2 B3#18pmos@102_poly-right##3 9.871
R4963 B3#18pmos@102_poly-right##3 B3#18pmos@102_poly-right##4 9.871
R4964 B3#18pmos@102_poly-right##4 B3#18pmos@102_poly-right##5 9.871
R4965 B3#18pmos@102_poly-right##5 B3#18pmos@102_poly-right##6 9.871
R4966 B3#18pmos@102_poly-right##6 B3#18pmos@102_poly-right##7 9.871
R4967 B3#18pmos@102_poly-right##7 B3#18pmos@102_poly-right##8 9.871
R4968 B3#18pmos@102_poly-right##8 B3#18pmos@102_poly-right##9 9.871
R4969 B3#18pmos@102_poly-right##9 B3#18pmos@102_poly-right##10 9.871
R4970 B3#18pmos@102_poly-right##10 B3#18pmos@102_poly-right##11 9.871
R4971 B3#18pmos@102_poly-right##11 B3#18pmos@102_poly-right##12 9.871
R4972 B3#18pmos@102_poly-right##12 B3#18pmos@102_poly-right##13 9.871
R4973 B3#18pmos@102_poly-right##13 B3#18pmos@102_poly-right##14 9.871
R4974 B3#18pmos@102_poly-right##14 B3#18pmos@102_poly-right##15 9.871
R4975 B3#18pmos@102_poly-right##15 B3#18pmos@102_poly-right##16 9.871
R4976 B3#18pmos@102_poly-right##16 B3#18pmos@102_poly-right##17 9.871
R4977 B3#18pmos@102_poly-right##17 B3#18pmos@102_poly-right##18 9.871
R4978 B3#18pmos@102_poly-right##18 B3#18pmos@102_poly-right##19 9.871
R4979 B3#18pmos@102_poly-right##19 B3#18pmos@102_poly-right##20 9.871
R4980 B3#18pmos@102_poly-right##20 B3#18pmos@102_poly-right##21 9.871
R4981 B3#18pmos@102_poly-right##21 B3#18pmos@102_poly-right##22 9.871
R4982 B3#18pmos@102_poly-right##22 B3#18pmos@102_poly-right##23 9.871
R4983 B3#18pmos@102_poly-right##23 B3#18pmos@102_poly-right##24 9.871
R4984 B3#18pmos@102_poly-right##24 B3#18pmos@102_poly-right##25 9.871
R4985 B3#18pmos@102_poly-right##25 B3#18pmos@102_poly-right##26 9.871
R4986 B3#18pmos@102_poly-right##26 B3#18pmos@102_poly-right##27 9.871
R4987 B3#18pmos@102_poly-right##27 B3#18pmos@102_poly-right##28 9.871
R4988 B3#18pmos@102_poly-right##28 B3#18pmos@102_poly-right##29 9.871
R4989 B3#18pmos@102_poly-right##29 B3#18pmos@102_poly-right##30 9.871
R4990 B3#18pmos@102_poly-right##30 B3#18pmos@102_poly-right##31 9.871
R4991 B3#18pmos@102_poly-right##31 B3#18pmos@102_poly-right##32 9.871
R4992 B3#18pmos@102_poly-right##32 B3#18pmos@102_poly-right##33 9.871
R4993 B3#18pmos@102_poly-right##33 B3#18pmos@102_poly-right##34 9.871
R4994 B3#18pmos@102_poly-right##34 B3#18pmos@102_poly-right##35 9.871
R4995 B3#18pmos@102_poly-right##35 B3#18pmos@102_poly-right##36 9.871
R4996 B3#18pmos@102_poly-right##36 B3#18pmos@102_poly-right##37 9.871
R4997 B3#18pmos@102_poly-right##37 B3#18pmos@102_poly-right##38 9.871
R4998 B3#18pmos@102_poly-right##38 B3#18pmos@102_poly-right##39 9.871
R4999 B3#18pmos@102_poly-right##39 B3#18pmos@102_poly-right##40 9.871
R5000 B3#18pmos@102_poly-right##40 B3#18pmos@102_poly-right##41 9.871
R5001 B3#18pmos@102_poly-right##41 B3#18pmos@102_poly-right##42 9.871
R5002 B3#18pmos@102_poly-right##42 B3#18pmos@102_poly-right##43 9.871
R5003 B3#18pmos@102_poly-right##43 B3#18pmos@102_poly-right##44 9.871
R5004 B3#18pmos@102_poly-right##44 B3#18pmos@102_poly-right##45 9.871
R5005 B3#18pmos@102_poly-right##45 B3#18pmos@102_poly-right##46 9.871
R5006 B3#18pmos@102_poly-right##46 B3#18pmos@102_poly-right##47 9.871
R5007 B3#18pmos@102_poly-right##47 B3#18pmos@102_poly-right##48 9.871
R5008 B3#18pmos@102_poly-right##48 B3#18pmos@102_poly-right##49 9.871
R5009 B3#18pmos@102_poly-right##49 B3#18pmos@102_poly-right##50 9.871
R5010 B3#18pmos@102_poly-right##50 B3#18pmos@102_poly-right##51 9.871
R5011 B3#18pmos@102_poly-right##51 B3#18pmos@102_poly-right##52 9.871
R5012 B3#18pmos@102_poly-right##52 B3#18pmos@102_poly-right##53 9.871
R5013 B3#18pmos@102_poly-right##53 B3#18pmos@102_poly-right##54 9.871
R5014 B3#18pmos@102_poly-right##54 B3#18pmos@102_poly-right##55 9.871
R5015 B3#18pmos@102_poly-right##55 B3#16nmos@102_poly-left 9.871
R5016 net@2211#14pmos@103_poly-right net@2211#14pmos@103_poly-right##0 9.871
R5017 net@2211#14pmos@103_poly-right##0 net@2211#14pmos@103_poly-right##1 9.871
R5018 net@2211#14pmos@103_poly-right##1 net@2211#14pmos@103_poly-right##2 9.871
R5019 net@2211#14pmos@103_poly-right##2 net@2211#14pmos@103_poly-right##3 9.871
R5020 net@2211#14pmos@103_poly-right##3 net@2211#14pmos@103_poly-right##4 9.871
R5021 net@2211#14pmos@103_poly-right##4 net@2211#14pmos@103_poly-right##5 9.871
R5022 net@2211#14pmos@103_poly-right##5 net@2211#14pmos@103_poly-right##6 9.871
R5023 net@2211#14pmos@103_poly-right##6 net@2211#14pmos@103_poly-right##7 9.871
R5024 net@2211#14pmos@103_poly-right##7 net@2211#14pmos@103_poly-right##8 9.871
R5025 net@2211#14pmos@103_poly-right##8 net@2211#14pmos@103_poly-right##9 9.871
R5026 net@2211#14pmos@103_poly-right##9 net@2211#14pmos@103_poly-right##10 9.871
R5027 net@2211#14pmos@103_poly-right##10 net@2211#14pmos@103_poly-right##11 9.871
R5028 net@2211#14pmos@103_poly-right##11 net@2211#14pmos@103_poly-right##12 9.871
R5029 net@2211#14pmos@103_poly-right##12 net@2211#14pmos@103_poly-right##13 9.871
R5030 net@2211#14pmos@103_poly-right##13 net@2211#14pmos@103_poly-right##14 9.871
R5031 net@2211#14pmos@103_poly-right##14 net@2211#14pmos@103_poly-right##15 9.871
R5032 net@2211#14pmos@103_poly-right##15 net@2211#14pmos@103_poly-right##16 9.871
R5033 net@2211#14pmos@103_poly-right##16 net@2211#14pmos@103_poly-right##17 9.871
R5034 net@2211#14pmos@103_poly-right##17 net@2211#14pmos@103_poly-right##18 9.871
R5035 net@2211#14pmos@103_poly-right##18 net@2211#14pmos@103_poly-right##19 9.871
R5036 net@2211#14pmos@103_poly-right##19 net@2211#14pmos@103_poly-right##20 9.871
R5037 net@2211#14pmos@103_poly-right##20 net@2211#14pmos@103_poly-right##21 9.871
R5038 net@2211#14pmos@103_poly-right##21 net@2211#14pmos@103_poly-right##22 9.871
R5039 net@2211#14pmos@103_poly-right##22 net@2211#14pmos@103_poly-right##23 9.871
R5040 net@2211#14pmos@103_poly-right##23 net@2211#14pmos@103_poly-right##24 9.871
R5041 net@2211#14pmos@103_poly-right##24 net@2211#14pmos@103_poly-right##25 9.871
R5042 net@2211#14pmos@103_poly-right##25 net@2211#14pmos@103_poly-right##26 9.871
R5043 net@2211#14pmos@103_poly-right##26 net@2211#14pmos@103_poly-right##27 9.871
R5044 net@2211#14pmos@103_poly-right##27 net@2211#14pmos@103_poly-right##28 9.871
R5045 net@2211#14pmos@103_poly-right##28 net@2211#14pmos@103_poly-right##29 9.871
R5046 net@2211#14pmos@103_poly-right##29 net@2211#14pmos@103_poly-right##30 9.871
R5047 net@2211#14pmos@103_poly-right##30 net@2211#14pmos@103_poly-right##31 9.871
R5048 net@2211#14pmos@103_poly-right##31 net@2211#14pmos@103_poly-right##32 9.871
R5049 net@2211#14pmos@103_poly-right##32 net@2211#14pmos@103_poly-right##33 9.871
R5050 net@2211#14pmos@103_poly-right##33 net@2211#14pmos@103_poly-right##34 9.871
R5051 net@2211#14pmos@103_poly-right##34 net@2211#14pmos@103_poly-right##35 9.871
R5052 net@2211#14pmos@103_poly-right##35 net@2211#14pmos@103_poly-right##36 9.871
R5053 net@2211#14pmos@103_poly-right##36 net@2211#14pmos@103_poly-right##37 9.871
R5054 net@2211#14pmos@103_poly-right##37 net@2211#14pmos@103_poly-right##38 9.871
R5055 net@2211#14pmos@103_poly-right##38 net@2211#14pmos@103_poly-right##39 9.871
R5056 net@2211#14pmos@103_poly-right##39 net@2211#14pmos@103_poly-right##40 9.871
R5057 net@2211#14pmos@103_poly-right##40 net@2211#14pmos@103_poly-right##41 9.871
R5058 net@2211#14pmos@103_poly-right##41 net@2211#14pmos@103_poly-right##42 9.871
R5059 net@2211#14pmos@103_poly-right##42 net@2211#14pmos@103_poly-right##43 9.871
R5060 net@2211#14pmos@103_poly-right##43 net@2211#14pmos@103_poly-right##44 9.871
R5061 net@2211#14pmos@103_poly-right##44 net@2211#14pmos@103_poly-right##45 9.871
R5062 net@2211#14pmos@103_poly-right##45 net@2211#14pmos@103_poly-right##46 9.871
R5063 net@2211#14pmos@103_poly-right##46 net@2211#14pmos@103_poly-right##47 9.871
R5064 net@2211#14pmos@103_poly-right##47 net@2211#14pmos@103_poly-right##48 9.871
R5065 net@2211#14pmos@103_poly-right##48 net@2211#14pmos@103_poly-right##49 9.871
R5066 net@2211#14pmos@103_poly-right##49 net@2211#14pmos@103_poly-right##50 9.871
R5067 net@2211#14pmos@103_poly-right##50 net@2211#14pmos@103_poly-right##51 9.871
R5068 net@2211#14pmos@103_poly-right##51 net@2211#14pmos@103_poly-right##52 9.871
R5069 net@2211#14pmos@103_poly-right##52 net@2211#14pmos@103_poly-right##53 9.871
R5070 net@2211#14pmos@103_poly-right##53 net@2211#14pmos@103_poly-right##54 9.871
R5071 net@2211#14pmos@103_poly-right##54 net@2211#14pmos@103_poly-right##55 9.871
R5072 net@2211#14pmos@103_poly-right##55 net@2211#9nmos@103_poly-left 9.871
R5073 net@2204#2contact@713_metal-1-polysilicon-1 net@2204 4.706
R5074 net@2204#12pmos@106_poly-right net@2204#12pmos@106_poly-right##0 9.864
R5075 net@2204#12pmos@106_poly-right##0 net@2204#12pmos@106_poly-right##1 9.864
R5076 net@2204#12pmos@106_poly-right##1 net@2204#12pmos@106_poly-right##2 9.864
R5077 net@2204#12pmos@106_poly-right##2 net@2204#12pmos@106_poly-right##3 9.864
R5078 net@2204#12pmos@106_poly-right##3 net@2204#12pmos@106_poly-right##4 9.864
R5079 net@2204#12pmos@106_poly-right##4 net@2204#12pmos@106_poly-right##5 9.864
R5080 net@2204#12pmos@106_poly-right##5 net@2204#12pmos@106_poly-right##6 9.864
R5081 net@2204#12pmos@106_poly-right##6 net@2204#12pmos@106_poly-right##7 9.864
R5082 net@2204#12pmos@106_poly-right##7 net@2204#12pmos@106_poly-right##8 9.864
R5083 net@2204#12pmos@106_poly-right##8 net@2204#12pmos@106_poly-right##9 9.864
R5084 net@2204#12pmos@106_poly-right##9 net@2204#12pmos@106_poly-right##10 9.864
R5085 net@2204#12pmos@106_poly-right##10 net@2204#12pmos@106_poly-right##11 9.864
R5086 net@2204#12pmos@106_poly-right##11 net@2204#12pmos@106_poly-right##12 9.864
R5087 net@2204#12pmos@106_poly-right##12 net@2204#12pmos@106_poly-right##13 9.864
R5088 net@2204#12pmos@106_poly-right##13 net@2204#12pmos@106_poly-right##14 9.864
R5089 net@2204#12pmos@106_poly-right##14 net@2204#12pmos@106_poly-right##15 9.864
R5090 net@2204#12pmos@106_poly-right##15 net@2204#12pmos@106_poly-right##16 9.864
R5091 net@2204#12pmos@106_poly-right##16 net@2204#12pmos@106_poly-right##17 9.864
R5092 net@2204#12pmos@106_poly-right##17 net@2204#12pmos@106_poly-right##18 9.864
R5093 net@2204#12pmos@106_poly-right##18 net@2204#12pmos@106_poly-right##19 9.864
R5094 net@2204#12pmos@106_poly-right##19 net@2204#12pmos@106_poly-right##20 9.864
R5095 net@2204#12pmos@106_poly-right##20 net@2204#12pmos@106_poly-right##21 9.864
R5096 net@2204#12pmos@106_poly-right##21 net@2204#12pmos@106_poly-right##22 9.864
R5097 net@2204#12pmos@106_poly-right##22 net@2204#12pmos@106_poly-right##23 9.864
R5098 net@2204#12pmos@106_poly-right##23 net@2204#12pmos@106_poly-right##24 9.864
R5099 net@2204#12pmos@106_poly-right##24 net@2204#12pmos@106_poly-right##25 9.864
R5100 net@2204#12pmos@106_poly-right##25 net@2204#12pmos@106_poly-right##26 9.864
R5101 net@2204#12pmos@106_poly-right##26 net@2204#12pmos@106_poly-right##27 9.864
R5102 net@2204#12pmos@106_poly-right##27 net@2204#12pmos@106_poly-right##28 9.864
R5103 net@2204#12pmos@106_poly-right##28 net@2204#12pmos@106_poly-right##29 9.864
R5104 net@2204#12pmos@106_poly-right##29 net@2204#12pmos@106_poly-right##30 9.864
R5105 net@2204#12pmos@106_poly-right##30 net@2204#12pmos@106_poly-right##31 9.864
R5106 net@2204#12pmos@106_poly-right##31 net@2204#12pmos@106_poly-right##32 9.864
R5107 net@2204#12pmos@106_poly-right##32 net@2204#12pmos@106_poly-right##33 9.864
R5108 net@2204#12pmos@106_poly-right##33 net@2204#12pmos@106_poly-right##34 9.864
R5109 net@2204#12pmos@106_poly-right##34 net@2204#12pmos@106_poly-right##35 9.864
R5110 net@2204#12pmos@106_poly-right##35 net@2204#12pmos@106_poly-right##36 9.864
R5111 net@2204#12pmos@106_poly-right##36 net@2204#12pmos@106_poly-right##37 9.864
R5112 net@2204#12pmos@106_poly-right##37 net@2204#12pmos@106_poly-right##38 9.864
R5113 net@2204#12pmos@106_poly-right##38 net@2204#12pmos@106_poly-right##39 9.864
R5114 net@2204#12pmos@106_poly-right##39 net@2204#12pmos@106_poly-right##40 9.864
R5115 net@2204#12pmos@106_poly-right##40 net@2204#12pmos@106_poly-right##41 9.864
R5116 net@2204#12pmos@106_poly-right##41 net@2204#12pmos@106_poly-right##42 9.864
R5117 net@2204#12pmos@106_poly-right##42 net@2204#12pmos@106_poly-right##43 9.864
R5118 net@2204#12pmos@106_poly-right##43 net@2204#12pmos@106_poly-right##44 9.864
R5119 net@2204#12pmos@106_poly-right##44 net@2204#12pmos@106_poly-right##45 9.864
R5120 net@2204#12pmos@106_poly-right##45 net@2204#12pmos@106_poly-right##46 9.864
R5121 net@2204#12pmos@106_poly-right##46 net@2204#12pmos@106_poly-right##47 9.864
R5122 net@2204#12pmos@106_poly-right##47 net@2204#12pmos@106_poly-right##48 9.864
R5123 net@2204#12pmos@106_poly-right##48 net@2204#12pmos@106_poly-right##49 9.864
R5124 net@2204#12pmos@106_poly-right##49 net@2204#12pmos@106_poly-right##50 9.864
R5125 net@2204#12pmos@106_poly-right##50 net@2204#12pmos@106_poly-right##51 9.864
R5126 net@2204#12pmos@106_poly-right##51 net@2204#12pmos@106_poly-right##52 9.864
R5127 net@2204#12pmos@106_poly-right##52 net@2204#12pmos@106_poly-right##53 9.864
R5128 net@2204#12pmos@106_poly-right##53 net@2204#5pin@634_polysilicon-1 9.864
R5129 XOR1_to_NAND4#22pmos@106_diff-top XOR1_to_NAND4#1contact@766_metal-1-metal-2 4.862
R5130 XOR1_to_NAND4#3pin@667_polysilicon-1 XOR1_to_NAND4#3pin@667_polysilicon-1##0 9.881
R5131 XOR1_to_NAND4#3pin@667_polysilicon-1##0 XOR1_to_NAND4#3pin@667_polysilicon-1##1 9.881
R5132 XOR1_to_NAND4#3pin@667_polysilicon-1##1 XOR1_to_NAND4#3pin@667_polysilicon-1##2 9.881
R5133 XOR1_to_NAND4#3pin@667_polysilicon-1##2 XOR1_to_NAND4#3pin@667_polysilicon-1##3 9.881
R5134 XOR1_to_NAND4#3pin@667_polysilicon-1##3 XOR1_to_NAND4#3pin@667_polysilicon-1##4 9.881
R5135 XOR1_to_NAND4#3pin@667_polysilicon-1##4 XOR1_to_NAND4#3pin@667_polysilicon-1##5 9.881
R5136 XOR1_to_NAND4#3pin@667_polysilicon-1##5 XOR1_to_NAND4#3pin@667_polysilicon-1##6 9.881
R5137 XOR1_to_NAND4#3pin@667_polysilicon-1##6 XOR1_to_NAND4#3pin@667_polysilicon-1##7 9.881
R5138 XOR1_to_NAND4#3pin@667_polysilicon-1##7 XOR1_to_NAND4#3pin@667_polysilicon-1##8 9.881
R5139 XOR1_to_NAND4#3pin@667_polysilicon-1##8 XOR1_to_NAND4#3pin@667_polysilicon-1##9 9.881
R5140 XOR1_to_NAND4#3pin@667_polysilicon-1##9 XOR1_to_NAND4#3pin@667_polysilicon-1##10 9.881
R5141 XOR1_to_NAND4#3pin@667_polysilicon-1##10 XOR1_to_NAND4#3pin@667_polysilicon-1##11 9.881
R5142 XOR1_to_NAND4#3pin@667_polysilicon-1##11 XOR1_to_NAND4#3pin@667_polysilicon-1##12 9.881
R5143 XOR1_to_NAND4#3pin@667_polysilicon-1##12 XOR1_to_NAND4#3pin@667_polysilicon-1##13 9.881
R5144 XOR1_to_NAND4#3pin@667_polysilicon-1##13 XOR1_to_NAND4#3pin@667_polysilicon-1##14 9.881
R5145 XOR1_to_NAND4#3pin@667_polysilicon-1##14 XOR1_to_NAND4#3pin@667_polysilicon-1##15 9.881
R5146 XOR1_to_NAND4#3pin@667_polysilicon-1##15 XOR1_to_NAND4#3pin@667_polysilicon-1##16 9.881
R5147 XOR1_to_NAND4#3pin@667_polysilicon-1##16 XOR1_to_NAND4#3pin@667_polysilicon-1##17 9.881
R5148 XOR1_to_NAND4#3pin@667_polysilicon-1##17 XOR1_to_NAND4#3pin@667_polysilicon-1##18 9.881
R5149 XOR1_to_NAND4#3pin@667_polysilicon-1##18 XOR1_to_NAND4#3pin@667_polysilicon-1##19 9.881
R5150 XOR1_to_NAND4#3pin@667_polysilicon-1##19 XOR1_to_NAND4#3pin@667_polysilicon-1##20 9.881
R5151 XOR1_to_NAND4#3pin@667_polysilicon-1##20 XOR1_to_NAND4#3pin@667_polysilicon-1##21 9.881
R5152 XOR1_to_NAND4#3pin@667_polysilicon-1##21 XOR1_to_NAND4#3pin@667_polysilicon-1##22 9.881
R5153 XOR1_to_NAND4#3pin@667_polysilicon-1##22 XOR1_to_NAND4#3pin@667_polysilicon-1##23 9.881
R5154 XOR1_to_NAND4#3pin@667_polysilicon-1##23 XOR1_to_NAND4#3pin@667_polysilicon-1##24 9.881
R5155 XOR1_to_NAND4#3pin@667_polysilicon-1##24 XOR1_to_NAND4#3pin@667_polysilicon-1##25 9.881
R5156 XOR1_to_NAND4#3pin@667_polysilicon-1##25 XOR1_to_NAND4#3pin@667_polysilicon-1##26 9.881
R5157 XOR1_to_NAND4#3pin@667_polysilicon-1##26 XOR1_to_NAND4#3pin@667_polysilicon-1##27 9.881
R5158 XOR1_to_NAND4#3pin@667_polysilicon-1##27 XOR1_to_NAND4#3pin@667_polysilicon-1##28 9.881
R5159 XOR1_to_NAND4#3pin@667_polysilicon-1##28 XOR1_to_NAND4#3pin@667_polysilicon-1##29 9.881
R5160 XOR1_to_NAND4#3pin@667_polysilicon-1##29 XOR1_to_NAND4#3pin@667_polysilicon-1##30 9.881
R5161 XOR1_to_NAND4#3pin@667_polysilicon-1##30 XOR1_to_NAND4#3pin@667_polysilicon-1##31 9.881
R5162 XOR1_to_NAND4#3pin@667_polysilicon-1##31 XOR1_to_NAND4#3pin@667_polysilicon-1##32 9.881
R5163 XOR1_to_NAND4#3pin@667_polysilicon-1##32 XOR1_to_NAND4#3pin@667_polysilicon-1##33 9.881
R5164 XOR1_to_NAND4#3pin@667_polysilicon-1##33 XOR1_to_NAND4#3pin@667_polysilicon-1##34 9.881
R5165 XOR1_to_NAND4#3pin@667_polysilicon-1##34 XOR1_to_NAND4#3pin@667_polysilicon-1##35 9.881
R5166 XOR1_to_NAND4#3pin@667_polysilicon-1##35 XOR1_to_NAND4#3pin@667_polysilicon-1##36 9.881
R5167 XOR1_to_NAND4#3pin@667_polysilicon-1##36 XOR1_to_NAND4#3pin@667_polysilicon-1##37 9.881
R5168 XOR1_to_NAND4#3pin@667_polysilicon-1##37 XOR1_to_NAND4#3pin@667_polysilicon-1##38 9.881
R5169 XOR1_to_NAND4#3pin@667_polysilicon-1##38 XOR1_to_NAND4#3pin@667_polysilicon-1##39 9.881
R5170 XOR1_to_NAND4#3pin@667_polysilicon-1##39 XOR1_to_NAND4#3pin@667_polysilicon-1##40 9.881
R5171 XOR1_to_NAND4#3pin@667_polysilicon-1##40 XOR1_to_NAND4#3pin@667_polysilicon-1##41 9.881
R5172 XOR1_to_NAND4#3pin@667_polysilicon-1##41 XOR1_to_NAND4#3pin@667_polysilicon-1##42 9.881
R5173 XOR1_to_NAND4#3pin@667_polysilicon-1##42 XOR1_to_NAND4#3pin@667_polysilicon-1##43 9.881
R5174 XOR1_to_NAND4#3pin@667_polysilicon-1##43 XOR1_to_NAND4#3pin@667_polysilicon-1##44 9.881
R5175 XOR1_to_NAND4#3pin@667_polysilicon-1##44 XOR1_to_NAND4#3pin@667_polysilicon-1##45 9.881
R5176 XOR1_to_NAND4#3pin@667_polysilicon-1##45 XOR1_to_NAND4#3pin@667_polysilicon-1##46 9.881
R5177 XOR1_to_NAND4#3pin@667_polysilicon-1##46 XOR1_to_NAND4#3pin@667_polysilicon-1##47 9.881
R5178 XOR1_to_NAND4#3pin@667_polysilicon-1##47 XOR1_to_NAND4#3pin@667_polysilicon-1##48 9.881
R5179 XOR1_to_NAND4#3pin@667_polysilicon-1##48 XOR1_to_NAND4#3pin@667_polysilicon-1##49 9.881
R5180 XOR1_to_NAND4#3pin@667_polysilicon-1##49 XOR1_to_NAND4#3pin@667_polysilicon-1##50 9.881
R5181 XOR1_to_NAND4#3pin@667_polysilicon-1##50 XOR1_to_NAND4#3pin@667_polysilicon-1##51 9.881
R5182 XOR1_to_NAND4#3pin@667_polysilicon-1##51 XOR1_to_NAND4#3pin@667_polysilicon-1##52 9.881
R5183 XOR1_to_NAND4#3pin@667_polysilicon-1##52 XOR1_to_NAND4#3pin@667_polysilicon-1##53 9.881
R5184 XOR1_to_NAND4#3pin@667_polysilicon-1##53 XOR1_to_NAND4#3pin@667_polysilicon-1##54 9.881
R5185 XOR1_to_NAND4#3pin@667_polysilicon-1##54 XOR1_to_NAND4#24nmos@112_poly-right 9.881
R5186 net@2108#5pmos@112_diff-top net@2108#2pin@656_metal-1 4.81
R5187 net@2108#1pin@666_polysilicon-1 net@2108#1pin@666_polysilicon-1##0 9.85
R5188 net@2108#1pin@666_polysilicon-1##0 net@2108#1pin@666_polysilicon-1##1 9.85
R5189 net@2108#1pin@666_polysilicon-1##1 net@2108#1pin@666_polysilicon-1##2 9.85
R5190 net@2108#1pin@666_polysilicon-1##2 net@2108#1pin@666_polysilicon-1##3 9.85
R5191 net@2108#1pin@666_polysilicon-1##3 net@2108#1pin@666_polysilicon-1##4 9.85
R5192 net@2108#1pin@666_polysilicon-1##4 net@2108#1pin@666_polysilicon-1##5 9.85
R5193 net@2108#1pin@666_polysilicon-1##5 net@2108#1pin@666_polysilicon-1##6 9.85
R5194 net@2108#1pin@666_polysilicon-1##6 net@2108#1pin@666_polysilicon-1##7 9.85
R5195 net@2108#1pin@666_polysilicon-1##7 net@2108#1pin@666_polysilicon-1##8 9.85
R5196 net@2108#1pin@666_polysilicon-1##8 net@2108#1pin@666_polysilicon-1##9 9.85
R5197 net@2108#1pin@666_polysilicon-1##9 net@2108#1pin@666_polysilicon-1##10 9.85
R5198 net@2108#1pin@666_polysilicon-1##10 net@2108#1pin@666_polysilicon-1##11 9.85
R5199 net@2108#1pin@666_polysilicon-1##11 net@2108#1pin@666_polysilicon-1##12 9.85
R5200 net@2108#1pin@666_polysilicon-1##12 net@2108#1pin@666_polysilicon-1##13 9.85
R5201 net@2108#1pin@666_polysilicon-1##13 net@2108#1pin@666_polysilicon-1##14 9.85
R5202 net@2108#1pin@666_polysilicon-1##14 net@2108#1pin@666_polysilicon-1##15 9.85
R5203 net@2108#1pin@666_polysilicon-1##15 net@2108#1pin@666_polysilicon-1##16 9.85
R5204 net@2108#1pin@666_polysilicon-1##16 net@2108#1pin@666_polysilicon-1##17 9.85
R5205 net@2108#1pin@666_polysilicon-1##17 net@2108#1pin@666_polysilicon-1##18 9.85
R5206 net@2108#1pin@666_polysilicon-1##18 net@2108#1pin@666_polysilicon-1##19 9.85
R5207 net@2108#1pin@666_polysilicon-1##19 net@2108#1pin@666_polysilicon-1##20 9.85
R5208 net@2108#1pin@666_polysilicon-1##20 net@2108#1pin@666_polysilicon-1##21 9.85
R5209 net@2108#1pin@666_polysilicon-1##21 net@2108#1pin@666_polysilicon-1##22 9.85
R5210 net@2108#1pin@666_polysilicon-1##22 net@2108#1pin@666_polysilicon-1##23 9.85
R5211 net@2108#1pin@666_polysilicon-1##23 net@2108#1pin@666_polysilicon-1##24 9.85
R5212 net@2108#1pin@666_polysilicon-1##24 net@2108#1pin@666_polysilicon-1##25 9.85
R5213 net@2108#1pin@666_polysilicon-1##25 net@2108#1pin@666_polysilicon-1##26 9.85
R5214 net@2108#1pin@666_polysilicon-1##26 net@2108#1pin@666_polysilicon-1##27 9.85
R5215 net@2108#1pin@666_polysilicon-1##27 net@2108#1pin@666_polysilicon-1##28 9.85
R5216 net@2108#1pin@666_polysilicon-1##28 net@2108#1pin@666_polysilicon-1##29 9.85
R5217 net@2108#1pin@666_polysilicon-1##29 net@2108#1pin@666_polysilicon-1##30 9.85
R5218 net@2108#1pin@666_polysilicon-1##30 net@2108#1pin@666_polysilicon-1##31 9.85
R5219 net@2108#1pin@666_polysilicon-1##31 net@2108#1pin@666_polysilicon-1##32 9.85
R5220 net@2108#1pin@666_polysilicon-1##32 net@2108#1pin@666_polysilicon-1##33 9.85
R5221 net@2108#1pin@666_polysilicon-1##33 net@2108#1pin@666_polysilicon-1##34 9.85
R5222 net@2108#1pin@666_polysilicon-1##34 net@2108#1pin@666_polysilicon-1##35 9.85
R5223 net@2108#1pin@666_polysilicon-1##35 net@2108#1pin@666_polysilicon-1##36 9.85
R5224 net@2108#1pin@666_polysilicon-1##36 net@2108#1pin@666_polysilicon-1##37 9.85
R5225 net@2108#1pin@666_polysilicon-1##37 net@2108#1pin@666_polysilicon-1##38 9.85
R5226 net@2108#1pin@666_polysilicon-1##38 net@2108#1pin@666_polysilicon-1##39 9.85
R5227 net@2108#1pin@666_polysilicon-1##39 net@2108#1pin@666_polysilicon-1##40 9.85
R5228 net@2108#1pin@666_polysilicon-1##40 net@2108#1pin@666_polysilicon-1##41 9.85
R5229 net@2108#1pin@666_polysilicon-1##41 net@2108#1pin@666_polysilicon-1##42 9.85
R5230 net@2108#1pin@666_polysilicon-1##42 net@2108#1pin@666_polysilicon-1##43 9.85
R5231 net@2108#1pin@666_polysilicon-1##43 net@2108#1pin@666_polysilicon-1##44 9.85
R5232 net@2108#1pin@666_polysilicon-1##44 net@2108#1pin@666_polysilicon-1##45 9.85
R5233 net@2108#1pin@666_polysilicon-1##45 net@2108#1pin@666_polysilicon-1##46 9.85
R5234 net@2108#1pin@666_polysilicon-1##46 net@2108#1pin@666_polysilicon-1##47 9.85
R5235 net@2108#1pin@666_polysilicon-1##47 net@2108#1pin@666_polysilicon-1##48 9.85
R5236 net@2108#1pin@666_polysilicon-1##48 net@2108#1pin@666_polysilicon-1##49 9.85
R5237 net@2108#1pin@666_polysilicon-1##49 net@2108#1pin@666_polysilicon-1##50 9.85
R5238 net@2108#1pin@666_polysilicon-1##50 net@2108#1pin@666_polysilicon-1##51 9.85
R5239 net@2108#1pin@666_polysilicon-1##51 net@2108#1pin@666_polysilicon-1##52 9.85
R5240 net@2108#1pin@666_polysilicon-1##52 net@2108#1pin@666_polysilicon-1##53 9.85
R5241 net@2108#1pin@666_polysilicon-1##53 net@2108#1pin@666_polysilicon-1##54 9.85
R5242 net@2108#1pin@666_polysilicon-1##54 net@2108#1pin@666_polysilicon-1##55 9.85
R5243 net@2108#1pin@666_polysilicon-1##55 net@2108#1pin@666_polysilicon-1##56 9.85
R5244 net@2108#1pin@666_polysilicon-1##56 net@2108#1pin@666_polysilicon-1##57 9.85
R5245 net@2108#1pin@666_polysilicon-1##57 net@2108#1pin@666_polysilicon-1##58 9.85
R5246 net@2108#1pin@666_polysilicon-1##58 net@2108#1pin@666_polysilicon-1##59 9.85
R5247 net@2108#1pin@666_polysilicon-1##59 net@2108#1pin@666_polysilicon-1##60 9.85
R5248 net@2108#1pin@666_polysilicon-1##60 net@2108#2pin@656_metal-1 9.85
R5249 Cin_to_XOR2___NAND4#26pmos@111_poly-right Cin_to_XOR2___NAND4#26pmos@111_poly-right##0 9.854
R5250 Cin_to_XOR2___NAND4#26pmos@111_poly-right##0 Cin_to_XOR2___NAND4#26pmos@111_poly-right##1 9.854
R5251 Cin_to_XOR2___NAND4#26pmos@111_poly-right##1 Cin_to_XOR2___NAND4#26pmos@111_poly-right##2 9.854
R5252 Cin_to_XOR2___NAND4#26pmos@111_poly-right##2 Cin_to_XOR2___NAND4#26pmos@111_poly-right##3 9.854
R5253 Cin_to_XOR2___NAND4#26pmos@111_poly-right##3 Cin_to_XOR2___NAND4#26pmos@111_poly-right##4 9.854
R5254 Cin_to_XOR2___NAND4#26pmos@111_poly-right##4 Cin_to_XOR2___NAND4#26pmos@111_poly-right##5 9.854
R5255 Cin_to_XOR2___NAND4#26pmos@111_poly-right##5 Cin_to_XOR2___NAND4#26pmos@111_poly-right##6 9.854
R5256 Cin_to_XOR2___NAND4#26pmos@111_poly-right##6 Cin_to_XOR2___NAND4#26pmos@111_poly-right##7 9.854
R5257 Cin_to_XOR2___NAND4#26pmos@111_poly-right##7 Cin_to_XOR2___NAND4#26pmos@111_poly-right##8 9.854
R5258 Cin_to_XOR2___NAND4#26pmos@111_poly-right##8 Cin_to_XOR2___NAND4#26pmos@111_poly-right##9 9.854
R5259 Cin_to_XOR2___NAND4#26pmos@111_poly-right##9 Cin_to_XOR2___NAND4#26pmos@111_poly-right##10 9.854
R5260 Cin_to_XOR2___NAND4#26pmos@111_poly-right##10 Cin_to_XOR2___NAND4#26pmos@111_poly-right##11 9.854
R5261 Cin_to_XOR2___NAND4#26pmos@111_poly-right##11 Cin_to_XOR2___NAND4#26pmos@111_poly-right##12 9.854
R5262 Cin_to_XOR2___NAND4#26pmos@111_poly-right##12 Cin_to_XOR2___NAND4#26pmos@111_poly-right##13 9.854
R5263 Cin_to_XOR2___NAND4#26pmos@111_poly-right##13 Cin_to_XOR2___NAND4#26pmos@111_poly-right##14 9.854
R5264 Cin_to_XOR2___NAND4#26pmos@111_poly-right##14 Cin_to_XOR2___NAND4#26pmos@111_poly-right##15 9.854
R5265 Cin_to_XOR2___NAND4#26pmos@111_poly-right##15 Cin_to_XOR2___NAND4#26pmos@111_poly-right##16 9.854
R5266 Cin_to_XOR2___NAND4#26pmos@111_poly-right##16 Cin_to_XOR2___NAND4#26pmos@111_poly-right##17 9.854
R5267 Cin_to_XOR2___NAND4#26pmos@111_poly-right##17 Cin_to_XOR2___NAND4#26pmos@111_poly-right##18 9.854
R5268 Cin_to_XOR2___NAND4#26pmos@111_poly-right##18 Cin_to_XOR2___NAND4#26pmos@111_poly-right##19 9.854
R5269 Cin_to_XOR2___NAND4#26pmos@111_poly-right##19 Cin_to_XOR2___NAND4#26pmos@111_poly-right##20 9.854
R5270 Cin_to_XOR2___NAND4#26pmos@111_poly-right##20 Cin_to_XOR2___NAND4#26pmos@111_poly-right##21 9.854
R5271 Cin_to_XOR2___NAND4#26pmos@111_poly-right##21 Cin_to_XOR2___NAND4#26pmos@111_poly-right##22 9.854
R5272 Cin_to_XOR2___NAND4#26pmos@111_poly-right##22 Cin_to_XOR2___NAND4#26pmos@111_poly-right##23 9.854
R5273 Cin_to_XOR2___NAND4#26pmos@111_poly-right##23 Cin_to_XOR2___NAND4#26pmos@111_poly-right##24 9.854
R5274 Cin_to_XOR2___NAND4#26pmos@111_poly-right##24 Cin_to_XOR2___NAND4#26pmos@111_poly-right##25 9.854
R5275 Cin_to_XOR2___NAND4#26pmos@111_poly-right##25 Cin_to_XOR2___NAND4#26pmos@111_poly-right##26 9.854
R5276 Cin_to_XOR2___NAND4#26pmos@111_poly-right##26 Cin_to_XOR2___NAND4#26pmos@111_poly-right##27 9.854
R5277 Cin_to_XOR2___NAND4#26pmos@111_poly-right##27 Cin_to_XOR2___NAND4#26pmos@111_poly-right##28 9.854
R5278 Cin_to_XOR2___NAND4#26pmos@111_poly-right##28 Cin_to_XOR2___NAND4#26pmos@111_poly-right##29 9.854
R5279 Cin_to_XOR2___NAND4#26pmos@111_poly-right##29 Cin_to_XOR2___NAND4#26pmos@111_poly-right##30 9.854
R5280 Cin_to_XOR2___NAND4#26pmos@111_poly-right##30 Cin_to_XOR2___NAND4#26pmos@111_poly-right##31 9.854
R5281 Cin_to_XOR2___NAND4#26pmos@111_poly-right##31 Cin_to_XOR2___NAND4#26pmos@111_poly-right##32 9.854
R5282 Cin_to_XOR2___NAND4#26pmos@111_poly-right##32 Cin_to_XOR2___NAND4#26pmos@111_poly-right##33 9.854
R5283 Cin_to_XOR2___NAND4#26pmos@111_poly-right##33 Cin_to_XOR2___NAND4#26pmos@111_poly-right##34 9.854
R5284 Cin_to_XOR2___NAND4#26pmos@111_poly-right##34 Cin_to_XOR2___NAND4#26pmos@111_poly-right##35 9.854
R5285 Cin_to_XOR2___NAND4#26pmos@111_poly-right##35 Cin_to_XOR2___NAND4#26pmos@111_poly-right##36 9.854
R5286 Cin_to_XOR2___NAND4#26pmos@111_poly-right##36 Cin_to_XOR2___NAND4#26pmos@111_poly-right##37 9.854
R5287 Cin_to_XOR2___NAND4#26pmos@111_poly-right##37 Cin_to_XOR2___NAND4#26pmos@111_poly-right##38 9.854
R5288 Cin_to_XOR2___NAND4#26pmos@111_poly-right##38 Cin_to_XOR2___NAND4#26pmos@111_poly-right##39 9.854
R5289 Cin_to_XOR2___NAND4#26pmos@111_poly-right##39 Cin_to_XOR2___NAND4#26pmos@111_poly-right##40 9.854
R5290 Cin_to_XOR2___NAND4#26pmos@111_poly-right##40 Cin_to_XOR2___NAND4#26pmos@111_poly-right##41 9.854
R5291 Cin_to_XOR2___NAND4#26pmos@111_poly-right##41 Cin_to_XOR2___NAND4#26pmos@111_poly-right##42 9.854
R5292 Cin_to_XOR2___NAND4#26pmos@111_poly-right##42 Cin_to_XOR2___NAND4#26pmos@111_poly-right##43 9.854
R5293 Cin_to_XOR2___NAND4#26pmos@111_poly-right##43 Cin_to_XOR2___NAND4#26pmos@111_poly-right##44 9.854
R5294 Cin_to_XOR2___NAND4#26pmos@111_poly-right##44 Cin_to_XOR2___NAND4#26pmos@111_poly-right##45 9.854
R5295 Cin_to_XOR2___NAND4#26pmos@111_poly-right##45 Cin_to_XOR2___NAND4#26pmos@111_poly-right##46 9.854
R5296 Cin_to_XOR2___NAND4#26pmos@111_poly-right##46 Cin_to_XOR2___NAND4#26pmos@111_poly-right##47 9.854
R5297 Cin_to_XOR2___NAND4#26pmos@111_poly-right##47 Cin_to_XOR2___NAND4#26pmos@111_poly-right##48 9.854
R5298 Cin_to_XOR2___NAND4#26pmos@111_poly-right##48 Cin_to_XOR2___NAND4#26pmos@111_poly-right##49 9.854
R5299 Cin_to_XOR2___NAND4#26pmos@111_poly-right##49 Cin_to_XOR2___NAND4#26pmos@111_poly-right##50 9.854
R5300 Cin_to_XOR2___NAND4#26pmos@111_poly-right##50 Cin_to_XOR2___NAND4#26pmos@111_poly-right##51 9.854
R5301 Cin_to_XOR2___NAND4#26pmos@111_poly-right##51 Cin_to_XOR2___NAND4#26pmos@111_poly-right##52 9.854
R5302 Cin_to_XOR2___NAND4#26pmos@111_poly-right##52 Cin_to_XOR2___NAND4#26pmos@111_poly-right##53 9.854
R5303 Cin_to_XOR2___NAND4#26pmos@111_poly-right##53 Cin_to_XOR2___NAND4#26pmos@111_poly-right##54 9.854
R5304 Cin_to_XOR2___NAND4#26pmos@111_poly-right##54 Cin_to_XOR2___NAND4#15pin@657_polysilicon-1 9.854
R5305 net@2118 net@2118#2contact@727_metal-1-metal-2 4.797
R5306 XOR1_to_NAND4#9pmos@107_poly-left XOR1_to_NAND4#9pmos@107_poly-left##0 9.871
R5307 XOR1_to_NAND4#9pmos@107_poly-left##0 XOR1_to_NAND4#9pmos@107_poly-left##1 9.871
R5308 XOR1_to_NAND4#9pmos@107_poly-left##1 XOR1_to_NAND4#9pmos@107_poly-left##2 9.871
R5309 XOR1_to_NAND4#9pmos@107_poly-left##2 XOR1_to_NAND4#9pmos@107_poly-left##3 9.871
R5310 XOR1_to_NAND4#9pmos@107_poly-left##3 XOR1_to_NAND4#9pmos@107_poly-left##4 9.871
R5311 XOR1_to_NAND4#9pmos@107_poly-left##4 XOR1_to_NAND4#9pmos@107_poly-left##5 9.871
R5312 XOR1_to_NAND4#9pmos@107_poly-left##5 XOR1_to_NAND4#9pmos@107_poly-left##6 9.871
R5313 XOR1_to_NAND4#9pmos@107_poly-left##6 XOR1_to_NAND4#9pmos@107_poly-left##7 9.871
R5314 XOR1_to_NAND4#9pmos@107_poly-left##7 XOR1_to_NAND4#9pmos@107_poly-left##8 9.871
R5315 XOR1_to_NAND4#9pmos@107_poly-left##8 XOR1_to_NAND4#9pmos@107_poly-left##9 9.871
R5316 XOR1_to_NAND4#9pmos@107_poly-left##9 XOR1_to_NAND4#9pmos@107_poly-left##10 9.871
R5317 XOR1_to_NAND4#9pmos@107_poly-left##10 XOR1_to_NAND4#9pmos@107_poly-left##11 9.871
R5318 XOR1_to_NAND4#9pmos@107_poly-left##11 XOR1_to_NAND4#9pmos@107_poly-left##12 9.871
R5319 XOR1_to_NAND4#9pmos@107_poly-left##12 XOR1_to_NAND4#9pmos@107_poly-left##13 9.871
R5320 XOR1_to_NAND4#9pmos@107_poly-left##13 XOR1_to_NAND4#9pmos@107_poly-left##14 9.871
R5321 XOR1_to_NAND4#9pmos@107_poly-left##14 XOR1_to_NAND4#9pmos@107_poly-left##15 9.871
R5322 XOR1_to_NAND4#9pmos@107_poly-left##15 XOR1_to_NAND4#9pmos@107_poly-left##16 9.871
R5323 XOR1_to_NAND4#9pmos@107_poly-left##16 XOR1_to_NAND4#9pmos@107_poly-left##17 9.871
R5324 XOR1_to_NAND4#9pmos@107_poly-left##17 XOR1_to_NAND4#9pmos@107_poly-left##18 9.871
R5325 XOR1_to_NAND4#9pmos@107_poly-left##18 XOR1_to_NAND4#9pmos@107_poly-left##19 9.871
R5326 XOR1_to_NAND4#9pmos@107_poly-left##19 XOR1_to_NAND4#9pmos@107_poly-left##20 9.871
R5327 XOR1_to_NAND4#9pmos@107_poly-left##20 XOR1_to_NAND4#9pmos@107_poly-left##21 9.871
R5328 XOR1_to_NAND4#9pmos@107_poly-left##21 XOR1_to_NAND4#9pmos@107_poly-left##22 9.871
R5329 XOR1_to_NAND4#9pmos@107_poly-left##22 XOR1_to_NAND4#9pmos@107_poly-left##23 9.871
R5330 XOR1_to_NAND4#9pmos@107_poly-left##23 XOR1_to_NAND4#9pmos@107_poly-left##24 9.871
R5331 XOR1_to_NAND4#9pmos@107_poly-left##24 XOR1_to_NAND4#9pmos@107_poly-left##25 9.871
R5332 XOR1_to_NAND4#9pmos@107_poly-left##25 XOR1_to_NAND4#9pmos@107_poly-left##26 9.871
R5333 XOR1_to_NAND4#9pmos@107_poly-left##26 XOR1_to_NAND4#9pmos@107_poly-left##27 9.871
R5334 XOR1_to_NAND4#9pmos@107_poly-left##27 XOR1_to_NAND4#9pmos@107_poly-left##28 9.871
R5335 XOR1_to_NAND4#9pmos@107_poly-left##28 XOR1_to_NAND4#9pmos@107_poly-left##29 9.871
R5336 XOR1_to_NAND4#9pmos@107_poly-left##29 XOR1_to_NAND4#9pmos@107_poly-left##30 9.871
R5337 XOR1_to_NAND4#9pmos@107_poly-left##30 XOR1_to_NAND4#9pmos@107_poly-left##31 9.871
R5338 XOR1_to_NAND4#9pmos@107_poly-left##31 XOR1_to_NAND4#9pmos@107_poly-left##32 9.871
R5339 XOR1_to_NAND4#9pmos@107_poly-left##32 XOR1_to_NAND4#9pmos@107_poly-left##33 9.871
R5340 XOR1_to_NAND4#9pmos@107_poly-left##33 XOR1_to_NAND4#9pmos@107_poly-left##34 9.871
R5341 XOR1_to_NAND4#9pmos@107_poly-left##34 XOR1_to_NAND4#9pmos@107_poly-left##35 9.871
R5342 XOR1_to_NAND4#9pmos@107_poly-left##35 XOR1_to_NAND4#9pmos@107_poly-left##36 9.871
R5343 XOR1_to_NAND4#9pmos@107_poly-left##36 XOR1_to_NAND4#9pmos@107_poly-left##37 9.871
R5344 XOR1_to_NAND4#9pmos@107_poly-left##37 XOR1_to_NAND4#9pmos@107_poly-left##38 9.871
R5345 XOR1_to_NAND4#9pmos@107_poly-left##38 XOR1_to_NAND4#9pmos@107_poly-left##39 9.871
R5346 XOR1_to_NAND4#9pmos@107_poly-left##39 XOR1_to_NAND4#9pmos@107_poly-left##40 9.871
R5347 XOR1_to_NAND4#9pmos@107_poly-left##40 XOR1_to_NAND4#9pmos@107_poly-left##41 9.871
R5348 XOR1_to_NAND4#9pmos@107_poly-left##41 XOR1_to_NAND4#9pmos@107_poly-left##42 9.871
R5349 XOR1_to_NAND4#9pmos@107_poly-left##42 XOR1_to_NAND4#9pmos@107_poly-left##43 9.871
R5350 XOR1_to_NAND4#9pmos@107_poly-left##43 XOR1_to_NAND4#9pmos@107_poly-left##44 9.871
R5351 XOR1_to_NAND4#9pmos@107_poly-left##44 XOR1_to_NAND4#9pmos@107_poly-left##45 9.871
R5352 XOR1_to_NAND4#9pmos@107_poly-left##45 XOR1_to_NAND4#9pmos@107_poly-left##46 9.871
R5353 XOR1_to_NAND4#9pmos@107_poly-left##46 XOR1_to_NAND4#9pmos@107_poly-left##47 9.871
R5354 XOR1_to_NAND4#9pmos@107_poly-left##47 XOR1_to_NAND4#9pmos@107_poly-left##48 9.871
R5355 XOR1_to_NAND4#9pmos@107_poly-left##48 XOR1_to_NAND4#9pmos@107_poly-left##49 9.871
R5356 XOR1_to_NAND4#9pmos@107_poly-left##49 XOR1_to_NAND4#9pmos@107_poly-left##50 9.871
R5357 XOR1_to_NAND4#9pmos@107_poly-left##50 XOR1_to_NAND4#9pmos@107_poly-left##51 9.871
R5358 XOR1_to_NAND4#9pmos@107_poly-left##51 XOR1_to_NAND4#9pmos@107_poly-left##52 9.871
R5359 XOR1_to_NAND4#9pmos@107_poly-left##52 XOR1_to_NAND4#9pmos@107_poly-left##53 9.871
R5360 XOR1_to_NAND4#9pmos@107_poly-left##53 XOR1_to_NAND4#9pmos@107_poly-left##54 9.871
R5361 XOR1_to_NAND4#9pmos@107_poly-left##54 XOR1_to_NAND4#9pmos@107_poly-left##55 9.871
R5362 XOR1_to_NAND4#9pmos@107_poly-left##55 XOR1_to_NAND4#26nmos@107_poly-right 9.871
R5363 net@2108#7pmos@108_poly-left net@2108#7pmos@108_poly-left##0 9.871
R5364 net@2108#7pmos@108_poly-left##0 net@2108#7pmos@108_poly-left##1 9.871
R5365 net@2108#7pmos@108_poly-left##1 net@2108#7pmos@108_poly-left##2 9.871
R5366 net@2108#7pmos@108_poly-left##2 net@2108#7pmos@108_poly-left##3 9.871
R5367 net@2108#7pmos@108_poly-left##3 net@2108#7pmos@108_poly-left##4 9.871
R5368 net@2108#7pmos@108_poly-left##4 net@2108#7pmos@108_poly-left##5 9.871
R5369 net@2108#7pmos@108_poly-left##5 net@2108#7pmos@108_poly-left##6 9.871
R5370 net@2108#7pmos@108_poly-left##6 net@2108#7pmos@108_poly-left##7 9.871
R5371 net@2108#7pmos@108_poly-left##7 net@2108#7pmos@108_poly-left##8 9.871
R5372 net@2108#7pmos@108_poly-left##8 net@2108#7pmos@108_poly-left##9 9.871
R5373 net@2108#7pmos@108_poly-left##9 net@2108#7pmos@108_poly-left##10 9.871
R5374 net@2108#7pmos@108_poly-left##10 net@2108#7pmos@108_poly-left##11 9.871
R5375 net@2108#7pmos@108_poly-left##11 net@2108#7pmos@108_poly-left##12 9.871
R5376 net@2108#7pmos@108_poly-left##12 net@2108#7pmos@108_poly-left##13 9.871
R5377 net@2108#7pmos@108_poly-left##13 net@2108#7pmos@108_poly-left##14 9.871
R5378 net@2108#7pmos@108_poly-left##14 net@2108#7pmos@108_poly-left##15 9.871
R5379 net@2108#7pmos@108_poly-left##15 net@2108#7pmos@108_poly-left##16 9.871
R5380 net@2108#7pmos@108_poly-left##16 net@2108#7pmos@108_poly-left##17 9.871
R5381 net@2108#7pmos@108_poly-left##17 net@2108#7pmos@108_poly-left##18 9.871
R5382 net@2108#7pmos@108_poly-left##18 net@2108#7pmos@108_poly-left##19 9.871
R5383 net@2108#7pmos@108_poly-left##19 net@2108#7pmos@108_poly-left##20 9.871
R5384 net@2108#7pmos@108_poly-left##20 net@2108#7pmos@108_poly-left##21 9.871
R5385 net@2108#7pmos@108_poly-left##21 net@2108#7pmos@108_poly-left##22 9.871
R5386 net@2108#7pmos@108_poly-left##22 net@2108#7pmos@108_poly-left##23 9.871
R5387 net@2108#7pmos@108_poly-left##23 net@2108#7pmos@108_poly-left##24 9.871
R5388 net@2108#7pmos@108_poly-left##24 net@2108#7pmos@108_poly-left##25 9.871
R5389 net@2108#7pmos@108_poly-left##25 net@2108#7pmos@108_poly-left##26 9.871
R5390 net@2108#7pmos@108_poly-left##26 net@2108#7pmos@108_poly-left##27 9.871
R5391 net@2108#7pmos@108_poly-left##27 net@2108#7pmos@108_poly-left##28 9.871
R5392 net@2108#7pmos@108_poly-left##28 net@2108#7pmos@108_poly-left##29 9.871
R5393 net@2108#7pmos@108_poly-left##29 net@2108#7pmos@108_poly-left##30 9.871
R5394 net@2108#7pmos@108_poly-left##30 net@2108#7pmos@108_poly-left##31 9.871
R5395 net@2108#7pmos@108_poly-left##31 net@2108#7pmos@108_poly-left##32 9.871
R5396 net@2108#7pmos@108_poly-left##32 net@2108#7pmos@108_poly-left##33 9.871
R5397 net@2108#7pmos@108_poly-left##33 net@2108#7pmos@108_poly-left##34 9.871
R5398 net@2108#7pmos@108_poly-left##34 net@2108#7pmos@108_poly-left##35 9.871
R5399 net@2108#7pmos@108_poly-left##35 net@2108#7pmos@108_poly-left##36 9.871
R5400 net@2108#7pmos@108_poly-left##36 net@2108#7pmos@108_poly-left##37 9.871
R5401 net@2108#7pmos@108_poly-left##37 net@2108#7pmos@108_poly-left##38 9.871
R5402 net@2108#7pmos@108_poly-left##38 net@2108#7pmos@108_poly-left##39 9.871
R5403 net@2108#7pmos@108_poly-left##39 net@2108#7pmos@108_poly-left##40 9.871
R5404 net@2108#7pmos@108_poly-left##40 net@2108#7pmos@108_poly-left##41 9.871
R5405 net@2108#7pmos@108_poly-left##41 net@2108#7pmos@108_poly-left##42 9.871
R5406 net@2108#7pmos@108_poly-left##42 net@2108#7pmos@108_poly-left##43 9.871
R5407 net@2108#7pmos@108_poly-left##43 net@2108#7pmos@108_poly-left##44 9.871
R5408 net@2108#7pmos@108_poly-left##44 net@2108#7pmos@108_poly-left##45 9.871
R5409 net@2108#7pmos@108_poly-left##45 net@2108#7pmos@108_poly-left##46 9.871
R5410 net@2108#7pmos@108_poly-left##46 net@2108#7pmos@108_poly-left##47 9.871
R5411 net@2108#7pmos@108_poly-left##47 net@2108#7pmos@108_poly-left##48 9.871
R5412 net@2108#7pmos@108_poly-left##48 net@2108#7pmos@108_poly-left##49 9.871
R5413 net@2108#7pmos@108_poly-left##49 net@2108#7pmos@108_poly-left##50 9.871
R5414 net@2108#7pmos@108_poly-left##50 net@2108#7pmos@108_poly-left##51 9.871
R5415 net@2108#7pmos@108_poly-left##51 net@2108#7pmos@108_poly-left##52 9.871
R5416 net@2108#7pmos@108_poly-left##52 net@2108#7pmos@108_poly-left##53 9.871
R5417 net@2108#7pmos@108_poly-left##53 net@2108#7pmos@108_poly-left##54 9.871
R5418 net@2108#7pmos@108_poly-left##54 net@2108#7pmos@108_poly-left##55 9.871
R5419 net@2108#7pmos@108_poly-left##55 net@2108#11nmos@108_poly-right 9.871
R5420 Cin_to_XOR2___NAND4#27pmos@109_poly-right Cin_to_XOR2___NAND4#27pmos@109_poly-right##0 9.871
R5421 Cin_to_XOR2___NAND4#27pmos@109_poly-right##0 Cin_to_XOR2___NAND4#27pmos@109_poly-right##1 9.871
R5422 Cin_to_XOR2___NAND4#27pmos@109_poly-right##1 Cin_to_XOR2___NAND4#27pmos@109_poly-right##2 9.871
R5423 Cin_to_XOR2___NAND4#27pmos@109_poly-right##2 Cin_to_XOR2___NAND4#27pmos@109_poly-right##3 9.871
R5424 Cin_to_XOR2___NAND4#27pmos@109_poly-right##3 Cin_to_XOR2___NAND4#27pmos@109_poly-right##4 9.871
R5425 Cin_to_XOR2___NAND4#27pmos@109_poly-right##4 Cin_to_XOR2___NAND4#27pmos@109_poly-right##5 9.871
R5426 Cin_to_XOR2___NAND4#27pmos@109_poly-right##5 Cin_to_XOR2___NAND4#27pmos@109_poly-right##6 9.871
R5427 Cin_to_XOR2___NAND4#27pmos@109_poly-right##6 Cin_to_XOR2___NAND4#27pmos@109_poly-right##7 9.871
R5428 Cin_to_XOR2___NAND4#27pmos@109_poly-right##7 Cin_to_XOR2___NAND4#27pmos@109_poly-right##8 9.871
R5429 Cin_to_XOR2___NAND4#27pmos@109_poly-right##8 Cin_to_XOR2___NAND4#27pmos@109_poly-right##9 9.871
R5430 Cin_to_XOR2___NAND4#27pmos@109_poly-right##9 Cin_to_XOR2___NAND4#27pmos@109_poly-right##10 9.871
R5431 Cin_to_XOR2___NAND4#27pmos@109_poly-right##10 Cin_to_XOR2___NAND4#27pmos@109_poly-right##11 9.871
R5432 Cin_to_XOR2___NAND4#27pmos@109_poly-right##11 Cin_to_XOR2___NAND4#27pmos@109_poly-right##12 9.871
R5433 Cin_to_XOR2___NAND4#27pmos@109_poly-right##12 Cin_to_XOR2___NAND4#27pmos@109_poly-right##13 9.871
R5434 Cin_to_XOR2___NAND4#27pmos@109_poly-right##13 Cin_to_XOR2___NAND4#27pmos@109_poly-right##14 9.871
R5435 Cin_to_XOR2___NAND4#27pmos@109_poly-right##14 Cin_to_XOR2___NAND4#27pmos@109_poly-right##15 9.871
R5436 Cin_to_XOR2___NAND4#27pmos@109_poly-right##15 Cin_to_XOR2___NAND4#27pmos@109_poly-right##16 9.871
R5437 Cin_to_XOR2___NAND4#27pmos@109_poly-right##16 Cin_to_XOR2___NAND4#27pmos@109_poly-right##17 9.871
R5438 Cin_to_XOR2___NAND4#27pmos@109_poly-right##17 Cin_to_XOR2___NAND4#27pmos@109_poly-right##18 9.871
R5439 Cin_to_XOR2___NAND4#27pmos@109_poly-right##18 Cin_to_XOR2___NAND4#27pmos@109_poly-right##19 9.871
R5440 Cin_to_XOR2___NAND4#27pmos@109_poly-right##19 Cin_to_XOR2___NAND4#27pmos@109_poly-right##20 9.871
R5441 Cin_to_XOR2___NAND4#27pmos@109_poly-right##20 Cin_to_XOR2___NAND4#27pmos@109_poly-right##21 9.871
R5442 Cin_to_XOR2___NAND4#27pmos@109_poly-right##21 Cin_to_XOR2___NAND4#27pmos@109_poly-right##22 9.871
R5443 Cin_to_XOR2___NAND4#27pmos@109_poly-right##22 Cin_to_XOR2___NAND4#27pmos@109_poly-right##23 9.871
R5444 Cin_to_XOR2___NAND4#27pmos@109_poly-right##23 Cin_to_XOR2___NAND4#27pmos@109_poly-right##24 9.871
R5445 Cin_to_XOR2___NAND4#27pmos@109_poly-right##24 Cin_to_XOR2___NAND4#27pmos@109_poly-right##25 9.871
R5446 Cin_to_XOR2___NAND4#27pmos@109_poly-right##25 Cin_to_XOR2___NAND4#27pmos@109_poly-right##26 9.871
R5447 Cin_to_XOR2___NAND4#27pmos@109_poly-right##26 Cin_to_XOR2___NAND4#27pmos@109_poly-right##27 9.871
R5448 Cin_to_XOR2___NAND4#27pmos@109_poly-right##27 Cin_to_XOR2___NAND4#27pmos@109_poly-right##28 9.871
R5449 Cin_to_XOR2___NAND4#27pmos@109_poly-right##28 Cin_to_XOR2___NAND4#27pmos@109_poly-right##29 9.871
R5450 Cin_to_XOR2___NAND4#27pmos@109_poly-right##29 Cin_to_XOR2___NAND4#27pmos@109_poly-right##30 9.871
R5451 Cin_to_XOR2___NAND4#27pmos@109_poly-right##30 Cin_to_XOR2___NAND4#27pmos@109_poly-right##31 9.871
R5452 Cin_to_XOR2___NAND4#27pmos@109_poly-right##31 Cin_to_XOR2___NAND4#27pmos@109_poly-right##32 9.871
R5453 Cin_to_XOR2___NAND4#27pmos@109_poly-right##32 Cin_to_XOR2___NAND4#27pmos@109_poly-right##33 9.871
R5454 Cin_to_XOR2___NAND4#27pmos@109_poly-right##33 Cin_to_XOR2___NAND4#27pmos@109_poly-right##34 9.871
R5455 Cin_to_XOR2___NAND4#27pmos@109_poly-right##34 Cin_to_XOR2___NAND4#27pmos@109_poly-right##35 9.871
R5456 Cin_to_XOR2___NAND4#27pmos@109_poly-right##35 Cin_to_XOR2___NAND4#27pmos@109_poly-right##36 9.871
R5457 Cin_to_XOR2___NAND4#27pmos@109_poly-right##36 Cin_to_XOR2___NAND4#27pmos@109_poly-right##37 9.871
R5458 Cin_to_XOR2___NAND4#27pmos@109_poly-right##37 Cin_to_XOR2___NAND4#27pmos@109_poly-right##38 9.871
R5459 Cin_to_XOR2___NAND4#27pmos@109_poly-right##38 Cin_to_XOR2___NAND4#27pmos@109_poly-right##39 9.871
R5460 Cin_to_XOR2___NAND4#27pmos@109_poly-right##39 Cin_to_XOR2___NAND4#27pmos@109_poly-right##40 9.871
R5461 Cin_to_XOR2___NAND4#27pmos@109_poly-right##40 Cin_to_XOR2___NAND4#27pmos@109_poly-right##41 9.871
R5462 Cin_to_XOR2___NAND4#27pmos@109_poly-right##41 Cin_to_XOR2___NAND4#27pmos@109_poly-right##42 9.871
R5463 Cin_to_XOR2___NAND4#27pmos@109_poly-right##42 Cin_to_XOR2___NAND4#27pmos@109_poly-right##43 9.871
R5464 Cin_to_XOR2___NAND4#27pmos@109_poly-right##43 Cin_to_XOR2___NAND4#27pmos@109_poly-right##44 9.871
R5465 Cin_to_XOR2___NAND4#27pmos@109_poly-right##44 Cin_to_XOR2___NAND4#27pmos@109_poly-right##45 9.871
R5466 Cin_to_XOR2___NAND4#27pmos@109_poly-right##45 Cin_to_XOR2___NAND4#27pmos@109_poly-right##46 9.871
R5467 Cin_to_XOR2___NAND4#27pmos@109_poly-right##46 Cin_to_XOR2___NAND4#27pmos@109_poly-right##47 9.871
R5468 Cin_to_XOR2___NAND4#27pmos@109_poly-right##47 Cin_to_XOR2___NAND4#27pmos@109_poly-right##48 9.871
R5469 Cin_to_XOR2___NAND4#27pmos@109_poly-right##48 Cin_to_XOR2___NAND4#27pmos@109_poly-right##49 9.871
R5470 Cin_to_XOR2___NAND4#27pmos@109_poly-right##49 Cin_to_XOR2___NAND4#27pmos@109_poly-right##50 9.871
R5471 Cin_to_XOR2___NAND4#27pmos@109_poly-right##50 Cin_to_XOR2___NAND4#27pmos@109_poly-right##51 9.871
R5472 Cin_to_XOR2___NAND4#27pmos@109_poly-right##51 Cin_to_XOR2___NAND4#27pmos@109_poly-right##52 9.871
R5473 Cin_to_XOR2___NAND4#27pmos@109_poly-right##52 Cin_to_XOR2___NAND4#27pmos@109_poly-right##53 9.871
R5474 Cin_to_XOR2___NAND4#27pmos@109_poly-right##53 Cin_to_XOR2___NAND4#27pmos@109_poly-right##54 9.871
R5475 Cin_to_XOR2___NAND4#27pmos@109_poly-right##54 Cin_to_XOR2___NAND4#27pmos@109_poly-right##55 9.871
R5476 Cin_to_XOR2___NAND4#27pmos@109_poly-right##55 Cin_to_XOR2___NAND4#18nmos@109_poly-left 9.871
R5477 net@2118#14pmos@110_poly-right net@2118#14pmos@110_poly-right##0 9.871
R5478 net@2118#14pmos@110_poly-right##0 net@2118#14pmos@110_poly-right##1 9.871
R5479 net@2118#14pmos@110_poly-right##1 net@2118#14pmos@110_poly-right##2 9.871
R5480 net@2118#14pmos@110_poly-right##2 net@2118#14pmos@110_poly-right##3 9.871
R5481 net@2118#14pmos@110_poly-right##3 net@2118#14pmos@110_poly-right##4 9.871
R5482 net@2118#14pmos@110_poly-right##4 net@2118#14pmos@110_poly-right##5 9.871
R5483 net@2118#14pmos@110_poly-right##5 net@2118#14pmos@110_poly-right##6 9.871
R5484 net@2118#14pmos@110_poly-right##6 net@2118#14pmos@110_poly-right##7 9.871
R5485 net@2118#14pmos@110_poly-right##7 net@2118#14pmos@110_poly-right##8 9.871
R5486 net@2118#14pmos@110_poly-right##8 net@2118#14pmos@110_poly-right##9 9.871
R5487 net@2118#14pmos@110_poly-right##9 net@2118#14pmos@110_poly-right##10 9.871
R5488 net@2118#14pmos@110_poly-right##10 net@2118#14pmos@110_poly-right##11 9.871
R5489 net@2118#14pmos@110_poly-right##11 net@2118#14pmos@110_poly-right##12 9.871
R5490 net@2118#14pmos@110_poly-right##12 net@2118#14pmos@110_poly-right##13 9.871
R5491 net@2118#14pmos@110_poly-right##13 net@2118#14pmos@110_poly-right##14 9.871
R5492 net@2118#14pmos@110_poly-right##14 net@2118#14pmos@110_poly-right##15 9.871
R5493 net@2118#14pmos@110_poly-right##15 net@2118#14pmos@110_poly-right##16 9.871
R5494 net@2118#14pmos@110_poly-right##16 net@2118#14pmos@110_poly-right##17 9.871
R5495 net@2118#14pmos@110_poly-right##17 net@2118#14pmos@110_poly-right##18 9.871
R5496 net@2118#14pmos@110_poly-right##18 net@2118#14pmos@110_poly-right##19 9.871
R5497 net@2118#14pmos@110_poly-right##19 net@2118#14pmos@110_poly-right##20 9.871
R5498 net@2118#14pmos@110_poly-right##20 net@2118#14pmos@110_poly-right##21 9.871
R5499 net@2118#14pmos@110_poly-right##21 net@2118#14pmos@110_poly-right##22 9.871
R5500 net@2118#14pmos@110_poly-right##22 net@2118#14pmos@110_poly-right##23 9.871
R5501 net@2118#14pmos@110_poly-right##23 net@2118#14pmos@110_poly-right##24 9.871
R5502 net@2118#14pmos@110_poly-right##24 net@2118#14pmos@110_poly-right##25 9.871
R5503 net@2118#14pmos@110_poly-right##25 net@2118#14pmos@110_poly-right##26 9.871
R5504 net@2118#14pmos@110_poly-right##26 net@2118#14pmos@110_poly-right##27 9.871
R5505 net@2118#14pmos@110_poly-right##27 net@2118#14pmos@110_poly-right##28 9.871
R5506 net@2118#14pmos@110_poly-right##28 net@2118#14pmos@110_poly-right##29 9.871
R5507 net@2118#14pmos@110_poly-right##29 net@2118#14pmos@110_poly-right##30 9.871
R5508 net@2118#14pmos@110_poly-right##30 net@2118#14pmos@110_poly-right##31 9.871
R5509 net@2118#14pmos@110_poly-right##31 net@2118#14pmos@110_poly-right##32 9.871
R5510 net@2118#14pmos@110_poly-right##32 net@2118#14pmos@110_poly-right##33 9.871
R5511 net@2118#14pmos@110_poly-right##33 net@2118#14pmos@110_poly-right##34 9.871
R5512 net@2118#14pmos@110_poly-right##34 net@2118#14pmos@110_poly-right##35 9.871
R5513 net@2118#14pmos@110_poly-right##35 net@2118#14pmos@110_poly-right##36 9.871
R5514 net@2118#14pmos@110_poly-right##36 net@2118#14pmos@110_poly-right##37 9.871
R5515 net@2118#14pmos@110_poly-right##37 net@2118#14pmos@110_poly-right##38 9.871
R5516 net@2118#14pmos@110_poly-right##38 net@2118#14pmos@110_poly-right##39 9.871
R5517 net@2118#14pmos@110_poly-right##39 net@2118#14pmos@110_poly-right##40 9.871
R5518 net@2118#14pmos@110_poly-right##40 net@2118#14pmos@110_poly-right##41 9.871
R5519 net@2118#14pmos@110_poly-right##41 net@2118#14pmos@110_poly-right##42 9.871
R5520 net@2118#14pmos@110_poly-right##42 net@2118#14pmos@110_poly-right##43 9.871
R5521 net@2118#14pmos@110_poly-right##43 net@2118#14pmos@110_poly-right##44 9.871
R5522 net@2118#14pmos@110_poly-right##44 net@2118#14pmos@110_poly-right##45 9.871
R5523 net@2118#14pmos@110_poly-right##45 net@2118#14pmos@110_poly-right##46 9.871
R5524 net@2118#14pmos@110_poly-right##46 net@2118#14pmos@110_poly-right##47 9.871
R5525 net@2118#14pmos@110_poly-right##47 net@2118#14pmos@110_poly-right##48 9.871
R5526 net@2118#14pmos@110_poly-right##48 net@2118#14pmos@110_poly-right##49 9.871
R5527 net@2118#14pmos@110_poly-right##49 net@2118#14pmos@110_poly-right##50 9.871
R5528 net@2118#14pmos@110_poly-right##50 net@2118#14pmos@110_poly-right##51 9.871
R5529 net@2118#14pmos@110_poly-right##51 net@2118#14pmos@110_poly-right##52 9.871
R5530 net@2118#14pmos@110_poly-right##52 net@2118#14pmos@110_poly-right##53 9.871
R5531 net@2118#14pmos@110_poly-right##53 net@2118#14pmos@110_poly-right##54 9.871
R5532 net@2118#14pmos@110_poly-right##54 net@2118#14pmos@110_poly-right##55 9.871
R5533 net@2118#14pmos@110_poly-right##55 net@2118#9nmos@110_poly-left 9.871
R5534 net@2117#2contact@752_metal-1-polysilicon-1 net@2117 4.654
R5535 net@2117#12pmos@113_poly-right net@2117#12pmos@113_poly-right##0 9.931
R5536 net@2117#12pmos@113_poly-right##0 net@2117#12pmos@113_poly-right##1 9.931
R5537 net@2117#12pmos@113_poly-right##1 net@2117#12pmos@113_poly-right##2 9.931
R5538 net@2117#12pmos@113_poly-right##2 net@2117#12pmos@113_poly-right##3 9.931
R5539 net@2117#12pmos@113_poly-right##3 net@2117#12pmos@113_poly-right##4 9.931
R5540 net@2117#12pmos@113_poly-right##4 net@2117#12pmos@113_poly-right##5 9.931
R5541 net@2117#12pmos@113_poly-right##5 net@2117#12pmos@113_poly-right##6 9.931
R5542 net@2117#12pmos@113_poly-right##6 net@2117#12pmos@113_poly-right##7 9.931
R5543 net@2117#12pmos@113_poly-right##7 net@2117#12pmos@113_poly-right##8 9.931
R5544 net@2117#12pmos@113_poly-right##8 net@2117#12pmos@113_poly-right##9 9.931
R5545 net@2117#12pmos@113_poly-right##9 net@2117#12pmos@113_poly-right##10 9.931
R5546 net@2117#12pmos@113_poly-right##10 net@2117#12pmos@113_poly-right##11 9.931
R5547 net@2117#12pmos@113_poly-right##11 net@2117#12pmos@113_poly-right##12 9.931
R5548 net@2117#12pmos@113_poly-right##12 net@2117#12pmos@113_poly-right##13 9.931
R5549 net@2117#12pmos@113_poly-right##13 net@2117#12pmos@113_poly-right##14 9.931
R5550 net@2117#12pmos@113_poly-right##14 net@2117#12pmos@113_poly-right##15 9.931
R5551 net@2117#12pmos@113_poly-right##15 net@2117#12pmos@113_poly-right##16 9.931
R5552 net@2117#12pmos@113_poly-right##16 net@2117#12pmos@113_poly-right##17 9.931
R5553 net@2117#12pmos@113_poly-right##17 net@2117#12pmos@113_poly-right##18 9.931
R5554 net@2117#12pmos@113_poly-right##18 net@2117#12pmos@113_poly-right##19 9.931
R5555 net@2117#12pmos@113_poly-right##19 net@2117#12pmos@113_poly-right##20 9.931
R5556 net@2117#12pmos@113_poly-right##20 net@2117#12pmos@113_poly-right##21 9.931
R5557 net@2117#12pmos@113_poly-right##21 net@2117#12pmos@113_poly-right##22 9.931
R5558 net@2117#12pmos@113_poly-right##22 net@2117#12pmos@113_poly-right##23 9.931
R5559 net@2117#12pmos@113_poly-right##23 net@2117#12pmos@113_poly-right##24 9.931
R5560 net@2117#12pmos@113_poly-right##24 net@2117#12pmos@113_poly-right##25 9.931
R5561 net@2117#12pmos@113_poly-right##25 net@2117#12pmos@113_poly-right##26 9.931
R5562 net@2117#12pmos@113_poly-right##26 net@2117#12pmos@113_poly-right##27 9.931
R5563 net@2117#12pmos@113_poly-right##27 net@2117#12pmos@113_poly-right##28 9.931
R5564 net@2117#12pmos@113_poly-right##28 net@2117#12pmos@113_poly-right##29 9.931
R5565 net@2117#12pmos@113_poly-right##29 net@2117#12pmos@113_poly-right##30 9.931
R5566 net@2117#12pmos@113_poly-right##30 net@2117#12pmos@113_poly-right##31 9.931
R5567 net@2117#12pmos@113_poly-right##31 net@2117#12pmos@113_poly-right##32 9.931
R5568 net@2117#12pmos@113_poly-right##32 net@2117#12pmos@113_poly-right##33 9.931
R5569 net@2117#12pmos@113_poly-right##33 net@2117#12pmos@113_poly-right##34 9.931
R5570 net@2117#12pmos@113_poly-right##34 net@2117#12pmos@113_poly-right##35 9.931
R5571 net@2117#12pmos@113_poly-right##35 net@2117#12pmos@113_poly-right##36 9.931
R5572 net@2117#12pmos@113_poly-right##36 net@2117#12pmos@113_poly-right##37 9.931
R5573 net@2117#12pmos@113_poly-right##37 net@2117#12pmos@113_poly-right##38 9.931
R5574 net@2117#12pmos@113_poly-right##38 net@2117#12pmos@113_poly-right##39 9.931
R5575 net@2117#12pmos@113_poly-right##39 net@2117#12pmos@113_poly-right##40 9.931
R5576 net@2117#12pmos@113_poly-right##40 net@2117#12pmos@113_poly-right##41 9.931
R5577 net@2117#12pmos@113_poly-right##41 net@2117#12pmos@113_poly-right##42 9.931
R5578 net@2117#12pmos@113_poly-right##42 net@2117#12pmos@113_poly-right##43 9.931
R5579 net@2117#12pmos@113_poly-right##43 net@2117#12pmos@113_poly-right##44 9.931
R5580 net@2117#12pmos@113_poly-right##44 net@2117#12pmos@113_poly-right##45 9.931
R5581 net@2117#12pmos@113_poly-right##45 net@2117#12pmos@113_poly-right##46 9.931
R5582 net@2117#12pmos@113_poly-right##46 net@2117#12pmos@113_poly-right##47 9.931
R5583 net@2117#12pmos@113_poly-right##47 net@2117#12pmos@113_poly-right##48 9.931
R5584 net@2117#12pmos@113_poly-right##48 net@2117#12pmos@113_poly-right##49 9.931
R5585 net@2117#12pmos@113_poly-right##49 net@2117#12pmos@113_poly-right##50 9.931
R5586 net@2117#12pmos@113_poly-right##50 net@2117#12pmos@113_poly-right##51 9.931
R5587 net@2117#12pmos@113_poly-right##51 net@2117#12pmos@113_poly-right##52 9.931
R5588 net@2117#12pmos@113_poly-right##52 net@2117#5pin@659_polysilicon-1 9.931
R5589 Sum3#4pmos@113_diff-top Sum3 4.823
R5590 XOR1_to_NAND4#14pin@671_polysilicon-1 XOR1_to_NAND4#14pin@671_polysilicon-1##0 9.854
R5591 XOR1_to_NAND4#14pin@671_polysilicon-1##0 XOR1_to_NAND4#14pin@671_polysilicon-1##1 9.854
R5592 XOR1_to_NAND4#14pin@671_polysilicon-1##1 XOR1_to_NAND4#14pin@671_polysilicon-1##2 9.854
R5593 XOR1_to_NAND4#14pin@671_polysilicon-1##2 XOR1_to_NAND4#14pin@671_polysilicon-1##3 9.854
R5594 XOR1_to_NAND4#14pin@671_polysilicon-1##3 XOR1_to_NAND4#14pin@671_polysilicon-1##4 9.854
R5595 XOR1_to_NAND4#14pin@671_polysilicon-1##4 XOR1_to_NAND4#14pin@671_polysilicon-1##5 9.854
R5596 XOR1_to_NAND4#14pin@671_polysilicon-1##5 XOR1_to_NAND4#14pin@671_polysilicon-1##6 9.854
R5597 XOR1_to_NAND4#14pin@671_polysilicon-1##6 XOR1_to_NAND4#14pin@671_polysilicon-1##7 9.854
R5598 XOR1_to_NAND4#14pin@671_polysilicon-1##7 XOR1_to_NAND4#14pin@671_polysilicon-1##8 9.854
R5599 XOR1_to_NAND4#14pin@671_polysilicon-1##8 XOR1_to_NAND4#14pin@671_polysilicon-1##9 9.854
R5600 XOR1_to_NAND4#14pin@671_polysilicon-1##9 XOR1_to_NAND4#14pin@671_polysilicon-1##10 9.854
R5601 XOR1_to_NAND4#14pin@671_polysilicon-1##10 XOR1_to_NAND4#14pin@671_polysilicon-1##11 9.854
R5602 XOR1_to_NAND4#14pin@671_polysilicon-1##11 XOR1_to_NAND4#14pin@671_polysilicon-1##12 9.854
R5603 XOR1_to_NAND4#14pin@671_polysilicon-1##12 XOR1_to_NAND4#14pin@671_polysilicon-1##13 9.854
R5604 XOR1_to_NAND4#14pin@671_polysilicon-1##13 XOR1_to_NAND4#14pin@671_polysilicon-1##14 9.854
R5605 XOR1_to_NAND4#14pin@671_polysilicon-1##14 XOR1_to_NAND4#14pin@671_polysilicon-1##15 9.854
R5606 XOR1_to_NAND4#14pin@671_polysilicon-1##15 XOR1_to_NAND4#14pin@671_polysilicon-1##16 9.854
R5607 XOR1_to_NAND4#14pin@671_polysilicon-1##16 XOR1_to_NAND4#14pin@671_polysilicon-1##17 9.854
R5608 XOR1_to_NAND4#14pin@671_polysilicon-1##17 XOR1_to_NAND4#14pin@671_polysilicon-1##18 9.854
R5609 XOR1_to_NAND4#14pin@671_polysilicon-1##18 XOR1_to_NAND4#14pin@671_polysilicon-1##19 9.854
R5610 XOR1_to_NAND4#14pin@671_polysilicon-1##19 XOR1_to_NAND4#14pin@671_polysilicon-1##20 9.854
R5611 XOR1_to_NAND4#14pin@671_polysilicon-1##20 XOR1_to_NAND4#14pin@671_polysilicon-1##21 9.854
R5612 XOR1_to_NAND4#14pin@671_polysilicon-1##21 XOR1_to_NAND4#14pin@671_polysilicon-1##22 9.854
R5613 XOR1_to_NAND4#14pin@671_polysilicon-1##22 XOR1_to_NAND4#14pin@671_polysilicon-1##23 9.854
R5614 XOR1_to_NAND4#14pin@671_polysilicon-1##23 XOR1_to_NAND4#14pin@671_polysilicon-1##24 9.854
R5615 XOR1_to_NAND4#14pin@671_polysilicon-1##24 XOR1_to_NAND4#14pin@671_polysilicon-1##25 9.854
R5616 XOR1_to_NAND4#14pin@671_polysilicon-1##25 XOR1_to_NAND4#14pin@671_polysilicon-1##26 9.854
R5617 XOR1_to_NAND4#14pin@671_polysilicon-1##26 XOR1_to_NAND4#14pin@671_polysilicon-1##27 9.854
R5618 XOR1_to_NAND4#14pin@671_polysilicon-1##27 XOR1_to_NAND4#14pin@671_polysilicon-1##28 9.854
R5619 XOR1_to_NAND4#14pin@671_polysilicon-1##28 XOR1_to_NAND4#14pin@671_polysilicon-1##29 9.854
R5620 XOR1_to_NAND4#14pin@671_polysilicon-1##29 XOR1_to_NAND4#14pin@671_polysilicon-1##30 9.854
R5621 XOR1_to_NAND4#14pin@671_polysilicon-1##30 XOR1_to_NAND4#14pin@671_polysilicon-1##31 9.854
R5622 XOR1_to_NAND4#14pin@671_polysilicon-1##31 XOR1_to_NAND4#14pin@671_polysilicon-1##32 9.854
R5623 XOR1_to_NAND4#14pin@671_polysilicon-1##32 XOR1_to_NAND4#14pin@671_polysilicon-1##33 9.854
R5624 XOR1_to_NAND4#14pin@671_polysilicon-1##33 XOR1_to_NAND4#14pin@671_polysilicon-1##34 9.854
R5625 XOR1_to_NAND4#14pin@671_polysilicon-1##34 XOR1_to_NAND4#14pin@671_polysilicon-1##35 9.854
R5626 XOR1_to_NAND4#14pin@671_polysilicon-1##35 XOR1_to_NAND4#14pin@671_polysilicon-1##36 9.854
R5627 XOR1_to_NAND4#14pin@671_polysilicon-1##36 XOR1_to_NAND4#14pin@671_polysilicon-1##37 9.854
R5628 XOR1_to_NAND4#14pin@671_polysilicon-1##37 XOR1_to_NAND4#14pin@671_polysilicon-1##38 9.854
R5629 XOR1_to_NAND4#14pin@671_polysilicon-1##38 XOR1_to_NAND4#14pin@671_polysilicon-1##39 9.854
R5630 XOR1_to_NAND4#14pin@671_polysilicon-1##39 XOR1_to_NAND4#14pin@671_polysilicon-1##40 9.854
R5631 XOR1_to_NAND4#14pin@671_polysilicon-1##40 XOR1_to_NAND4#14pin@671_polysilicon-1##41 9.854
R5632 XOR1_to_NAND4#14pin@671_polysilicon-1##41 XOR1_to_NAND4#14pin@671_polysilicon-1##42 9.854
R5633 XOR1_to_NAND4#14pin@671_polysilicon-1##42 XOR1_to_NAND4#14pin@671_polysilicon-1##43 9.854
R5634 XOR1_to_NAND4#14pin@671_polysilicon-1##43 XOR1_to_NAND4#14pin@671_polysilicon-1##44 9.854
R5635 XOR1_to_NAND4#14pin@671_polysilicon-1##44 XOR1_to_NAND4#14pin@671_polysilicon-1##45 9.854
R5636 XOR1_to_NAND4#14pin@671_polysilicon-1##45 XOR1_to_NAND4#14pin@671_polysilicon-1##46 9.854
R5637 XOR1_to_NAND4#14pin@671_polysilicon-1##46 XOR1_to_NAND4#14pin@671_polysilicon-1##47 9.854
R5638 XOR1_to_NAND4#14pin@671_polysilicon-1##47 XOR1_to_NAND4#14pin@671_polysilicon-1##48 9.854
R5639 XOR1_to_NAND4#14pin@671_polysilicon-1##48 XOR1_to_NAND4#14pin@671_polysilicon-1##49 9.854
R5640 XOR1_to_NAND4#14pin@671_polysilicon-1##49 XOR1_to_NAND4#14pin@671_polysilicon-1##50 9.854
R5641 XOR1_to_NAND4#14pin@671_polysilicon-1##50 XOR1_to_NAND4#14pin@671_polysilicon-1##51 9.854
R5642 XOR1_to_NAND4#14pin@671_polysilicon-1##51 XOR1_to_NAND4#14pin@671_polysilicon-1##52 9.854
R5643 XOR1_to_NAND4#14pin@671_polysilicon-1##52 XOR1_to_NAND4#14pin@671_polysilicon-1##53 9.854
R5644 XOR1_to_NAND4#14pin@671_polysilicon-1##53 XOR1_to_NAND4#14pin@671_polysilicon-1##54 9.854
R5645 XOR1_to_NAND4#14pin@671_polysilicon-1##54 XOR1_to_NAND4#27nmos@114_poly-right 9.854
R5646 Cin_to_XOR2___NAND4#29pmos@115_poly-right Cin_to_XOR2___NAND4#29pmos@115_poly-right##0 9.877
R5647 Cin_to_XOR2___NAND4#29pmos@115_poly-right##0 Cin_to_XOR2___NAND4#29pmos@115_poly-right##1 9.877
R5648 Cin_to_XOR2___NAND4#29pmos@115_poly-right##1 Cin_to_XOR2___NAND4#29pmos@115_poly-right##2 9.877
R5649 Cin_to_XOR2___NAND4#29pmos@115_poly-right##2 Cin_to_XOR2___NAND4#29pmos@115_poly-right##3 9.877
R5650 Cin_to_XOR2___NAND4#29pmos@115_poly-right##3 Cin_to_XOR2___NAND4#29pmos@115_poly-right##4 9.877
R5651 Cin_to_XOR2___NAND4#29pmos@115_poly-right##4 Cin_to_XOR2___NAND4#29pmos@115_poly-right##5 9.877
R5652 Cin_to_XOR2___NAND4#29pmos@115_poly-right##5 Cin_to_XOR2___NAND4#29pmos@115_poly-right##6 9.877
R5653 Cin_to_XOR2___NAND4#29pmos@115_poly-right##6 Cin_to_XOR2___NAND4#29pmos@115_poly-right##7 9.877
R5654 Cin_to_XOR2___NAND4#29pmos@115_poly-right##7 Cin_to_XOR2___NAND4#29pmos@115_poly-right##8 9.877
R5655 Cin_to_XOR2___NAND4#29pmos@115_poly-right##8 Cin_to_XOR2___NAND4#29pmos@115_poly-right##9 9.877
R5656 Cin_to_XOR2___NAND4#29pmos@115_poly-right##9 Cin_to_XOR2___NAND4#29pmos@115_poly-right##10 9.877
R5657 Cin_to_XOR2___NAND4#29pmos@115_poly-right##10 Cin_to_XOR2___NAND4#29pmos@115_poly-right##11 9.877
R5658 Cin_to_XOR2___NAND4#29pmos@115_poly-right##11 Cin_to_XOR2___NAND4#29pmos@115_poly-right##12 9.877
R5659 Cin_to_XOR2___NAND4#29pmos@115_poly-right##12 Cin_to_XOR2___NAND4#29pmos@115_poly-right##13 9.877
R5660 Cin_to_XOR2___NAND4#29pmos@115_poly-right##13 Cin_to_XOR2___NAND4#29pmos@115_poly-right##14 9.877
R5661 Cin_to_XOR2___NAND4#29pmos@115_poly-right##14 Cin_to_XOR2___NAND4#29pmos@115_poly-right##15 9.877
R5662 Cin_to_XOR2___NAND4#29pmos@115_poly-right##15 Cin_to_XOR2___NAND4#29pmos@115_poly-right##16 9.877
R5663 Cin_to_XOR2___NAND4#29pmos@115_poly-right##16 Cin_to_XOR2___NAND4#29pmos@115_poly-right##17 9.877
R5664 Cin_to_XOR2___NAND4#29pmos@115_poly-right##17 Cin_to_XOR2___NAND4#29pmos@115_poly-right##18 9.877
R5665 Cin_to_XOR2___NAND4#29pmos@115_poly-right##18 Cin_to_XOR2___NAND4#29pmos@115_poly-right##19 9.877
R5666 Cin_to_XOR2___NAND4#29pmos@115_poly-right##19 Cin_to_XOR2___NAND4#29pmos@115_poly-right##20 9.877
R5667 Cin_to_XOR2___NAND4#29pmos@115_poly-right##20 Cin_to_XOR2___NAND4#29pmos@115_poly-right##21 9.877
R5668 Cin_to_XOR2___NAND4#29pmos@115_poly-right##21 Cin_to_XOR2___NAND4#29pmos@115_poly-right##22 9.877
R5669 Cin_to_XOR2___NAND4#29pmos@115_poly-right##22 Cin_to_XOR2___NAND4#29pmos@115_poly-right##23 9.877
R5670 Cin_to_XOR2___NAND4#29pmos@115_poly-right##23 Cin_to_XOR2___NAND4#29pmos@115_poly-right##24 9.877
R5671 Cin_to_XOR2___NAND4#29pmos@115_poly-right##24 Cin_to_XOR2___NAND4#29pmos@115_poly-right##25 9.877
R5672 Cin_to_XOR2___NAND4#29pmos@115_poly-right##25 Cin_to_XOR2___NAND4#29pmos@115_poly-right##26 9.877
R5673 Cin_to_XOR2___NAND4#29pmos@115_poly-right##26 Cin_to_XOR2___NAND4#29pmos@115_poly-right##27 9.877
R5674 Cin_to_XOR2___NAND4#29pmos@115_poly-right##27 Cin_to_XOR2___NAND4#29pmos@115_poly-right##28 9.877
R5675 Cin_to_XOR2___NAND4#29pmos@115_poly-right##28 Cin_to_XOR2___NAND4#29pmos@115_poly-right##29 9.877
R5676 Cin_to_XOR2___NAND4#29pmos@115_poly-right##29 Cin_to_XOR2___NAND4#29pmos@115_poly-right##30 9.877
R5677 Cin_to_XOR2___NAND4#29pmos@115_poly-right##30 Cin_to_XOR2___NAND4#29pmos@115_poly-right##31 9.877
R5678 Cin_to_XOR2___NAND4#29pmos@115_poly-right##31 Cin_to_XOR2___NAND4#29pmos@115_poly-right##32 9.877
R5679 Cin_to_XOR2___NAND4#29pmos@115_poly-right##32 Cin_to_XOR2___NAND4#29pmos@115_poly-right##33 9.877
R5680 Cin_to_XOR2___NAND4#29pmos@115_poly-right##33 Cin_to_XOR2___NAND4#29pmos@115_poly-right##34 9.877
R5681 Cin_to_XOR2___NAND4#29pmos@115_poly-right##34 Cin_to_XOR2___NAND4#29pmos@115_poly-right##35 9.877
R5682 Cin_to_XOR2___NAND4#29pmos@115_poly-right##35 Cin_to_XOR2___NAND4#29pmos@115_poly-right##36 9.877
R5683 Cin_to_XOR2___NAND4#29pmos@115_poly-right##36 Cin_to_XOR2___NAND4#29pmos@115_poly-right##37 9.877
R5684 Cin_to_XOR2___NAND4#29pmos@115_poly-right##37 Cin_to_XOR2___NAND4#29pmos@115_poly-right##38 9.877
R5685 Cin_to_XOR2___NAND4#29pmos@115_poly-right##38 Cin_to_XOR2___NAND4#29pmos@115_poly-right##39 9.877
R5686 Cin_to_XOR2___NAND4#29pmos@115_poly-right##39 Cin_to_XOR2___NAND4#29pmos@115_poly-right##40 9.877
R5687 Cin_to_XOR2___NAND4#29pmos@115_poly-right##40 Cin_to_XOR2___NAND4#29pmos@115_poly-right##41 9.877
R5688 Cin_to_XOR2___NAND4#29pmos@115_poly-right##41 Cin_to_XOR2___NAND4#29pmos@115_poly-right##42 9.877
R5689 Cin_to_XOR2___NAND4#29pmos@115_poly-right##42 Cin_to_XOR2___NAND4#29pmos@115_poly-right##43 9.877
R5690 Cin_to_XOR2___NAND4#29pmos@115_poly-right##43 Cin_to_XOR2___NAND4#29pmos@115_poly-right##44 9.877
R5691 Cin_to_XOR2___NAND4#29pmos@115_poly-right##44 Cin_to_XOR2___NAND4#29pmos@115_poly-right##45 9.877
R5692 Cin_to_XOR2___NAND4#29pmos@115_poly-right##45 Cin_to_XOR2___NAND4#29pmos@115_poly-right##46 9.877
R5693 Cin_to_XOR2___NAND4#29pmos@115_poly-right##46 Cin_to_XOR2___NAND4#29pmos@115_poly-right##47 9.877
R5694 Cin_to_XOR2___NAND4#29pmos@115_poly-right##47 Cin_to_XOR2___NAND4#29pmos@115_poly-right##48 9.877
R5695 Cin_to_XOR2___NAND4#29pmos@115_poly-right##48 Cin_to_XOR2___NAND4#29pmos@115_poly-right##49 9.877
R5696 Cin_to_XOR2___NAND4#29pmos@115_poly-right##49 Cin_to_XOR2___NAND4#23pin@675_polysilicon-1 9.877
R5697 NAND1_to_NAND6 NAND1_to_NAND6#4nmos@115_diff-bottom 4.823
R5698 A3#10pin@678_polysilicon-1 A3#10pin@678_polysilicon-1##0 9.938
R5699 A3#10pin@678_polysilicon-1##0 A3#10pin@678_polysilicon-1##1 9.938
R5700 A3#10pin@678_polysilicon-1##1 A3#10pin@678_polysilicon-1##2 9.938
R5701 A3#10pin@678_polysilicon-1##2 A3#10pin@678_polysilicon-1##3 9.938
R5702 A3#10pin@678_polysilicon-1##3 A3#10pin@678_polysilicon-1##4 9.938
R5703 A3#10pin@678_polysilicon-1##4 A3#10pin@678_polysilicon-1##5 9.938
R5704 A3#10pin@678_polysilicon-1##5 A3#10pin@678_polysilicon-1##6 9.938
R5705 A3#10pin@678_polysilicon-1##6 A3#10pin@678_polysilicon-1##7 9.938
R5706 A3#10pin@678_polysilicon-1##7 A3#10pin@678_polysilicon-1##8 9.938
R5707 A3#10pin@678_polysilicon-1##8 A3#10pin@678_polysilicon-1##9 9.938
R5708 A3#10pin@678_polysilicon-1##9 A3#10pin@678_polysilicon-1##10 9.938
R5709 A3#10pin@678_polysilicon-1##10 A3#10pin@678_polysilicon-1##11 9.938
R5710 A3#10pin@678_polysilicon-1##11 A3#10pin@678_polysilicon-1##12 9.938
R5711 A3#10pin@678_polysilicon-1##12 A3#10pin@678_polysilicon-1##13 9.938
R5712 A3#10pin@678_polysilicon-1##13 A3#10pin@678_polysilicon-1##14 9.938
R5713 A3#10pin@678_polysilicon-1##14 A3#10pin@678_polysilicon-1##15 9.938
R5714 A3#10pin@678_polysilicon-1##15 A3#10pin@678_polysilicon-1##16 9.938
R5715 A3#10pin@678_polysilicon-1##16 A3#10pin@678_polysilicon-1##17 9.938
R5716 A3#10pin@678_polysilicon-1##17 A3#10pin@678_polysilicon-1##18 9.938
R5717 A3#10pin@678_polysilicon-1##18 A3#10pin@678_polysilicon-1##19 9.938
R5718 A3#10pin@678_polysilicon-1##19 A3#10pin@678_polysilicon-1##20 9.938
R5719 A3#10pin@678_polysilicon-1##20 A3#10pin@678_polysilicon-1##21 9.938
R5720 A3#10pin@678_polysilicon-1##21 A3#10pin@678_polysilicon-1##22 9.938
R5721 A3#10pin@678_polysilicon-1##22 A3#10pin@678_polysilicon-1##23 9.938
R5722 A3#10pin@678_polysilicon-1##23 A3#10pin@678_polysilicon-1##24 9.938
R5723 A3#10pin@678_polysilicon-1##24 A3#10pin@678_polysilicon-1##25 9.938
R5724 A3#10pin@678_polysilicon-1##25 A3#10pin@678_polysilicon-1##26 9.938
R5725 A3#10pin@678_polysilicon-1##26 A3#10pin@678_polysilicon-1##27 9.938
R5726 A3#10pin@678_polysilicon-1##27 A3#10pin@678_polysilicon-1##28 9.938
R5727 A3#10pin@678_polysilicon-1##28 A3#10pin@678_polysilicon-1##29 9.938
R5728 A3#10pin@678_polysilicon-1##29 A3#10pin@678_polysilicon-1##30 9.938
R5729 A3#10pin@678_polysilicon-1##30 A3#10pin@678_polysilicon-1##31 9.938
R5730 A3#10pin@678_polysilicon-1##31 A3#10pin@678_polysilicon-1##32 9.938
R5731 A3#10pin@678_polysilicon-1##32 A3#10pin@678_polysilicon-1##33 9.938
R5732 A3#10pin@678_polysilicon-1##33 A3#10pin@678_polysilicon-1##34 9.938
R5733 A3#10pin@678_polysilicon-1##34 A3#10pin@678_polysilicon-1##35 9.938
R5734 A3#10pin@678_polysilicon-1##35 A3#10pin@678_polysilicon-1##36 9.938
R5735 A3#10pin@678_polysilicon-1##36 A3#10pin@678_polysilicon-1##37 9.938
R5736 A3#10pin@678_polysilicon-1##37 A3#10pin@678_polysilicon-1##38 9.938
R5737 A3#10pin@678_polysilicon-1##38 A3#10pin@678_polysilicon-1##39 9.938
R5738 A3#10pin@678_polysilicon-1##39 A3#10pin@678_polysilicon-1##40 9.938
R5739 A3#10pin@678_polysilicon-1##40 A3#10pin@678_polysilicon-1##41 9.938
R5740 A3#10pin@678_polysilicon-1##41 A3#10pin@678_polysilicon-1##42 9.938
R5741 A3#10pin@678_polysilicon-1##42 A3#10pin@678_polysilicon-1##43 9.938
R5742 A3#10pin@678_polysilicon-1##43 A3#10pin@678_polysilicon-1##44 9.938
R5743 A3#10pin@678_polysilicon-1##44 A3#10pin@678_polysilicon-1##45 9.938
R5744 A3#10pin@678_polysilicon-1##45 A3#10pin@678_polysilicon-1##46 9.938
R5745 A3#10pin@678_polysilicon-1##46 A3#10pin@678_polysilicon-1##47 9.938
R5746 A3#10pin@678_polysilicon-1##47 A3#10pin@678_polysilicon-1##48 9.938
R5747 A3#10pin@678_polysilicon-1##48 A3#10pin@678_polysilicon-1##49 9.938
R5748 A3#10pin@678_polysilicon-1##49 A3#19nmos@116_poly-right 9.938
R5749 B3#20pmos@117_poly-right B3#20pmos@117_poly-right##0 9.869
R5750 B3#20pmos@117_poly-right##0 B3#20pmos@117_poly-right##1 9.869
R5751 B3#20pmos@117_poly-right##1 B3#20pmos@117_poly-right##2 9.869
R5752 B3#20pmos@117_poly-right##2 B3#20pmos@117_poly-right##3 9.869
R5753 B3#20pmos@117_poly-right##3 B3#20pmos@117_poly-right##4 9.869
R5754 B3#20pmos@117_poly-right##4 B3#20pmos@117_poly-right##5 9.869
R5755 B3#20pmos@117_poly-right##5 B3#20pmos@117_poly-right##6 9.869
R5756 B3#20pmos@117_poly-right##6 B3#20pmos@117_poly-right##7 9.869
R5757 B3#20pmos@117_poly-right##7 B3#20pmos@117_poly-right##8 9.869
R5758 B3#20pmos@117_poly-right##8 B3#20pmos@117_poly-right##9 9.869
R5759 B3#20pmos@117_poly-right##9 B3#20pmos@117_poly-right##10 9.869
R5760 B3#20pmos@117_poly-right##10 B3#20pmos@117_poly-right##11 9.869
R5761 B3#20pmos@117_poly-right##11 B3#20pmos@117_poly-right##12 9.869
R5762 B3#20pmos@117_poly-right##12 B3#20pmos@117_poly-right##13 9.869
R5763 B3#20pmos@117_poly-right##13 B3#20pmos@117_poly-right##14 9.869
R5764 B3#20pmos@117_poly-right##14 B3#20pmos@117_poly-right##15 9.869
R5765 B3#20pmos@117_poly-right##15 B3#20pmos@117_poly-right##16 9.869
R5766 B3#20pmos@117_poly-right##16 B3#20pmos@117_poly-right##17 9.869
R5767 B3#20pmos@117_poly-right##17 B3#20pmos@117_poly-right##18 9.869
R5768 B3#20pmos@117_poly-right##18 B3#20pmos@117_poly-right##19 9.869
R5769 B3#20pmos@117_poly-right##19 B3#20pmos@117_poly-right##20 9.869
R5770 B3#20pmos@117_poly-right##20 B3#20pmos@117_poly-right##21 9.869
R5771 B3#20pmos@117_poly-right##21 B3#20pmos@117_poly-right##22 9.869
R5772 B3#20pmos@117_poly-right##22 B3#20pmos@117_poly-right##23 9.869
R5773 B3#20pmos@117_poly-right##23 B3#20pmos@117_poly-right##24 9.869
R5774 B3#20pmos@117_poly-right##24 B3#20pmos@117_poly-right##25 9.869
R5775 B3#20pmos@117_poly-right##25 B3#20pmos@117_poly-right##26 9.869
R5776 B3#20pmos@117_poly-right##26 B3#20pmos@117_poly-right##27 9.869
R5777 B3#20pmos@117_poly-right##27 B3#20pmos@117_poly-right##28 9.869
R5778 B3#20pmos@117_poly-right##28 B3#20pmos@117_poly-right##29 9.869
R5779 B3#20pmos@117_poly-right##29 B3#20pmos@117_poly-right##30 9.869
R5780 B3#20pmos@117_poly-right##30 B3#20pmos@117_poly-right##31 9.869
R5781 B3#20pmos@117_poly-right##31 B3#20pmos@117_poly-right##32 9.869
R5782 B3#20pmos@117_poly-right##32 B3#20pmos@117_poly-right##33 9.869
R5783 B3#20pmos@117_poly-right##33 B3#20pmos@117_poly-right##34 9.869
R5784 B3#20pmos@117_poly-right##34 B3#20pmos@117_poly-right##35 9.869
R5785 B3#20pmos@117_poly-right##35 B3#20pmos@117_poly-right##36 9.869
R5786 B3#20pmos@117_poly-right##36 B3#20pmos@117_poly-right##37 9.869
R5787 B3#20pmos@117_poly-right##37 B3#20pmos@117_poly-right##38 9.869
R5788 B3#20pmos@117_poly-right##38 B3#20pmos@117_poly-right##39 9.869
R5789 B3#20pmos@117_poly-right##39 B3#20pmos@117_poly-right##40 9.869
R5790 B3#20pmos@117_poly-right##40 B3#20pmos@117_poly-right##41 9.869
R5791 B3#20pmos@117_poly-right##41 B3#20pmos@117_poly-right##42 9.869
R5792 B3#20pmos@117_poly-right##42 B3#20pmos@117_poly-right##43 9.869
R5793 B3#20pmos@117_poly-right##43 B3#20pmos@117_poly-right##44 9.869
R5794 B3#20pmos@117_poly-right##44 B3#20pmos@117_poly-right##45 9.869
R5795 B3#20pmos@117_poly-right##45 B3#20pmos@117_poly-right##46 9.869
R5796 B3#20pmos@117_poly-right##46 B3#20pmos@117_poly-right##47 9.869
R5797 B3#20pmos@117_poly-right##47 B3#10pin@682_polysilicon-1 9.869
R5798 NAND2_to_Nand6#9pin@684_polysilicon-1 NAND2_to_Nand6#9pin@684_polysilicon-1##0 9.938
R5799 NAND2_to_Nand6#9pin@684_polysilicon-1##0 NAND2_to_Nand6#9pin@684_polysilicon-1##1 9.938
R5800 NAND2_to_Nand6#9pin@684_polysilicon-1##1 NAND2_to_Nand6#9pin@684_polysilicon-1##2 9.938
R5801 NAND2_to_Nand6#9pin@684_polysilicon-1##2 NAND2_to_Nand6#9pin@684_polysilicon-1##3 9.938
R5802 NAND2_to_Nand6#9pin@684_polysilicon-1##3 NAND2_to_Nand6#9pin@684_polysilicon-1##4 9.938
R5803 NAND2_to_Nand6#9pin@684_polysilicon-1##4 NAND2_to_Nand6#9pin@684_polysilicon-1##5 9.938
R5804 NAND2_to_Nand6#9pin@684_polysilicon-1##5 NAND2_to_Nand6#9pin@684_polysilicon-1##6 9.938
R5805 NAND2_to_Nand6#9pin@684_polysilicon-1##6 NAND2_to_Nand6#9pin@684_polysilicon-1##7 9.938
R5806 NAND2_to_Nand6#9pin@684_polysilicon-1##7 NAND2_to_Nand6#9pin@684_polysilicon-1##8 9.938
R5807 NAND2_to_Nand6#9pin@684_polysilicon-1##8 NAND2_to_Nand6#9pin@684_polysilicon-1##9 9.938
R5808 NAND2_to_Nand6#9pin@684_polysilicon-1##9 NAND2_to_Nand6#9pin@684_polysilicon-1##10 9.938
R5809 NAND2_to_Nand6#9pin@684_polysilicon-1##10 NAND2_to_Nand6#9pin@684_polysilicon-1##11 9.938
R5810 NAND2_to_Nand6#9pin@684_polysilicon-1##11 NAND2_to_Nand6#9pin@684_polysilicon-1##12 9.938
R5811 NAND2_to_Nand6#9pin@684_polysilicon-1##12 NAND2_to_Nand6#9pin@684_polysilicon-1##13 9.938
R5812 NAND2_to_Nand6#9pin@684_polysilicon-1##13 NAND2_to_Nand6#9pin@684_polysilicon-1##14 9.938
R5813 NAND2_to_Nand6#9pin@684_polysilicon-1##14 NAND2_to_Nand6#9pin@684_polysilicon-1##15 9.938
R5814 NAND2_to_Nand6#9pin@684_polysilicon-1##15 NAND2_to_Nand6#9pin@684_polysilicon-1##16 9.938
R5815 NAND2_to_Nand6#9pin@684_polysilicon-1##16 NAND2_to_Nand6#9pin@684_polysilicon-1##17 9.938
R5816 NAND2_to_Nand6#9pin@684_polysilicon-1##17 NAND2_to_Nand6#9pin@684_polysilicon-1##18 9.938
R5817 NAND2_to_Nand6#9pin@684_polysilicon-1##18 NAND2_to_Nand6#9pin@684_polysilicon-1##19 9.938
R5818 NAND2_to_Nand6#9pin@684_polysilicon-1##19 NAND2_to_Nand6#9pin@684_polysilicon-1##20 9.938
R5819 NAND2_to_Nand6#9pin@684_polysilicon-1##20 NAND2_to_Nand6#9pin@684_polysilicon-1##21 9.938
R5820 NAND2_to_Nand6#9pin@684_polysilicon-1##21 NAND2_to_Nand6#9pin@684_polysilicon-1##22 9.938
R5821 NAND2_to_Nand6#9pin@684_polysilicon-1##22 NAND2_to_Nand6#9pin@684_polysilicon-1##23 9.938
R5822 NAND2_to_Nand6#9pin@684_polysilicon-1##23 NAND2_to_Nand6#9pin@684_polysilicon-1##24 9.938
R5823 NAND2_to_Nand6#9pin@684_polysilicon-1##24 NAND2_to_Nand6#9pin@684_polysilicon-1##25 9.938
R5824 NAND2_to_Nand6#9pin@684_polysilicon-1##25 NAND2_to_Nand6#9pin@684_polysilicon-1##26 9.938
R5825 NAND2_to_Nand6#9pin@684_polysilicon-1##26 NAND2_to_Nand6#9pin@684_polysilicon-1##27 9.938
R5826 NAND2_to_Nand6#9pin@684_polysilicon-1##27 NAND2_to_Nand6#9pin@684_polysilicon-1##28 9.938
R5827 NAND2_to_Nand6#9pin@684_polysilicon-1##28 NAND2_to_Nand6#9pin@684_polysilicon-1##29 9.938
R5828 NAND2_to_Nand6#9pin@684_polysilicon-1##29 NAND2_to_Nand6#9pin@684_polysilicon-1##30 9.938
R5829 NAND2_to_Nand6#9pin@684_polysilicon-1##30 NAND2_to_Nand6#9pin@684_polysilicon-1##31 9.938
R5830 NAND2_to_Nand6#9pin@684_polysilicon-1##31 NAND2_to_Nand6#9pin@684_polysilicon-1##32 9.938
R5831 NAND2_to_Nand6#9pin@684_polysilicon-1##32 NAND2_to_Nand6#9pin@684_polysilicon-1##33 9.938
R5832 NAND2_to_Nand6#9pin@684_polysilicon-1##33 NAND2_to_Nand6#9pin@684_polysilicon-1##34 9.938
R5833 NAND2_to_Nand6#9pin@684_polysilicon-1##34 NAND2_to_Nand6#9pin@684_polysilicon-1##35 9.938
R5834 NAND2_to_Nand6#9pin@684_polysilicon-1##35 NAND2_to_Nand6#9pin@684_polysilicon-1##36 9.938
R5835 NAND2_to_Nand6#9pin@684_polysilicon-1##36 NAND2_to_Nand6#9pin@684_polysilicon-1##37 9.938
R5836 NAND2_to_Nand6#9pin@684_polysilicon-1##37 NAND2_to_Nand6#9pin@684_polysilicon-1##38 9.938
R5837 NAND2_to_Nand6#9pin@684_polysilicon-1##38 NAND2_to_Nand6#9pin@684_polysilicon-1##39 9.938
R5838 NAND2_to_Nand6#9pin@684_polysilicon-1##39 NAND2_to_Nand6#9pin@684_polysilicon-1##40 9.938
R5839 NAND2_to_Nand6#9pin@684_polysilicon-1##40 NAND2_to_Nand6#9pin@684_polysilicon-1##41 9.938
R5840 NAND2_to_Nand6#9pin@684_polysilicon-1##41 NAND2_to_Nand6#9pin@684_polysilicon-1##42 9.938
R5841 NAND2_to_Nand6#9pin@684_polysilicon-1##42 NAND2_to_Nand6#9pin@684_polysilicon-1##43 9.938
R5842 NAND2_to_Nand6#9pin@684_polysilicon-1##43 NAND2_to_Nand6#9pin@684_polysilicon-1##44 9.938
R5843 NAND2_to_Nand6#9pin@684_polysilicon-1##44 NAND2_to_Nand6#9pin@684_polysilicon-1##45 9.938
R5844 NAND2_to_Nand6#9pin@684_polysilicon-1##45 NAND2_to_Nand6#9pin@684_polysilicon-1##46 9.938
R5845 NAND2_to_Nand6#9pin@684_polysilicon-1##46 NAND2_to_Nand6#9pin@684_polysilicon-1##47 9.938
R5846 NAND2_to_Nand6#9pin@684_polysilicon-1##47 NAND2_to_Nand6#9pin@684_polysilicon-1##48 9.938
R5847 NAND2_to_Nand6#9pin@684_polysilicon-1##48 NAND2_to_Nand6#9pin@684_polysilicon-1##49 9.938
R5848 NAND2_to_Nand6#9pin@684_polysilicon-1##49 NAND2_to_Nand6#11nmos@118_poly-right 9.938
R5849 NAND1_to_NAND6#14nmos@119_poly-right NAND1_to_NAND6#14nmos@119_poly-right##0 9.898
R5850 NAND1_to_NAND6#14nmos@119_poly-right##0 NAND1_to_NAND6#14nmos@119_poly-right##1 9.898
R5851 NAND1_to_NAND6#14nmos@119_poly-right##1 NAND1_to_NAND6#14nmos@119_poly-right##2 9.898
R5852 NAND1_to_NAND6#14nmos@119_poly-right##2 NAND1_to_NAND6#14nmos@119_poly-right##3 9.898
R5853 NAND1_to_NAND6#14nmos@119_poly-right##3 NAND1_to_NAND6#14nmos@119_poly-right##4 9.898
R5854 NAND1_to_NAND6#14nmos@119_poly-right##4 NAND1_to_NAND6#14nmos@119_poly-right##5 9.898
R5855 NAND1_to_NAND6#14nmos@119_poly-right##5 NAND1_to_NAND6#14nmos@119_poly-right##6 9.898
R5856 NAND1_to_NAND6#14nmos@119_poly-right##6 NAND1_to_NAND6#14nmos@119_poly-right##7 9.898
R5857 NAND1_to_NAND6#14nmos@119_poly-right##7 NAND1_to_NAND6#14nmos@119_poly-right##8 9.898
R5858 NAND1_to_NAND6#14nmos@119_poly-right##8 NAND1_to_NAND6#14nmos@119_poly-right##9 9.898
R5859 NAND1_to_NAND6#14nmos@119_poly-right##9 NAND1_to_NAND6#14nmos@119_poly-right##10 9.898
R5860 NAND1_to_NAND6#14nmos@119_poly-right##10 NAND1_to_NAND6#14nmos@119_poly-right##11 9.898
R5861 NAND1_to_NAND6#14nmos@119_poly-right##11 NAND1_to_NAND6#14nmos@119_poly-right##12 9.898
R5862 NAND1_to_NAND6#14nmos@119_poly-right##12 NAND1_to_NAND6#14nmos@119_poly-right##13 9.898
R5863 NAND1_to_NAND6#14nmos@119_poly-right##13 NAND1_to_NAND6#14nmos@119_poly-right##14 9.898
R5864 NAND1_to_NAND6#14nmos@119_poly-right##14 NAND1_to_NAND6#14nmos@119_poly-right##15 9.898
R5865 NAND1_to_NAND6#14nmos@119_poly-right##15 NAND1_to_NAND6#14nmos@119_poly-right##16 9.898
R5866 NAND1_to_NAND6#14nmos@119_poly-right##16 NAND1_to_NAND6#14nmos@119_poly-right##17 9.898
R5867 NAND1_to_NAND6#14nmos@119_poly-right##17 NAND1_to_NAND6#14nmos@119_poly-right##18 9.898
R5868 NAND1_to_NAND6#14nmos@119_poly-right##18 NAND1_to_NAND6#14nmos@119_poly-right##19 9.898
R5869 NAND1_to_NAND6#14nmos@119_poly-right##19 NAND1_to_NAND6#14nmos@119_poly-right##20 9.898
R5870 NAND1_to_NAND6#14nmos@119_poly-right##20 NAND1_to_NAND6#14nmos@119_poly-right##21 9.898
R5871 NAND1_to_NAND6#14nmos@119_poly-right##21 NAND1_to_NAND6#14nmos@119_poly-right##22 9.898
R5872 NAND1_to_NAND6#14nmos@119_poly-right##22 NAND1_to_NAND6#14nmos@119_poly-right##23 9.898
R5873 NAND1_to_NAND6#14nmos@119_poly-right##23 NAND1_to_NAND6#14nmos@119_poly-right##24 9.898
R5874 NAND1_to_NAND6#14nmos@119_poly-right##24 NAND1_to_NAND6#14nmos@119_poly-right##25 9.898
R5875 NAND1_to_NAND6#14nmos@119_poly-right##25 NAND1_to_NAND6#14nmos@119_poly-right##26 9.898
R5876 NAND1_to_NAND6#14nmos@119_poly-right##26 NAND1_to_NAND6#14nmos@119_poly-right##27 9.898
R5877 NAND1_to_NAND6#14nmos@119_poly-right##27 NAND1_to_NAND6#14nmos@119_poly-right##28 9.898
R5878 NAND1_to_NAND6#14nmos@119_poly-right##28 NAND1_to_NAND6#14nmos@119_poly-right##29 9.898
R5879 NAND1_to_NAND6#14nmos@119_poly-right##29 NAND1_to_NAND6#14nmos@119_poly-right##30 9.898
R5880 NAND1_to_NAND6#14nmos@119_poly-right##30 NAND1_to_NAND6#14nmos@119_poly-right##31 9.898
R5881 NAND1_to_NAND6#14nmos@119_poly-right##31 NAND1_to_NAND6#14nmos@119_poly-right##32 9.898
R5882 NAND1_to_NAND6#14nmos@119_poly-right##32 NAND1_to_NAND6#14nmos@119_poly-right##33 9.898
R5883 NAND1_to_NAND6#14nmos@119_poly-right##33 NAND1_to_NAND6#14nmos@119_poly-right##34 9.898
R5884 NAND1_to_NAND6#14nmos@119_poly-right##34 NAND1_to_NAND6#14nmos@119_poly-right##35 9.898
R5885 NAND1_to_NAND6#14nmos@119_poly-right##35 NAND1_to_NAND6#14nmos@119_poly-right##36 9.898
R5886 NAND1_to_NAND6#14nmos@119_poly-right##36 NAND1_to_NAND6#14nmos@119_poly-right##37 9.898
R5887 NAND1_to_NAND6#14nmos@119_poly-right##37 NAND1_to_NAND6#14nmos@119_poly-right##38 9.898
R5888 NAND1_to_NAND6#14nmos@119_poly-right##38 NAND1_to_NAND6#14nmos@119_poly-right##39 9.898
R5889 NAND1_to_NAND6#14nmos@119_poly-right##39 NAND1_to_NAND6#14nmos@119_poly-right##40 9.898
R5890 NAND1_to_NAND6#14nmos@119_poly-right##40 NAND1_to_NAND6#14nmos@119_poly-right##41 9.898
R5891 NAND1_to_NAND6#14nmos@119_poly-right##41 NAND1_to_NAND6#14nmos@119_poly-right##42 9.898
R5892 NAND1_to_NAND6#14nmos@119_poly-right##42 NAND1_to_NAND6#14nmos@119_poly-right##43 9.898
R5893 NAND1_to_NAND6#14nmos@119_poly-right##43 NAND1_to_NAND6#14nmos@119_poly-right##44 9.898
R5894 NAND1_to_NAND6#14nmos@119_poly-right##44 NAND1_to_NAND6#14nmos@119_poly-right##45 9.898
R5895 NAND1_to_NAND6#14nmos@119_poly-right##45 NAND1_to_NAND6#14nmos@119_poly-right##46 9.898
R5896 NAND1_to_NAND6#14nmos@119_poly-right##46 NAND1_to_NAND6#14nmos@119_poly-right##47 9.898
R5897 NAND1_to_NAND6#14nmos@119_poly-right##47 NAND1_to_NAND6#14nmos@119_poly-right##48 9.898
R5898 NAND1_to_NAND6#14nmos@119_poly-right##48 NAND1_to_NAND6#14nmos@119_poly-right##49 9.898
R5899 NAND1_to_NAND6#14nmos@119_poly-right##49 NAND1_to_NAND6#14nmos@119_poly-right##50 9.898
R5900 NAND1_to_NAND6#14nmos@119_poly-right##50 NAND1_to_NAND6#14nmos@119_poly-right##51 9.898
R5901 NAND1_to_NAND6#14nmos@119_poly-right##51 NAND1_to_NAND6#14nmos@119_poly-right##52 9.898
R5902 NAND1_to_NAND6#14nmos@119_poly-right##52 NAND1_to_NAND6#14nmos@119_poly-right##53 9.898
R5903 NAND1_to_NAND6#14nmos@119_poly-right##53 NAND1_to_NAND6#14nmos@119_poly-right##54 9.898
R5904 NAND1_to_NAND6#14nmos@119_poly-right##54 NAND1_to_NAND6#14nmos@119_poly-right##55 9.898
R5905 NAND1_to_NAND6#14nmos@119_poly-right##55 NAND1_to_NAND6#11pmos@119_poly-right 9.898
R5906 NAND2_to_Nand6 NAND2_to_Nand6#4nmos@117_diff-bottom 4.42
R5907 net@2392 net@2392##0 9.92
R5908 net@2392##0 net@2392##1 9.92
R5909 net@2392##1 net@2392##2 9.92
R5910 net@2392##2 net@2392##3 9.92
R5911 net@2392##3 net@2392##4 9.92
R5912 net@2392##4 net@2392##5 9.92
R5913 net@2392##5 net@2392##6 9.92
R5914 net@2392##6 net@2392##7 9.92
R5915 net@2392##7 net@2392##8 9.92
R5916 net@2392##8 net@2392##9 9.92
R5917 net@2392##9 net@2392##10 9.92
R5918 net@2392##10 net@2392##11 9.92
R5919 net@2392##11 net@2392##12 9.92
R5920 net@2392##12 net@2392##13 9.92
R5921 net@2392##13 net@2392##14 9.92
R5922 net@2392##14 net@2392##15 9.92
R5923 net@2392##15 net@2392##16 9.92
R5924 net@2392##16 net@2392##17 9.92
R5925 net@2392##17 net@2392##18 9.92
R5926 net@2392##18 net@2392#1pin@727_polysilicon-1 9.92
R5927 net@2394 net@2394##0 9.92
R5928 net@2394##0 net@2394##1 9.92
R5929 net@2394##1 net@2394##2 9.92
R5930 net@2394##2 net@2394##3 9.92
R5931 net@2394##3 net@2394##4 9.92
R5932 net@2394##4 net@2394##5 9.92
R5933 net@2394##5 net@2394##6 9.92
R5934 net@2394##6 net@2394##7 9.92
R5935 net@2394##7 net@2394##8 9.92
R5936 net@2394##8 net@2394##9 9.92
R5937 net@2394##9 net@2394##10 9.92
R5938 net@2394##10 net@2394##11 9.92
R5939 net@2394##11 net@2394##12 9.92
R5940 net@2394##12 net@2394##13 9.92
R5941 net@2394##13 net@2394##14 9.92
R5942 net@2394##14 net@2394##15 9.92
R5943 net@2394##15 net@2394##16 9.92
R5944 net@2394##16 net@2394##17 9.92
R5945 net@2394##17 net@2394##18 9.92
R5946 net@2394##18 net@2394#1pin@752_polysilicon-1 9.92
R5947 XOR1_to_NAND5#3pin@753_polysilicon-1 XOR1_to_NAND5#3pin@753_polysilicon-1##0 6.2
R5948 XOR1_to_NAND5#3pin@753_polysilicon-1##0 XOR1_to_NAND5#4pmos@132_poly-right 6.2
R5949 XOR1_to_NAND5#3pin@753_polysilicon-1 XOR1_to_NAND5#3pin@753_polysilicon-1##0 8.138
R5950 XOR1_to_NAND5#3pin@753_polysilicon-1##0 XOR1_to_NAND5#3pin@753_polysilicon-1##1 8.138
R5951 XOR1_to_NAND5#3pin@753_polysilicon-1##1 XOR1_to_NAND5#3pin@753_polysilicon-1##2 8.138
R5952 XOR1_to_NAND5#3pin@753_polysilicon-1##2 XOR1_to_NAND5#1contact@875_metal-1-metal-2 8.138
R5953 Cin_to_XOR2___NAND5#14nmos@131_poly-right Cin_to_XOR2___NAND5#14nmos@131_poly-right##0 5.425
R5954 Cin_to_XOR2___NAND5#14nmos@131_poly-right##0 Cin_to_XOR2___NAND5#15pin@743_polysilicon-1 5.425
R5955 Cin_to_XOR2___NAND5 Cin_to_XOR2___NAND5##0 8.99
R5956 Cin_to_XOR2___NAND5##0 Cin_to_XOR2___NAND5##1 8.99
R5957 Cin_to_XOR2___NAND5##1 Cin_to_XOR2___NAND5##2 8.99
R5958 Cin_to_XOR2___NAND5##2 Cin_to_XOR2___NAND5##3 8.99
R5959 Cin_to_XOR2___NAND5##3 Cin_to_XOR2___NAND5#15pin@743_polysilicon-1 8.99
R5960 A4#3pin@728_polysilicon-1 A4#3pin@728_polysilicon-1##0 6.2
R5961 A4#3pin@728_polysilicon-1##0 A4#4pmos@125_poly-right 6.2
R5962 XOR1_to_NAND5#9pmos@127_poly-left XOR1_to_NAND5#9pmos@127_poly-left##0 8.138
R5963 XOR1_to_NAND5#9pmos@127_poly-left##0 XOR1_to_NAND5#9pmos@127_poly-left##1 8.138
R5964 XOR1_to_NAND5#9pmos@127_poly-left##1 XOR1_to_NAND5#9pmos@127_poly-left##2 8.138
R5965 XOR1_to_NAND5#9pmos@127_poly-left##2 XOR1_to_NAND5#10pin@740_polysilicon-1 8.138
R5966 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##0 9.843
R5967 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##0 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##1 9.843
R5968 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##1 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##2 9.843
R5969 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##2 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##3 9.843
R5970 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##3 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##4 9.843
R5971 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##4 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##5 9.843
R5972 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##5 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##6 9.843
R5973 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##6 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##7 9.843
R5974 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##7 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##8 9.843
R5975 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##8 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##9 9.843
R5976 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##9 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##10 9.843
R5977 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##10 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##11 9.843
R5978 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##11 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##12 9.843
R5979 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##12 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##13 9.843
R5980 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##13 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##14 9.843
R5981 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##14 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##15 9.843
R5982 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##15 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##16 9.843
R5983 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##16 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##17 9.843
R5984 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##17 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##18 9.843
R5985 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1##18 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1 9.843
R5986 net@2403#4nmos@133_poly-right net@2403#4nmos@133_poly-right##0 9.3
R5987 net@2403#4nmos@133_poly-right##0 net@2403#4nmos@133_poly-right##1 9.3
R5988 net@2403#4nmos@133_poly-right##1 net@2403#5pin@745_polysilicon-1 9.3
R5989 net@2403#2contact@861_metal-1-polysilicon-1 net@2403#2contact@861_metal-1-polysilicon-1##0 8.99
R5990 net@2403#2contact@861_metal-1-polysilicon-1##0 net@2403#2contact@861_metal-1-polysilicon-1##1 8.99
R5991 net@2403#2contact@861_metal-1-polysilicon-1##1 net@2403#2contact@861_metal-1-polysilicon-1##2 8.99
R5992 net@2403#2contact@861_metal-1-polysilicon-1##2 net@2403#2contact@861_metal-1-polysilicon-1##3 8.99
R5993 net@2403#2contact@861_metal-1-polysilicon-1##3 net@2403#5pin@745_polysilicon-1 8.99
R5994 A4#3pin@728_polysilicon-1 A4#3pin@728_polysilicon-1##0 8.138
R5995 A4#3pin@728_polysilicon-1##0 A4#3pin@728_polysilicon-1##1 8.138
R5996 A4#3pin@728_polysilicon-1##1 A4#3pin@728_polysilicon-1##2 8.138
R5997 A4#3pin@728_polysilicon-1##2 A4#1pin@767_metal-2 8.138
R5998 XOR1_to_NAND5#1contact@875_metal-1-metal-2 XOR1_to_NAND5#1contact@875_metal-1-metal-2##0 6.717
R5999 XOR1_to_NAND5#1contact@875_metal-1-metal-2##0 XOR1_to_NAND5#1contact@875_metal-1-metal-2##1 6.717
R6000 XOR1_to_NAND5#1contact@875_metal-1-metal-2##1 XOR1_to_NAND5#12pin@741_polysilicon-1 6.717
R6001 XOR1_to_NAND5#10pin@740_polysilicon-1 XOR1_to_NAND5#10pin@740_polysilicon-1##0 7.75
R6002 XOR1_to_NAND5#10pin@740_polysilicon-1##0 XOR1_to_NAND5#10pin@740_polysilicon-1##1 7.75
R6003 XOR1_to_NAND5#10pin@740_polysilicon-1##1 XOR1_to_NAND5#12pin@741_polysilicon-1 7.75
R6004 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1##0 9.743
R6005 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1##0 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1##1 9.743
R6006 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1##1 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1##2 9.743
R6007 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1##2 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1##3 9.743
R6008 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1##3 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1##4 9.743
R6009 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1##4 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1##5 9.743
R6010 Cin_to_XOR2___NAND5#17pin@750_polysilicon-1##5 Cin_to_XOR2___NAND5 9.743
R6011 net@2394#7pmos@128_poly-left net@2394#7pmos@128_poly-left##0 7.75
R6012 net@2394#7pmos@128_poly-left##0 net@2394 7.75
R6013 Cin_to_XOR2___NAND5#18nmos@129_poly-left Cin_to_XOR2___NAND5#18nmos@129_poly-left##0 6.2
R6014 Cin_to_XOR2___NAND5#18nmos@129_poly-left##0 Cin_to_XOR2___NAND5#16pin@733_polysilicon-1 6.2
R6015 net@2404#9nmos@130_poly-left net@2404#9nmos@130_poly-left##0 8.37
R6016 net@2404#9nmos@130_poly-left##0 net@2404#9nmos@130_poly-left##1 8.37
R6017 net@2404#9nmos@130_poly-left##1 net@2404#9nmos@130_poly-left##2 8.37
R6018 net@2404#9nmos@130_poly-left##2 net@2404#9nmos@130_poly-left##3 8.37
R6019 net@2404#9nmos@130_poly-left##3 net@2404#2contact@836_metal-1-metal-2 8.37
R6020 XOR1_to_NAND5 XOR1_to_NAND5##0 6.717
R6021 XOR1_to_NAND5##0 XOR1_to_NAND5##1 6.717
R6022 XOR1_to_NAND5##1 XOR1_to_NAND5#14pin@757_polysilicon-1 6.717
R6023 XOR1_to_NAND5#16pmos@134_poly-right XOR1_to_NAND5#16pmos@134_poly-right##0 6.2
R6024 XOR1_to_NAND5#16pmos@134_poly-right##0 XOR1_to_NAND5#14pin@757_polysilicon-1 6.2
R6025 Cin_to_XOR2___NAND5#23pin@761_polysilicon-1 Cin_to_XOR2___NAND5#23pin@761_polysilicon-1##0 9.688
R6026 Cin_to_XOR2___NAND5#23pin@761_polysilicon-1##0 Cin_to_XOR2___NAND5#23pin@761_polysilicon-1##1 9.688
R6027 Cin_to_XOR2___NAND5#23pin@761_polysilicon-1##1 Cin_to_XOR2___NAND5#23pin@761_polysilicon-1##2 9.688
R6028 Cin_to_XOR2___NAND5#23pin@761_polysilicon-1##2 Cin_to_XOR2___NAND5#20contact@874_metal-1-metal-2 9.688
R6029 Cin_to_XOR2___NAND5#20contact@874_metal-1-metal-2 Cin_to_XOR2___NAND5 4.953
R6030 A4#0contact@883_metal-1-metal-2 A4#0contact@883_metal-1-metal-2##0 6.717
R6031 A4#0contact@883_metal-1-metal-2##0 A4#0contact@883_metal-1-metal-2##1 6.717
R6032 A4#0contact@883_metal-1-metal-2##1 A4#10pin@764_polysilicon-1 6.717
R6033 A4#11pmos@136_poly-right A4#11pmos@136_poly-right##0 9.558
R6034 A4#11pmos@136_poly-right##0 A4#11pmos@136_poly-right##1 9.558
R6035 A4#11pmos@136_poly-right##1 A4#11pmos@136_poly-right##2 9.558
R6036 A4#11pmos@136_poly-right##2 A4#11pmos@136_poly-right##3 9.558
R6037 A4#11pmos@136_poly-right##3 A4#11pmos@136_poly-right##4 9.558
R6038 A4#11pmos@136_poly-right##4 A4#10pin@764_polysilicon-1 9.558
R6039 B4#10pin@768_polysilicon-1 B4#10pin@768_polysilicon-1##0 8.138
R6040 B4#10pin@768_polysilicon-1##0 B4#10pin@768_polysilicon-1##1 8.138
R6041 B4#10pin@768_polysilicon-1##1 B4#10pin@768_polysilicon-1##2 8.138
R6042 B4#10pin@768_polysilicon-1##2 B4#0contact@884_metal-1-metal-2 8.138
R6043 B4#11nmos@124_poly-right B4#11nmos@124_poly-right##0 5.425
R6044 B4#11nmos@124_poly-right##0 B4#12pin@718_polysilicon-1 5.425
R6045 NAND2_to_Nand7 NAND2_to_Nand7##0 6.717
R6046 NAND2_to_Nand7##0 NAND2_to_Nand7##1 6.717
R6047 NAND2_to_Nand7##1 NAND2_to_Nand7#9pin@770_polysilicon-1 6.717
R6048 NAND2_to_Nand7#10pmos@138_poly-right NAND2_to_Nand7#10pmos@138_poly-right##0 9.558
R6049 NAND2_to_Nand7#10pmos@138_poly-right##0 NAND2_to_Nand7#10pmos@138_poly-right##1 9.558
R6050 NAND2_to_Nand7#10pmos@138_poly-right##1 NAND2_to_Nand7#10pmos@138_poly-right##2 9.558
R6051 NAND2_to_Nand7#10pmos@138_poly-right##2 NAND2_to_Nand7#10pmos@138_poly-right##3 9.558
R6052 NAND2_to_Nand7#10pmos@138_poly-right##3 NAND2_to_Nand7#10pmos@138_poly-right##4 9.558
R6053 NAND2_to_Nand7#10pmos@138_poly-right##4 NAND2_to_Nand7#9pin@770_polysilicon-1 9.558
R6054 B4#1pin@769_metal-2 B4#1pin@769_metal-2##0 8.99
R6055 B4#1pin@769_metal-2##0 B4#1pin@769_metal-2##1 8.99
R6056 B4#1pin@769_metal-2##1 B4#1pin@769_metal-2##2 8.99
R6057 B4#1pin@769_metal-2##2 B4#1pin@769_metal-2##3 8.99
R6058 B4#1pin@769_metal-2##3 B4#12pin@718_polysilicon-1 8.99
R6059 NAND1_to_NAND7#11pmos@139_poly-right NAND1_to_NAND7#11pmos@139_poly-right##0 5.425
R6060 NAND1_to_NAND7#11pmos@139_poly-right##0 NAND1_to_NAND7#12pin@774_polysilicon-1 5.425
R6061 NAND1_to_NAND7#12pin@774_polysilicon-1 NAND1_to_NAND7#12pin@774_polysilicon-1##0 9.3
R6062 NAND1_to_NAND7#12pin@774_polysilicon-1##0 NAND1_to_NAND7#12pin@774_polysilicon-1##1 9.3
R6063 NAND1_to_NAND7#12pin@774_polysilicon-1##1 NAND1_to_NAND7 9.3
R6064 Cin_to_XOR2___NAND5#25nmos@135_poly-right Cin_to_XOR2___NAND5#25nmos@135_poly-right##0 8.636
R6065 Cin_to_XOR2___NAND5#25nmos@135_poly-right##0 Cin_to_XOR2___NAND5#25nmos@135_poly-right##1 8.636
R6066 Cin_to_XOR2___NAND5#25nmos@135_poly-right##1 Cin_to_XOR2___NAND5#25nmos@135_poly-right##2 8.636
R6067 Cin_to_XOR2___NAND5#25nmos@135_poly-right##2 Cin_to_XOR2___NAND5#25nmos@135_poly-right##3 8.636
R6068 Cin_to_XOR2___NAND5#25nmos@135_poly-right##3 Cin_to_XOR2___NAND5#25nmos@135_poly-right##4 8.636
R6069 Cin_to_XOR2___NAND5#25nmos@135_poly-right##4 Cin_to_XOR2___NAND5#25nmos@135_poly-right##5 8.636
R6070 Cin_to_XOR2___NAND5#25nmos@135_poly-right##5 Cin_to_XOR2___NAND5#23pin@761_polysilicon-1 8.636
R6071 B4#13nmos@137_poly-right B4#13nmos@137_poly-right##0 8.956
R6072 B4#13nmos@137_poly-right##0 B4#13nmos@137_poly-right##1 8.956
R6073 B4#13nmos@137_poly-right##1 B4#13nmos@137_poly-right##2 8.956
R6074 B4#13nmos@137_poly-right##2 B4#13nmos@137_poly-right##3 8.956
R6075 B4#13nmos@137_poly-right##3 B4#13nmos@137_poly-right##4 8.956
R6076 B4#13nmos@137_poly-right##4 B4#13nmos@137_poly-right##5 8.956
R6077 B4#13nmos@137_poly-right##5 B4#13nmos@137_poly-right##6 8.956
R6078 B4#13nmos@137_poly-right##6 B4#13nmos@137_poly-right##7 8.956
R6079 B4#13nmos@137_poly-right##7 B4#10pin@768_polysilicon-1 8.956
R6080 A4#12pmos@120_poly-left A4#12pmos@120_poly-left##0 8.138
R6081 A4#12pmos@120_poly-left##0 A4#12pmos@120_poly-left##1 8.138
R6082 A4#12pmos@120_poly-left##1 A4#12pmos@120_poly-left##2 8.138
R6083 A4#12pmos@120_poly-left##2 A4#13pin@715_polysilicon-1 8.138
R6084 B4#14pin@708_polysilicon-1 B4#14pin@708_polysilicon-1##0 9.843
R6085 B4#14pin@708_polysilicon-1##0 B4#14pin@708_polysilicon-1##1 9.843
R6086 B4#14pin@708_polysilicon-1##1 B4#14pin@708_polysilicon-1##2 9.843
R6087 B4#14pin@708_polysilicon-1##2 B4#14pin@708_polysilicon-1##3 9.843
R6088 B4#14pin@708_polysilicon-1##3 B4#14pin@708_polysilicon-1##4 9.843
R6089 B4#14pin@708_polysilicon-1##4 B4#14pin@708_polysilicon-1##5 9.843
R6090 B4#14pin@708_polysilicon-1##5 B4#14pin@708_polysilicon-1##6 9.843
R6091 B4#14pin@708_polysilicon-1##6 B4#14pin@708_polysilicon-1##7 9.843
R6092 B4#14pin@708_polysilicon-1##7 B4#14pin@708_polysilicon-1##8 9.843
R6093 B4#14pin@708_polysilicon-1##8 B4#14pin@708_polysilicon-1##9 9.843
R6094 B4#14pin@708_polysilicon-1##9 B4#14pin@708_polysilicon-1##10 9.843
R6095 B4#14pin@708_polysilicon-1##10 B4#14pin@708_polysilicon-1##11 9.843
R6096 B4#14pin@708_polysilicon-1##11 B4#14pin@708_polysilicon-1##12 9.843
R6097 B4#14pin@708_polysilicon-1##12 B4#14pin@708_polysilicon-1##13 9.843
R6098 B4#14pin@708_polysilicon-1##13 B4#14pin@708_polysilicon-1##14 9.843
R6099 B4#14pin@708_polysilicon-1##14 B4#14pin@708_polysilicon-1##15 9.843
R6100 B4#14pin@708_polysilicon-1##15 B4#14pin@708_polysilicon-1##16 9.843
R6101 B4#14pin@708_polysilicon-1##16 B4#14pin@708_polysilicon-1##17 9.843
R6102 B4#14pin@708_polysilicon-1##17 B4#14pin@708_polysilicon-1##18 9.843
R6103 B4#14pin@708_polysilicon-1##18 B4#15pin@725_polysilicon-1 9.843
R6104 net@2490#4nmos@126_poly-right net@2490#4nmos@126_poly-right##0 7.233
R6105 net@2490#4nmos@126_poly-right##0 net@2490#4nmos@126_poly-right##1 7.233
R6106 net@2490#4nmos@126_poly-right##1 net@2490#5pin@720_polysilicon-1 7.233
R6107 net@2490#2contact@822_metal-1-polysilicon-1 net@2490#2contact@822_metal-1-polysilicon-1##0 8.99
R6108 net@2490#2contact@822_metal-1-polysilicon-1##0 net@2490#2contact@822_metal-1-polysilicon-1##1 8.99
R6109 net@2490#2contact@822_metal-1-polysilicon-1##1 net@2490#2contact@822_metal-1-polysilicon-1##2 8.99
R6110 net@2490#2contact@822_metal-1-polysilicon-1##2 net@2490#2contact@822_metal-1-polysilicon-1##3 8.99
R6111 net@2490#2contact@822_metal-1-polysilicon-1##3 net@2490#5pin@720_polysilicon-1 8.99
R6112 A4#1pin@767_metal-2 A4#1pin@767_metal-2##0 6.717
R6113 A4#1pin@767_metal-2##0 A4#1pin@767_metal-2##1 6.717
R6114 A4#1pin@767_metal-2##1 A4#15pin@716_polysilicon-1 6.717
R6115 A4#13pin@715_polysilicon-1 A4#13pin@715_polysilicon-1##0 7.75
R6116 A4#13pin@715_polysilicon-1##0 A4#13pin@715_polysilicon-1##1 7.75
R6117 A4#13pin@715_polysilicon-1##1 A4#15pin@716_polysilicon-1 7.75
R6118 B4#15pin@725_polysilicon-1 B4#15pin@725_polysilicon-1##0 9.743
R6119 B4#15pin@725_polysilicon-1##0 B4#15pin@725_polysilicon-1##1 9.743
R6120 B4#15pin@725_polysilicon-1##1 B4#15pin@725_polysilicon-1##2 9.743
R6121 B4#15pin@725_polysilicon-1##2 B4#15pin@725_polysilicon-1##3 9.743
R6122 B4#15pin@725_polysilicon-1##3 B4#15pin@725_polysilicon-1##4 9.743
R6123 B4#15pin@725_polysilicon-1##4 B4#15pin@725_polysilicon-1##5 9.743
R6124 B4#15pin@725_polysilicon-1##5 B4#1pin@769_metal-2 9.743
R6125 net@2392#7pmos@121_poly-left net@2392#7pmos@121_poly-left##0 7.75
R6126 net@2392#7pmos@121_poly-left##0 net@2392 7.75
R6127 B4#16nmos@122_poly-left B4#16nmos@122_poly-left##0 6.2
R6128 B4#16nmos@122_poly-left##0 B4#14pin@708_polysilicon-1 6.2
R6129 net@2497#9nmos@123_poly-left net@2497#9nmos@123_poly-left##0 8.37
R6130 net@2497#9nmos@123_poly-left##0 net@2497#9nmos@123_poly-left##1 8.37
R6131 net@2497#9nmos@123_poly-left##1 net@2497#9nmos@123_poly-left##2 8.37
R6132 net@2497#9nmos@123_poly-left##2 net@2497#9nmos@123_poly-left##3 8.37
R6133 net@2497#9nmos@123_poly-left##3 net@2497#2contact@798_metal-1-metal-2 8.37
R6134 A4#3pin@728_polysilicon-1 A4#3pin@728_polysilicon-1##0 9.881
R6135 A4#3pin@728_polysilicon-1##0 A4#3pin@728_polysilicon-1##1 9.881
R6136 A4#3pin@728_polysilicon-1##1 A4#3pin@728_polysilicon-1##2 9.881
R6137 A4#3pin@728_polysilicon-1##2 A4#3pin@728_polysilicon-1##3 9.881
R6138 A4#3pin@728_polysilicon-1##3 A4#3pin@728_polysilicon-1##4 9.881
R6139 A4#3pin@728_polysilicon-1##4 A4#3pin@728_polysilicon-1##5 9.881
R6140 A4#3pin@728_polysilicon-1##5 A4#3pin@728_polysilicon-1##6 9.881
R6141 A4#3pin@728_polysilicon-1##6 A4#3pin@728_polysilicon-1##7 9.881
R6142 A4#3pin@728_polysilicon-1##7 A4#3pin@728_polysilicon-1##8 9.881
R6143 A4#3pin@728_polysilicon-1##8 A4#3pin@728_polysilicon-1##9 9.881
R6144 A4#3pin@728_polysilicon-1##9 A4#3pin@728_polysilicon-1##10 9.881
R6145 A4#3pin@728_polysilicon-1##10 A4#3pin@728_polysilicon-1##11 9.881
R6146 A4#3pin@728_polysilicon-1##11 A4#3pin@728_polysilicon-1##12 9.881
R6147 A4#3pin@728_polysilicon-1##12 A4#3pin@728_polysilicon-1##13 9.881
R6148 A4#3pin@728_polysilicon-1##13 A4#3pin@728_polysilicon-1##14 9.881
R6149 A4#3pin@728_polysilicon-1##14 A4#3pin@728_polysilicon-1##15 9.881
R6150 A4#3pin@728_polysilicon-1##15 A4#3pin@728_polysilicon-1##16 9.881
R6151 A4#3pin@728_polysilicon-1##16 A4#3pin@728_polysilicon-1##17 9.881
R6152 A4#3pin@728_polysilicon-1##17 A4#3pin@728_polysilicon-1##18 9.881
R6153 A4#3pin@728_polysilicon-1##18 A4#3pin@728_polysilicon-1##19 9.881
R6154 A4#3pin@728_polysilicon-1##19 A4#3pin@728_polysilicon-1##20 9.881
R6155 A4#3pin@728_polysilicon-1##20 A4#3pin@728_polysilicon-1##21 9.881
R6156 A4#3pin@728_polysilicon-1##21 A4#3pin@728_polysilicon-1##22 9.881
R6157 A4#3pin@728_polysilicon-1##22 A4#3pin@728_polysilicon-1##23 9.881
R6158 A4#3pin@728_polysilicon-1##23 A4#3pin@728_polysilicon-1##24 9.881
R6159 A4#3pin@728_polysilicon-1##24 A4#3pin@728_polysilicon-1##25 9.881
R6160 A4#3pin@728_polysilicon-1##25 A4#3pin@728_polysilicon-1##26 9.881
R6161 A4#3pin@728_polysilicon-1##26 A4#3pin@728_polysilicon-1##27 9.881
R6162 A4#3pin@728_polysilicon-1##27 A4#3pin@728_polysilicon-1##28 9.881
R6163 A4#3pin@728_polysilicon-1##28 A4#3pin@728_polysilicon-1##29 9.881
R6164 A4#3pin@728_polysilicon-1##29 A4#3pin@728_polysilicon-1##30 9.881
R6165 A4#3pin@728_polysilicon-1##30 A4#3pin@728_polysilicon-1##31 9.881
R6166 A4#3pin@728_polysilicon-1##31 A4#3pin@728_polysilicon-1##32 9.881
R6167 A4#3pin@728_polysilicon-1##32 A4#3pin@728_polysilicon-1##33 9.881
R6168 A4#3pin@728_polysilicon-1##33 A4#3pin@728_polysilicon-1##34 9.881
R6169 A4#3pin@728_polysilicon-1##34 A4#3pin@728_polysilicon-1##35 9.881
R6170 A4#3pin@728_polysilicon-1##35 A4#3pin@728_polysilicon-1##36 9.881
R6171 A4#3pin@728_polysilicon-1##36 A4#3pin@728_polysilicon-1##37 9.881
R6172 A4#3pin@728_polysilicon-1##37 A4#3pin@728_polysilicon-1##38 9.881
R6173 A4#3pin@728_polysilicon-1##38 A4#3pin@728_polysilicon-1##39 9.881
R6174 A4#3pin@728_polysilicon-1##39 A4#3pin@728_polysilicon-1##40 9.881
R6175 A4#3pin@728_polysilicon-1##40 A4#3pin@728_polysilicon-1##41 9.881
R6176 A4#3pin@728_polysilicon-1##41 A4#3pin@728_polysilicon-1##42 9.881
R6177 A4#3pin@728_polysilicon-1##42 A4#3pin@728_polysilicon-1##43 9.881
R6178 A4#3pin@728_polysilicon-1##43 A4#3pin@728_polysilicon-1##44 9.881
R6179 A4#3pin@728_polysilicon-1##44 A4#3pin@728_polysilicon-1##45 9.881
R6180 A4#3pin@728_polysilicon-1##45 A4#3pin@728_polysilicon-1##46 9.881
R6181 A4#3pin@728_polysilicon-1##46 A4#3pin@728_polysilicon-1##47 9.881
R6182 A4#3pin@728_polysilicon-1##47 A4#3pin@728_polysilicon-1##48 9.881
R6183 A4#3pin@728_polysilicon-1##48 A4#3pin@728_polysilicon-1##49 9.881
R6184 A4#3pin@728_polysilicon-1##49 A4#3pin@728_polysilicon-1##50 9.881
R6185 A4#3pin@728_polysilicon-1##50 A4#3pin@728_polysilicon-1##51 9.881
R6186 A4#3pin@728_polysilicon-1##51 A4#3pin@728_polysilicon-1##52 9.881
R6187 A4#3pin@728_polysilicon-1##52 A4#3pin@728_polysilicon-1##53 9.881
R6188 A4#3pin@728_polysilicon-1##53 A4#3pin@728_polysilicon-1##54 9.881
R6189 A4#3pin@728_polysilicon-1##54 A4#16nmos@125_poly-right 9.881
R6190 net@2392#5pmos@125_diff-top net@2392#2pin@717_metal-1 4.81
R6191 net@2392#1pin@727_polysilicon-1 net@2392#1pin@727_polysilicon-1##0 9.85
R6192 net@2392#1pin@727_polysilicon-1##0 net@2392#1pin@727_polysilicon-1##1 9.85
R6193 net@2392#1pin@727_polysilicon-1##1 net@2392#1pin@727_polysilicon-1##2 9.85
R6194 net@2392#1pin@727_polysilicon-1##2 net@2392#1pin@727_polysilicon-1##3 9.85
R6195 net@2392#1pin@727_polysilicon-1##3 net@2392#1pin@727_polysilicon-1##4 9.85
R6196 net@2392#1pin@727_polysilicon-1##4 net@2392#1pin@727_polysilicon-1##5 9.85
R6197 net@2392#1pin@727_polysilicon-1##5 net@2392#1pin@727_polysilicon-1##6 9.85
R6198 net@2392#1pin@727_polysilicon-1##6 net@2392#1pin@727_polysilicon-1##7 9.85
R6199 net@2392#1pin@727_polysilicon-1##7 net@2392#1pin@727_polysilicon-1##8 9.85
R6200 net@2392#1pin@727_polysilicon-1##8 net@2392#1pin@727_polysilicon-1##9 9.85
R6201 net@2392#1pin@727_polysilicon-1##9 net@2392#1pin@727_polysilicon-1##10 9.85
R6202 net@2392#1pin@727_polysilicon-1##10 net@2392#1pin@727_polysilicon-1##11 9.85
R6203 net@2392#1pin@727_polysilicon-1##11 net@2392#1pin@727_polysilicon-1##12 9.85
R6204 net@2392#1pin@727_polysilicon-1##12 net@2392#1pin@727_polysilicon-1##13 9.85
R6205 net@2392#1pin@727_polysilicon-1##13 net@2392#1pin@727_polysilicon-1##14 9.85
R6206 net@2392#1pin@727_polysilicon-1##14 net@2392#1pin@727_polysilicon-1##15 9.85
R6207 net@2392#1pin@727_polysilicon-1##15 net@2392#1pin@727_polysilicon-1##16 9.85
R6208 net@2392#1pin@727_polysilicon-1##16 net@2392#1pin@727_polysilicon-1##17 9.85
R6209 net@2392#1pin@727_polysilicon-1##17 net@2392#1pin@727_polysilicon-1##18 9.85
R6210 net@2392#1pin@727_polysilicon-1##18 net@2392#1pin@727_polysilicon-1##19 9.85
R6211 net@2392#1pin@727_polysilicon-1##19 net@2392#1pin@727_polysilicon-1##20 9.85
R6212 net@2392#1pin@727_polysilicon-1##20 net@2392#1pin@727_polysilicon-1##21 9.85
R6213 net@2392#1pin@727_polysilicon-1##21 net@2392#1pin@727_polysilicon-1##22 9.85
R6214 net@2392#1pin@727_polysilicon-1##22 net@2392#1pin@727_polysilicon-1##23 9.85
R6215 net@2392#1pin@727_polysilicon-1##23 net@2392#1pin@727_polysilicon-1##24 9.85
R6216 net@2392#1pin@727_polysilicon-1##24 net@2392#1pin@727_polysilicon-1##25 9.85
R6217 net@2392#1pin@727_polysilicon-1##25 net@2392#1pin@727_polysilicon-1##26 9.85
R6218 net@2392#1pin@727_polysilicon-1##26 net@2392#1pin@727_polysilicon-1##27 9.85
R6219 net@2392#1pin@727_polysilicon-1##27 net@2392#1pin@727_polysilicon-1##28 9.85
R6220 net@2392#1pin@727_polysilicon-1##28 net@2392#1pin@727_polysilicon-1##29 9.85
R6221 net@2392#1pin@727_polysilicon-1##29 net@2392#1pin@727_polysilicon-1##30 9.85
R6222 net@2392#1pin@727_polysilicon-1##30 net@2392#1pin@727_polysilicon-1##31 9.85
R6223 net@2392#1pin@727_polysilicon-1##31 net@2392#1pin@727_polysilicon-1##32 9.85
R6224 net@2392#1pin@727_polysilicon-1##32 net@2392#1pin@727_polysilicon-1##33 9.85
R6225 net@2392#1pin@727_polysilicon-1##33 net@2392#1pin@727_polysilicon-1##34 9.85
R6226 net@2392#1pin@727_polysilicon-1##34 net@2392#1pin@727_polysilicon-1##35 9.85
R6227 net@2392#1pin@727_polysilicon-1##35 net@2392#1pin@727_polysilicon-1##36 9.85
R6228 net@2392#1pin@727_polysilicon-1##36 net@2392#1pin@727_polysilicon-1##37 9.85
R6229 net@2392#1pin@727_polysilicon-1##37 net@2392#1pin@727_polysilicon-1##38 9.85
R6230 net@2392#1pin@727_polysilicon-1##38 net@2392#1pin@727_polysilicon-1##39 9.85
R6231 net@2392#1pin@727_polysilicon-1##39 net@2392#1pin@727_polysilicon-1##40 9.85
R6232 net@2392#1pin@727_polysilicon-1##40 net@2392#1pin@727_polysilicon-1##41 9.85
R6233 net@2392#1pin@727_polysilicon-1##41 net@2392#1pin@727_polysilicon-1##42 9.85
R6234 net@2392#1pin@727_polysilicon-1##42 net@2392#1pin@727_polysilicon-1##43 9.85
R6235 net@2392#1pin@727_polysilicon-1##43 net@2392#1pin@727_polysilicon-1##44 9.85
R6236 net@2392#1pin@727_polysilicon-1##44 net@2392#1pin@727_polysilicon-1##45 9.85
R6237 net@2392#1pin@727_polysilicon-1##45 net@2392#1pin@727_polysilicon-1##46 9.85
R6238 net@2392#1pin@727_polysilicon-1##46 net@2392#1pin@727_polysilicon-1##47 9.85
R6239 net@2392#1pin@727_polysilicon-1##47 net@2392#1pin@727_polysilicon-1##48 9.85
R6240 net@2392#1pin@727_polysilicon-1##48 net@2392#1pin@727_polysilicon-1##49 9.85
R6241 net@2392#1pin@727_polysilicon-1##49 net@2392#1pin@727_polysilicon-1##50 9.85
R6242 net@2392#1pin@727_polysilicon-1##50 net@2392#1pin@727_polysilicon-1##51 9.85
R6243 net@2392#1pin@727_polysilicon-1##51 net@2392#1pin@727_polysilicon-1##52 9.85
R6244 net@2392#1pin@727_polysilicon-1##52 net@2392#1pin@727_polysilicon-1##53 9.85
R6245 net@2392#1pin@727_polysilicon-1##53 net@2392#1pin@727_polysilicon-1##54 9.85
R6246 net@2392#1pin@727_polysilicon-1##54 net@2392#1pin@727_polysilicon-1##55 9.85
R6247 net@2392#1pin@727_polysilicon-1##55 net@2392#1pin@727_polysilicon-1##56 9.85
R6248 net@2392#1pin@727_polysilicon-1##56 net@2392#1pin@727_polysilicon-1##57 9.85
R6249 net@2392#1pin@727_polysilicon-1##57 net@2392#1pin@727_polysilicon-1##58 9.85
R6250 net@2392#1pin@727_polysilicon-1##58 net@2392#1pin@727_polysilicon-1##59 9.85
R6251 net@2392#1pin@727_polysilicon-1##59 net@2392#1pin@727_polysilicon-1##60 9.85
R6252 net@2392#1pin@727_polysilicon-1##60 net@2392#2pin@717_metal-1 9.85
R6253 B4#17pmos@124_poly-right B4#17pmos@124_poly-right##0 9.854
R6254 B4#17pmos@124_poly-right##0 B4#17pmos@124_poly-right##1 9.854
R6255 B4#17pmos@124_poly-right##1 B4#17pmos@124_poly-right##2 9.854
R6256 B4#17pmos@124_poly-right##2 B4#17pmos@124_poly-right##3 9.854
R6257 B4#17pmos@124_poly-right##3 B4#17pmos@124_poly-right##4 9.854
R6258 B4#17pmos@124_poly-right##4 B4#17pmos@124_poly-right##5 9.854
R6259 B4#17pmos@124_poly-right##5 B4#17pmos@124_poly-right##6 9.854
R6260 B4#17pmos@124_poly-right##6 B4#17pmos@124_poly-right##7 9.854
R6261 B4#17pmos@124_poly-right##7 B4#17pmos@124_poly-right##8 9.854
R6262 B4#17pmos@124_poly-right##8 B4#17pmos@124_poly-right##9 9.854
R6263 B4#17pmos@124_poly-right##9 B4#17pmos@124_poly-right##10 9.854
R6264 B4#17pmos@124_poly-right##10 B4#17pmos@124_poly-right##11 9.854
R6265 B4#17pmos@124_poly-right##11 B4#17pmos@124_poly-right##12 9.854
R6266 B4#17pmos@124_poly-right##12 B4#17pmos@124_poly-right##13 9.854
R6267 B4#17pmos@124_poly-right##13 B4#17pmos@124_poly-right##14 9.854
R6268 B4#17pmos@124_poly-right##14 B4#17pmos@124_poly-right##15 9.854
R6269 B4#17pmos@124_poly-right##15 B4#17pmos@124_poly-right##16 9.854
R6270 B4#17pmos@124_poly-right##16 B4#17pmos@124_poly-right##17 9.854
R6271 B4#17pmos@124_poly-right##17 B4#17pmos@124_poly-right##18 9.854
R6272 B4#17pmos@124_poly-right##18 B4#17pmos@124_poly-right##19 9.854
R6273 B4#17pmos@124_poly-right##19 B4#17pmos@124_poly-right##20 9.854
R6274 B4#17pmos@124_poly-right##20 B4#17pmos@124_poly-right##21 9.854
R6275 B4#17pmos@124_poly-right##21 B4#17pmos@124_poly-right##22 9.854
R6276 B4#17pmos@124_poly-right##22 B4#17pmos@124_poly-right##23 9.854
R6277 B4#17pmos@124_poly-right##23 B4#17pmos@124_poly-right##24 9.854
R6278 B4#17pmos@124_poly-right##24 B4#17pmos@124_poly-right##25 9.854
R6279 B4#17pmos@124_poly-right##25 B4#17pmos@124_poly-right##26 9.854
R6280 B4#17pmos@124_poly-right##26 B4#17pmos@124_poly-right##27 9.854
R6281 B4#17pmos@124_poly-right##27 B4#17pmos@124_poly-right##28 9.854
R6282 B4#17pmos@124_poly-right##28 B4#17pmos@124_poly-right##29 9.854
R6283 B4#17pmos@124_poly-right##29 B4#17pmos@124_poly-right##30 9.854
R6284 B4#17pmos@124_poly-right##30 B4#17pmos@124_poly-right##31 9.854
R6285 B4#17pmos@124_poly-right##31 B4#17pmos@124_poly-right##32 9.854
R6286 B4#17pmos@124_poly-right##32 B4#17pmos@124_poly-right##33 9.854
R6287 B4#17pmos@124_poly-right##33 B4#17pmos@124_poly-right##34 9.854
R6288 B4#17pmos@124_poly-right##34 B4#17pmos@124_poly-right##35 9.854
R6289 B4#17pmos@124_poly-right##35 B4#17pmos@124_poly-right##36 9.854
R6290 B4#17pmos@124_poly-right##36 B4#17pmos@124_poly-right##37 9.854
R6291 B4#17pmos@124_poly-right##37 B4#17pmos@124_poly-right##38 9.854
R6292 B4#17pmos@124_poly-right##38 B4#17pmos@124_poly-right##39 9.854
R6293 B4#17pmos@124_poly-right##39 B4#17pmos@124_poly-right##40 9.854
R6294 B4#17pmos@124_poly-right##40 B4#17pmos@124_poly-right##41 9.854
R6295 B4#17pmos@124_poly-right##41 B4#17pmos@124_poly-right##42 9.854
R6296 B4#17pmos@124_poly-right##42 B4#17pmos@124_poly-right##43 9.854
R6297 B4#17pmos@124_poly-right##43 B4#17pmos@124_poly-right##44 9.854
R6298 B4#17pmos@124_poly-right##44 B4#17pmos@124_poly-right##45 9.854
R6299 B4#17pmos@124_poly-right##45 B4#17pmos@124_poly-right##46 9.854
R6300 B4#17pmos@124_poly-right##46 B4#17pmos@124_poly-right##47 9.854
R6301 B4#17pmos@124_poly-right##47 B4#17pmos@124_poly-right##48 9.854
R6302 B4#17pmos@124_poly-right##48 B4#17pmos@124_poly-right##49 9.854
R6303 B4#17pmos@124_poly-right##49 B4#17pmos@124_poly-right##50 9.854
R6304 B4#17pmos@124_poly-right##50 B4#17pmos@124_poly-right##51 9.854
R6305 B4#17pmos@124_poly-right##51 B4#17pmos@124_poly-right##52 9.854
R6306 B4#17pmos@124_poly-right##52 B4#17pmos@124_poly-right##53 9.854
R6307 B4#17pmos@124_poly-right##53 B4#17pmos@124_poly-right##54 9.854
R6308 B4#17pmos@124_poly-right##54 B4#12pin@718_polysilicon-1 9.854
R6309 net@2497 net@2497#2contact@798_metal-1-metal-2 4.797
R6310 A4#17nmos@120_poly-right A4#17nmos@120_poly-right##0 9.871
R6311 A4#17nmos@120_poly-right##0 A4#17nmos@120_poly-right##1 9.871
R6312 A4#17nmos@120_poly-right##1 A4#17nmos@120_poly-right##2 9.871
R6313 A4#17nmos@120_poly-right##2 A4#17nmos@120_poly-right##3 9.871
R6314 A4#17nmos@120_poly-right##3 A4#17nmos@120_poly-right##4 9.871
R6315 A4#17nmos@120_poly-right##4 A4#17nmos@120_poly-right##5 9.871
R6316 A4#17nmos@120_poly-right##5 A4#17nmos@120_poly-right##6 9.871
R6317 A4#17nmos@120_poly-right##6 A4#17nmos@120_poly-right##7 9.871
R6318 A4#17nmos@120_poly-right##7 A4#17nmos@120_poly-right##8 9.871
R6319 A4#17nmos@120_poly-right##8 A4#17nmos@120_poly-right##9 9.871
R6320 A4#17nmos@120_poly-right##9 A4#17nmos@120_poly-right##10 9.871
R6321 A4#17nmos@120_poly-right##10 A4#17nmos@120_poly-right##11 9.871
R6322 A4#17nmos@120_poly-right##11 A4#17nmos@120_poly-right##12 9.871
R6323 A4#17nmos@120_poly-right##12 A4#17nmos@120_poly-right##13 9.871
R6324 A4#17nmos@120_poly-right##13 A4#17nmos@120_poly-right##14 9.871
R6325 A4#17nmos@120_poly-right##14 A4#17nmos@120_poly-right##15 9.871
R6326 A4#17nmos@120_poly-right##15 A4#17nmos@120_poly-right##16 9.871
R6327 A4#17nmos@120_poly-right##16 A4#17nmos@120_poly-right##17 9.871
R6328 A4#17nmos@120_poly-right##17 A4#17nmos@120_poly-right##18 9.871
R6329 A4#17nmos@120_poly-right##18 A4#17nmos@120_poly-right##19 9.871
R6330 A4#17nmos@120_poly-right##19 A4#17nmos@120_poly-right##20 9.871
R6331 A4#17nmos@120_poly-right##20 A4#17nmos@120_poly-right##21 9.871
R6332 A4#17nmos@120_poly-right##21 A4#17nmos@120_poly-right##22 9.871
R6333 A4#17nmos@120_poly-right##22 A4#17nmos@120_poly-right##23 9.871
R6334 A4#17nmos@120_poly-right##23 A4#17nmos@120_poly-right##24 9.871
R6335 A4#17nmos@120_poly-right##24 A4#17nmos@120_poly-right##25 9.871
R6336 A4#17nmos@120_poly-right##25 A4#17nmos@120_poly-right##26 9.871
R6337 A4#17nmos@120_poly-right##26 A4#17nmos@120_poly-right##27 9.871
R6338 A4#17nmos@120_poly-right##27 A4#17nmos@120_poly-right##28 9.871
R6339 A4#17nmos@120_poly-right##28 A4#17nmos@120_poly-right##29 9.871
R6340 A4#17nmos@120_poly-right##29 A4#17nmos@120_poly-right##30 9.871
R6341 A4#17nmos@120_poly-right##30 A4#17nmos@120_poly-right##31 9.871
R6342 A4#17nmos@120_poly-right##31 A4#17nmos@120_poly-right##32 9.871
R6343 A4#17nmos@120_poly-right##32 A4#17nmos@120_poly-right##33 9.871
R6344 A4#17nmos@120_poly-right##33 A4#17nmos@120_poly-right##34 9.871
R6345 A4#17nmos@120_poly-right##34 A4#17nmos@120_poly-right##35 9.871
R6346 A4#17nmos@120_poly-right##35 A4#17nmos@120_poly-right##36 9.871
R6347 A4#17nmos@120_poly-right##36 A4#17nmos@120_poly-right##37 9.871
R6348 A4#17nmos@120_poly-right##37 A4#17nmos@120_poly-right##38 9.871
R6349 A4#17nmos@120_poly-right##38 A4#17nmos@120_poly-right##39 9.871
R6350 A4#17nmos@120_poly-right##39 A4#17nmos@120_poly-right##40 9.871
R6351 A4#17nmos@120_poly-right##40 A4#17nmos@120_poly-right##41 9.871
R6352 A4#17nmos@120_poly-right##41 A4#17nmos@120_poly-right##42 9.871
R6353 A4#17nmos@120_poly-right##42 A4#17nmos@120_poly-right##43 9.871
R6354 A4#17nmos@120_poly-right##43 A4#17nmos@120_poly-right##44 9.871
R6355 A4#17nmos@120_poly-right##44 A4#17nmos@120_poly-right##45 9.871
R6356 A4#17nmos@120_poly-right##45 A4#17nmos@120_poly-right##46 9.871
R6357 A4#17nmos@120_poly-right##46 A4#17nmos@120_poly-right##47 9.871
R6358 A4#17nmos@120_poly-right##47 A4#17nmos@120_poly-right##48 9.871
R6359 A4#17nmos@120_poly-right##48 A4#17nmos@120_poly-right##49 9.871
R6360 A4#17nmos@120_poly-right##49 A4#17nmos@120_poly-right##50 9.871
R6361 A4#17nmos@120_poly-right##50 A4#17nmos@120_poly-right##51 9.871
R6362 A4#17nmos@120_poly-right##51 A4#17nmos@120_poly-right##52 9.871
R6363 A4#17nmos@120_poly-right##52 A4#17nmos@120_poly-right##53 9.871
R6364 A4#17nmos@120_poly-right##53 A4#17nmos@120_poly-right##54 9.871
R6365 A4#17nmos@120_poly-right##54 A4#17nmos@120_poly-right##55 9.871
R6366 A4#17nmos@120_poly-right##55 A4#12pmos@120_poly-left 9.871
R6367 net@2392#7pmos@121_poly-left net@2392#7pmos@121_poly-left##0 9.871
R6368 net@2392#7pmos@121_poly-left##0 net@2392#7pmos@121_poly-left##1 9.871
R6369 net@2392#7pmos@121_poly-left##1 net@2392#7pmos@121_poly-left##2 9.871
R6370 net@2392#7pmos@121_poly-left##2 net@2392#7pmos@121_poly-left##3 9.871
R6371 net@2392#7pmos@121_poly-left##3 net@2392#7pmos@121_poly-left##4 9.871
R6372 net@2392#7pmos@121_poly-left##4 net@2392#7pmos@121_poly-left##5 9.871
R6373 net@2392#7pmos@121_poly-left##5 net@2392#7pmos@121_poly-left##6 9.871
R6374 net@2392#7pmos@121_poly-left##6 net@2392#7pmos@121_poly-left##7 9.871
R6375 net@2392#7pmos@121_poly-left##7 net@2392#7pmos@121_poly-left##8 9.871
R6376 net@2392#7pmos@121_poly-left##8 net@2392#7pmos@121_poly-left##9 9.871
R6377 net@2392#7pmos@121_poly-left##9 net@2392#7pmos@121_poly-left##10 9.871
R6378 net@2392#7pmos@121_poly-left##10 net@2392#7pmos@121_poly-left##11 9.871
R6379 net@2392#7pmos@121_poly-left##11 net@2392#7pmos@121_poly-left##12 9.871
R6380 net@2392#7pmos@121_poly-left##12 net@2392#7pmos@121_poly-left##13 9.871
R6381 net@2392#7pmos@121_poly-left##13 net@2392#7pmos@121_poly-left##14 9.871
R6382 net@2392#7pmos@121_poly-left##14 net@2392#7pmos@121_poly-left##15 9.871
R6383 net@2392#7pmos@121_poly-left##15 net@2392#7pmos@121_poly-left##16 9.871
R6384 net@2392#7pmos@121_poly-left##16 net@2392#7pmos@121_poly-left##17 9.871
R6385 net@2392#7pmos@121_poly-left##17 net@2392#7pmos@121_poly-left##18 9.871
R6386 net@2392#7pmos@121_poly-left##18 net@2392#7pmos@121_poly-left##19 9.871
R6387 net@2392#7pmos@121_poly-left##19 net@2392#7pmos@121_poly-left##20 9.871
R6388 net@2392#7pmos@121_poly-left##20 net@2392#7pmos@121_poly-left##21 9.871
R6389 net@2392#7pmos@121_poly-left##21 net@2392#7pmos@121_poly-left##22 9.871
R6390 net@2392#7pmos@121_poly-left##22 net@2392#7pmos@121_poly-left##23 9.871
R6391 net@2392#7pmos@121_poly-left##23 net@2392#7pmos@121_poly-left##24 9.871
R6392 net@2392#7pmos@121_poly-left##24 net@2392#7pmos@121_poly-left##25 9.871
R6393 net@2392#7pmos@121_poly-left##25 net@2392#7pmos@121_poly-left##26 9.871
R6394 net@2392#7pmos@121_poly-left##26 net@2392#7pmos@121_poly-left##27 9.871
R6395 net@2392#7pmos@121_poly-left##27 net@2392#7pmos@121_poly-left##28 9.871
R6396 net@2392#7pmos@121_poly-left##28 net@2392#7pmos@121_poly-left##29 9.871
R6397 net@2392#7pmos@121_poly-left##29 net@2392#7pmos@121_poly-left##30 9.871
R6398 net@2392#7pmos@121_poly-left##30 net@2392#7pmos@121_poly-left##31 9.871
R6399 net@2392#7pmos@121_poly-left##31 net@2392#7pmos@121_poly-left##32 9.871
R6400 net@2392#7pmos@121_poly-left##32 net@2392#7pmos@121_poly-left##33 9.871
R6401 net@2392#7pmos@121_poly-left##33 net@2392#7pmos@121_poly-left##34 9.871
R6402 net@2392#7pmos@121_poly-left##34 net@2392#7pmos@121_poly-left##35 9.871
R6403 net@2392#7pmos@121_poly-left##35 net@2392#7pmos@121_poly-left##36 9.871
R6404 net@2392#7pmos@121_poly-left##36 net@2392#7pmos@121_poly-left##37 9.871
R6405 net@2392#7pmos@121_poly-left##37 net@2392#7pmos@121_poly-left##38 9.871
R6406 net@2392#7pmos@121_poly-left##38 net@2392#7pmos@121_poly-left##39 9.871
R6407 net@2392#7pmos@121_poly-left##39 net@2392#7pmos@121_poly-left##40 9.871
R6408 net@2392#7pmos@121_poly-left##40 net@2392#7pmos@121_poly-left##41 9.871
R6409 net@2392#7pmos@121_poly-left##41 net@2392#7pmos@121_poly-left##42 9.871
R6410 net@2392#7pmos@121_poly-left##42 net@2392#7pmos@121_poly-left##43 9.871
R6411 net@2392#7pmos@121_poly-left##43 net@2392#7pmos@121_poly-left##44 9.871
R6412 net@2392#7pmos@121_poly-left##44 net@2392#7pmos@121_poly-left##45 9.871
R6413 net@2392#7pmos@121_poly-left##45 net@2392#7pmos@121_poly-left##46 9.871
R6414 net@2392#7pmos@121_poly-left##46 net@2392#7pmos@121_poly-left##47 9.871
R6415 net@2392#7pmos@121_poly-left##47 net@2392#7pmos@121_poly-left##48 9.871
R6416 net@2392#7pmos@121_poly-left##48 net@2392#7pmos@121_poly-left##49 9.871
R6417 net@2392#7pmos@121_poly-left##49 net@2392#7pmos@121_poly-left##50 9.871
R6418 net@2392#7pmos@121_poly-left##50 net@2392#7pmos@121_poly-left##51 9.871
R6419 net@2392#7pmos@121_poly-left##51 net@2392#7pmos@121_poly-left##52 9.871
R6420 net@2392#7pmos@121_poly-left##52 net@2392#7pmos@121_poly-left##53 9.871
R6421 net@2392#7pmos@121_poly-left##53 net@2392#7pmos@121_poly-left##54 9.871
R6422 net@2392#7pmos@121_poly-left##54 net@2392#7pmos@121_poly-left##55 9.871
R6423 net@2392#7pmos@121_poly-left##55 net@2392#11nmos@121_poly-right 9.871
R6424 B4#18pmos@122_poly-right B4#18pmos@122_poly-right##0 9.871
R6425 B4#18pmos@122_poly-right##0 B4#18pmos@122_poly-right##1 9.871
R6426 B4#18pmos@122_poly-right##1 B4#18pmos@122_poly-right##2 9.871
R6427 B4#18pmos@122_poly-right##2 B4#18pmos@122_poly-right##3 9.871
R6428 B4#18pmos@122_poly-right##3 B4#18pmos@122_poly-right##4 9.871
R6429 B4#18pmos@122_poly-right##4 B4#18pmos@122_poly-right##5 9.871
R6430 B4#18pmos@122_poly-right##5 B4#18pmos@122_poly-right##6 9.871
R6431 B4#18pmos@122_poly-right##6 B4#18pmos@122_poly-right##7 9.871
R6432 B4#18pmos@122_poly-right##7 B4#18pmos@122_poly-right##8 9.871
R6433 B4#18pmos@122_poly-right##8 B4#18pmos@122_poly-right##9 9.871
R6434 B4#18pmos@122_poly-right##9 B4#18pmos@122_poly-right##10 9.871
R6435 B4#18pmos@122_poly-right##10 B4#18pmos@122_poly-right##11 9.871
R6436 B4#18pmos@122_poly-right##11 B4#18pmos@122_poly-right##12 9.871
R6437 B4#18pmos@122_poly-right##12 B4#18pmos@122_poly-right##13 9.871
R6438 B4#18pmos@122_poly-right##13 B4#18pmos@122_poly-right##14 9.871
R6439 B4#18pmos@122_poly-right##14 B4#18pmos@122_poly-right##15 9.871
R6440 B4#18pmos@122_poly-right##15 B4#18pmos@122_poly-right##16 9.871
R6441 B4#18pmos@122_poly-right##16 B4#18pmos@122_poly-right##17 9.871
R6442 B4#18pmos@122_poly-right##17 B4#18pmos@122_poly-right##18 9.871
R6443 B4#18pmos@122_poly-right##18 B4#18pmos@122_poly-right##19 9.871
R6444 B4#18pmos@122_poly-right##19 B4#18pmos@122_poly-right##20 9.871
R6445 B4#18pmos@122_poly-right##20 B4#18pmos@122_poly-right##21 9.871
R6446 B4#18pmos@122_poly-right##21 B4#18pmos@122_poly-right##22 9.871
R6447 B4#18pmos@122_poly-right##22 B4#18pmos@122_poly-right##23 9.871
R6448 B4#18pmos@122_poly-right##23 B4#18pmos@122_poly-right##24 9.871
R6449 B4#18pmos@122_poly-right##24 B4#18pmos@122_poly-right##25 9.871
R6450 B4#18pmos@122_poly-right##25 B4#18pmos@122_poly-right##26 9.871
R6451 B4#18pmos@122_poly-right##26 B4#18pmos@122_poly-right##27 9.871
R6452 B4#18pmos@122_poly-right##27 B4#18pmos@122_poly-right##28 9.871
R6453 B4#18pmos@122_poly-right##28 B4#18pmos@122_poly-right##29 9.871
R6454 B4#18pmos@122_poly-right##29 B4#18pmos@122_poly-right##30 9.871
R6455 B4#18pmos@122_poly-right##30 B4#18pmos@122_poly-right##31 9.871
R6456 B4#18pmos@122_poly-right##31 B4#18pmos@122_poly-right##32 9.871
R6457 B4#18pmos@122_poly-right##32 B4#18pmos@122_poly-right##33 9.871
R6458 B4#18pmos@122_poly-right##33 B4#18pmos@122_poly-right##34 9.871
R6459 B4#18pmos@122_poly-right##34 B4#18pmos@122_poly-right##35 9.871
R6460 B4#18pmos@122_poly-right##35 B4#18pmos@122_poly-right##36 9.871
R6461 B4#18pmos@122_poly-right##36 B4#18pmos@122_poly-right##37 9.871
R6462 B4#18pmos@122_poly-right##37 B4#18pmos@122_poly-right##38 9.871
R6463 B4#18pmos@122_poly-right##38 B4#18pmos@122_poly-right##39 9.871
R6464 B4#18pmos@122_poly-right##39 B4#18pmos@122_poly-right##40 9.871
R6465 B4#18pmos@122_poly-right##40 B4#18pmos@122_poly-right##41 9.871
R6466 B4#18pmos@122_poly-right##41 B4#18pmos@122_poly-right##42 9.871
R6467 B4#18pmos@122_poly-right##42 B4#18pmos@122_poly-right##43 9.871
R6468 B4#18pmos@122_poly-right##43 B4#18pmos@122_poly-right##44 9.871
R6469 B4#18pmos@122_poly-right##44 B4#18pmos@122_poly-right##45 9.871
R6470 B4#18pmos@122_poly-right##45 B4#18pmos@122_poly-right##46 9.871
R6471 B4#18pmos@122_poly-right##46 B4#18pmos@122_poly-right##47 9.871
R6472 B4#18pmos@122_poly-right##47 B4#18pmos@122_poly-right##48 9.871
R6473 B4#18pmos@122_poly-right##48 B4#18pmos@122_poly-right##49 9.871
R6474 B4#18pmos@122_poly-right##49 B4#18pmos@122_poly-right##50 9.871
R6475 B4#18pmos@122_poly-right##50 B4#18pmos@122_poly-right##51 9.871
R6476 B4#18pmos@122_poly-right##51 B4#18pmos@122_poly-right##52 9.871
R6477 B4#18pmos@122_poly-right##52 B4#18pmos@122_poly-right##53 9.871
R6478 B4#18pmos@122_poly-right##53 B4#18pmos@122_poly-right##54 9.871
R6479 B4#18pmos@122_poly-right##54 B4#18pmos@122_poly-right##55 9.871
R6480 B4#18pmos@122_poly-right##55 B4#16nmos@122_poly-left 9.871
R6481 net@2497#14pmos@123_poly-right net@2497#14pmos@123_poly-right##0 9.871
R6482 net@2497#14pmos@123_poly-right##0 net@2497#14pmos@123_poly-right##1 9.871
R6483 net@2497#14pmos@123_poly-right##1 net@2497#14pmos@123_poly-right##2 9.871
R6484 net@2497#14pmos@123_poly-right##2 net@2497#14pmos@123_poly-right##3 9.871
R6485 net@2497#14pmos@123_poly-right##3 net@2497#14pmos@123_poly-right##4 9.871
R6486 net@2497#14pmos@123_poly-right##4 net@2497#14pmos@123_poly-right##5 9.871
R6487 net@2497#14pmos@123_poly-right##5 net@2497#14pmos@123_poly-right##6 9.871
R6488 net@2497#14pmos@123_poly-right##6 net@2497#14pmos@123_poly-right##7 9.871
R6489 net@2497#14pmos@123_poly-right##7 net@2497#14pmos@123_poly-right##8 9.871
R6490 net@2497#14pmos@123_poly-right##8 net@2497#14pmos@123_poly-right##9 9.871
R6491 net@2497#14pmos@123_poly-right##9 net@2497#14pmos@123_poly-right##10 9.871
R6492 net@2497#14pmos@123_poly-right##10 net@2497#14pmos@123_poly-right##11 9.871
R6493 net@2497#14pmos@123_poly-right##11 net@2497#14pmos@123_poly-right##12 9.871
R6494 net@2497#14pmos@123_poly-right##12 net@2497#14pmos@123_poly-right##13 9.871
R6495 net@2497#14pmos@123_poly-right##13 net@2497#14pmos@123_poly-right##14 9.871
R6496 net@2497#14pmos@123_poly-right##14 net@2497#14pmos@123_poly-right##15 9.871
R6497 net@2497#14pmos@123_poly-right##15 net@2497#14pmos@123_poly-right##16 9.871
R6498 net@2497#14pmos@123_poly-right##16 net@2497#14pmos@123_poly-right##17 9.871
R6499 net@2497#14pmos@123_poly-right##17 net@2497#14pmos@123_poly-right##18 9.871
R6500 net@2497#14pmos@123_poly-right##18 net@2497#14pmos@123_poly-right##19 9.871
R6501 net@2497#14pmos@123_poly-right##19 net@2497#14pmos@123_poly-right##20 9.871
R6502 net@2497#14pmos@123_poly-right##20 net@2497#14pmos@123_poly-right##21 9.871
R6503 net@2497#14pmos@123_poly-right##21 net@2497#14pmos@123_poly-right##22 9.871
R6504 net@2497#14pmos@123_poly-right##22 net@2497#14pmos@123_poly-right##23 9.871
R6505 net@2497#14pmos@123_poly-right##23 net@2497#14pmos@123_poly-right##24 9.871
R6506 net@2497#14pmos@123_poly-right##24 net@2497#14pmos@123_poly-right##25 9.871
R6507 net@2497#14pmos@123_poly-right##25 net@2497#14pmos@123_poly-right##26 9.871
R6508 net@2497#14pmos@123_poly-right##26 net@2497#14pmos@123_poly-right##27 9.871
R6509 net@2497#14pmos@123_poly-right##27 net@2497#14pmos@123_poly-right##28 9.871
R6510 net@2497#14pmos@123_poly-right##28 net@2497#14pmos@123_poly-right##29 9.871
R6511 net@2497#14pmos@123_poly-right##29 net@2497#14pmos@123_poly-right##30 9.871
R6512 net@2497#14pmos@123_poly-right##30 net@2497#14pmos@123_poly-right##31 9.871
R6513 net@2497#14pmos@123_poly-right##31 net@2497#14pmos@123_poly-right##32 9.871
R6514 net@2497#14pmos@123_poly-right##32 net@2497#14pmos@123_poly-right##33 9.871
R6515 net@2497#14pmos@123_poly-right##33 net@2497#14pmos@123_poly-right##34 9.871
R6516 net@2497#14pmos@123_poly-right##34 net@2497#14pmos@123_poly-right##35 9.871
R6517 net@2497#14pmos@123_poly-right##35 net@2497#14pmos@123_poly-right##36 9.871
R6518 net@2497#14pmos@123_poly-right##36 net@2497#14pmos@123_poly-right##37 9.871
R6519 net@2497#14pmos@123_poly-right##37 net@2497#14pmos@123_poly-right##38 9.871
R6520 net@2497#14pmos@123_poly-right##38 net@2497#14pmos@123_poly-right##39 9.871
R6521 net@2497#14pmos@123_poly-right##39 net@2497#14pmos@123_poly-right##40 9.871
R6522 net@2497#14pmos@123_poly-right##40 net@2497#14pmos@123_poly-right##41 9.871
R6523 net@2497#14pmos@123_poly-right##41 net@2497#14pmos@123_poly-right##42 9.871
R6524 net@2497#14pmos@123_poly-right##42 net@2497#14pmos@123_poly-right##43 9.871
R6525 net@2497#14pmos@123_poly-right##43 net@2497#14pmos@123_poly-right##44 9.871
R6526 net@2497#14pmos@123_poly-right##44 net@2497#14pmos@123_poly-right##45 9.871
R6527 net@2497#14pmos@123_poly-right##45 net@2497#14pmos@123_poly-right##46 9.871
R6528 net@2497#14pmos@123_poly-right##46 net@2497#14pmos@123_poly-right##47 9.871
R6529 net@2497#14pmos@123_poly-right##47 net@2497#14pmos@123_poly-right##48 9.871
R6530 net@2497#14pmos@123_poly-right##48 net@2497#14pmos@123_poly-right##49 9.871
R6531 net@2497#14pmos@123_poly-right##49 net@2497#14pmos@123_poly-right##50 9.871
R6532 net@2497#14pmos@123_poly-right##50 net@2497#14pmos@123_poly-right##51 9.871
R6533 net@2497#14pmos@123_poly-right##51 net@2497#14pmos@123_poly-right##52 9.871
R6534 net@2497#14pmos@123_poly-right##52 net@2497#14pmos@123_poly-right##53 9.871
R6535 net@2497#14pmos@123_poly-right##53 net@2497#14pmos@123_poly-right##54 9.871
R6536 net@2497#14pmos@123_poly-right##54 net@2497#14pmos@123_poly-right##55 9.871
R6537 net@2497#14pmos@123_poly-right##55 net@2497#9nmos@123_poly-left 9.871
R6538 net@2490#2contact@822_metal-1-polysilicon-1 net@2490 4.706
R6539 net@2490#12pmos@126_poly-right net@2490#12pmos@126_poly-right##0 9.864
R6540 net@2490#12pmos@126_poly-right##0 net@2490#12pmos@126_poly-right##1 9.864
R6541 net@2490#12pmos@126_poly-right##1 net@2490#12pmos@126_poly-right##2 9.864
R6542 net@2490#12pmos@126_poly-right##2 net@2490#12pmos@126_poly-right##3 9.864
R6543 net@2490#12pmos@126_poly-right##3 net@2490#12pmos@126_poly-right##4 9.864
R6544 net@2490#12pmos@126_poly-right##4 net@2490#12pmos@126_poly-right##5 9.864
R6545 net@2490#12pmos@126_poly-right##5 net@2490#12pmos@126_poly-right##6 9.864
R6546 net@2490#12pmos@126_poly-right##6 net@2490#12pmos@126_poly-right##7 9.864
R6547 net@2490#12pmos@126_poly-right##7 net@2490#12pmos@126_poly-right##8 9.864
R6548 net@2490#12pmos@126_poly-right##8 net@2490#12pmos@126_poly-right##9 9.864
R6549 net@2490#12pmos@126_poly-right##9 net@2490#12pmos@126_poly-right##10 9.864
R6550 net@2490#12pmos@126_poly-right##10 net@2490#12pmos@126_poly-right##11 9.864
R6551 net@2490#12pmos@126_poly-right##11 net@2490#12pmos@126_poly-right##12 9.864
R6552 net@2490#12pmos@126_poly-right##12 net@2490#12pmos@126_poly-right##13 9.864
R6553 net@2490#12pmos@126_poly-right##13 net@2490#12pmos@126_poly-right##14 9.864
R6554 net@2490#12pmos@126_poly-right##14 net@2490#12pmos@126_poly-right##15 9.864
R6555 net@2490#12pmos@126_poly-right##15 net@2490#12pmos@126_poly-right##16 9.864
R6556 net@2490#12pmos@126_poly-right##16 net@2490#12pmos@126_poly-right##17 9.864
R6557 net@2490#12pmos@126_poly-right##17 net@2490#12pmos@126_poly-right##18 9.864
R6558 net@2490#12pmos@126_poly-right##18 net@2490#12pmos@126_poly-right##19 9.864
R6559 net@2490#12pmos@126_poly-right##19 net@2490#12pmos@126_poly-right##20 9.864
R6560 net@2490#12pmos@126_poly-right##20 net@2490#12pmos@126_poly-right##21 9.864
R6561 net@2490#12pmos@126_poly-right##21 net@2490#12pmos@126_poly-right##22 9.864
R6562 net@2490#12pmos@126_poly-right##22 net@2490#12pmos@126_poly-right##23 9.864
R6563 net@2490#12pmos@126_poly-right##23 net@2490#12pmos@126_poly-right##24 9.864
R6564 net@2490#12pmos@126_poly-right##24 net@2490#12pmos@126_poly-right##25 9.864
R6565 net@2490#12pmos@126_poly-right##25 net@2490#12pmos@126_poly-right##26 9.864
R6566 net@2490#12pmos@126_poly-right##26 net@2490#12pmos@126_poly-right##27 9.864
R6567 net@2490#12pmos@126_poly-right##27 net@2490#12pmos@126_poly-right##28 9.864
R6568 net@2490#12pmos@126_poly-right##28 net@2490#12pmos@126_poly-right##29 9.864
R6569 net@2490#12pmos@126_poly-right##29 net@2490#12pmos@126_poly-right##30 9.864
R6570 net@2490#12pmos@126_poly-right##30 net@2490#12pmos@126_poly-right##31 9.864
R6571 net@2490#12pmos@126_poly-right##31 net@2490#12pmos@126_poly-right##32 9.864
R6572 net@2490#12pmos@126_poly-right##32 net@2490#12pmos@126_poly-right##33 9.864
R6573 net@2490#12pmos@126_poly-right##33 net@2490#12pmos@126_poly-right##34 9.864
R6574 net@2490#12pmos@126_poly-right##34 net@2490#12pmos@126_poly-right##35 9.864
R6575 net@2490#12pmos@126_poly-right##35 net@2490#12pmos@126_poly-right##36 9.864
R6576 net@2490#12pmos@126_poly-right##36 net@2490#12pmos@126_poly-right##37 9.864
R6577 net@2490#12pmos@126_poly-right##37 net@2490#12pmos@126_poly-right##38 9.864
R6578 net@2490#12pmos@126_poly-right##38 net@2490#12pmos@126_poly-right##39 9.864
R6579 net@2490#12pmos@126_poly-right##39 net@2490#12pmos@126_poly-right##40 9.864
R6580 net@2490#12pmos@126_poly-right##40 net@2490#12pmos@126_poly-right##41 9.864
R6581 net@2490#12pmos@126_poly-right##41 net@2490#12pmos@126_poly-right##42 9.864
R6582 net@2490#12pmos@126_poly-right##42 net@2490#12pmos@126_poly-right##43 9.864
R6583 net@2490#12pmos@126_poly-right##43 net@2490#12pmos@126_poly-right##44 9.864
R6584 net@2490#12pmos@126_poly-right##44 net@2490#12pmos@126_poly-right##45 9.864
R6585 net@2490#12pmos@126_poly-right##45 net@2490#12pmos@126_poly-right##46 9.864
R6586 net@2490#12pmos@126_poly-right##46 net@2490#12pmos@126_poly-right##47 9.864
R6587 net@2490#12pmos@126_poly-right##47 net@2490#12pmos@126_poly-right##48 9.864
R6588 net@2490#12pmos@126_poly-right##48 net@2490#12pmos@126_poly-right##49 9.864
R6589 net@2490#12pmos@126_poly-right##49 net@2490#12pmos@126_poly-right##50 9.864
R6590 net@2490#12pmos@126_poly-right##50 net@2490#12pmos@126_poly-right##51 9.864
R6591 net@2490#12pmos@126_poly-right##51 net@2490#12pmos@126_poly-right##52 9.864
R6592 net@2490#12pmos@126_poly-right##52 net@2490#12pmos@126_poly-right##53 9.864
R6593 net@2490#12pmos@126_poly-right##53 net@2490#5pin@720_polysilicon-1 9.864
R6594 XOR1_to_NAND5#22pmos@126_diff-top XOR1_to_NAND5#1contact@875_metal-1-metal-2 4.862
R6595 XOR1_to_NAND5#3pin@753_polysilicon-1 XOR1_to_NAND5#3pin@753_polysilicon-1##0 9.881
R6596 XOR1_to_NAND5#3pin@753_polysilicon-1##0 XOR1_to_NAND5#3pin@753_polysilicon-1##1 9.881
R6597 XOR1_to_NAND5#3pin@753_polysilicon-1##1 XOR1_to_NAND5#3pin@753_polysilicon-1##2 9.881
R6598 XOR1_to_NAND5#3pin@753_polysilicon-1##2 XOR1_to_NAND5#3pin@753_polysilicon-1##3 9.881
R6599 XOR1_to_NAND5#3pin@753_polysilicon-1##3 XOR1_to_NAND5#3pin@753_polysilicon-1##4 9.881
R6600 XOR1_to_NAND5#3pin@753_polysilicon-1##4 XOR1_to_NAND5#3pin@753_polysilicon-1##5 9.881
R6601 XOR1_to_NAND5#3pin@753_polysilicon-1##5 XOR1_to_NAND5#3pin@753_polysilicon-1##6 9.881
R6602 XOR1_to_NAND5#3pin@753_polysilicon-1##6 XOR1_to_NAND5#3pin@753_polysilicon-1##7 9.881
R6603 XOR1_to_NAND5#3pin@753_polysilicon-1##7 XOR1_to_NAND5#3pin@753_polysilicon-1##8 9.881
R6604 XOR1_to_NAND5#3pin@753_polysilicon-1##8 XOR1_to_NAND5#3pin@753_polysilicon-1##9 9.881
R6605 XOR1_to_NAND5#3pin@753_polysilicon-1##9 XOR1_to_NAND5#3pin@753_polysilicon-1##10 9.881
R6606 XOR1_to_NAND5#3pin@753_polysilicon-1##10 XOR1_to_NAND5#3pin@753_polysilicon-1##11 9.881
R6607 XOR1_to_NAND5#3pin@753_polysilicon-1##11 XOR1_to_NAND5#3pin@753_polysilicon-1##12 9.881
R6608 XOR1_to_NAND5#3pin@753_polysilicon-1##12 XOR1_to_NAND5#3pin@753_polysilicon-1##13 9.881
R6609 XOR1_to_NAND5#3pin@753_polysilicon-1##13 XOR1_to_NAND5#3pin@753_polysilicon-1##14 9.881
R6610 XOR1_to_NAND5#3pin@753_polysilicon-1##14 XOR1_to_NAND5#3pin@753_polysilicon-1##15 9.881
R6611 XOR1_to_NAND5#3pin@753_polysilicon-1##15 XOR1_to_NAND5#3pin@753_polysilicon-1##16 9.881
R6612 XOR1_to_NAND5#3pin@753_polysilicon-1##16 XOR1_to_NAND5#3pin@753_polysilicon-1##17 9.881
R6613 XOR1_to_NAND5#3pin@753_polysilicon-1##17 XOR1_to_NAND5#3pin@753_polysilicon-1##18 9.881
R6614 XOR1_to_NAND5#3pin@753_polysilicon-1##18 XOR1_to_NAND5#3pin@753_polysilicon-1##19 9.881
R6615 XOR1_to_NAND5#3pin@753_polysilicon-1##19 XOR1_to_NAND5#3pin@753_polysilicon-1##20 9.881
R6616 XOR1_to_NAND5#3pin@753_polysilicon-1##20 XOR1_to_NAND5#3pin@753_polysilicon-1##21 9.881
R6617 XOR1_to_NAND5#3pin@753_polysilicon-1##21 XOR1_to_NAND5#3pin@753_polysilicon-1##22 9.881
R6618 XOR1_to_NAND5#3pin@753_polysilicon-1##22 XOR1_to_NAND5#3pin@753_polysilicon-1##23 9.881
R6619 XOR1_to_NAND5#3pin@753_polysilicon-1##23 XOR1_to_NAND5#3pin@753_polysilicon-1##24 9.881
R6620 XOR1_to_NAND5#3pin@753_polysilicon-1##24 XOR1_to_NAND5#3pin@753_polysilicon-1##25 9.881
R6621 XOR1_to_NAND5#3pin@753_polysilicon-1##25 XOR1_to_NAND5#3pin@753_polysilicon-1##26 9.881
R6622 XOR1_to_NAND5#3pin@753_polysilicon-1##26 XOR1_to_NAND5#3pin@753_polysilicon-1##27 9.881
R6623 XOR1_to_NAND5#3pin@753_polysilicon-1##27 XOR1_to_NAND5#3pin@753_polysilicon-1##28 9.881
R6624 XOR1_to_NAND5#3pin@753_polysilicon-1##28 XOR1_to_NAND5#3pin@753_polysilicon-1##29 9.881
R6625 XOR1_to_NAND5#3pin@753_polysilicon-1##29 XOR1_to_NAND5#3pin@753_polysilicon-1##30 9.881
R6626 XOR1_to_NAND5#3pin@753_polysilicon-1##30 XOR1_to_NAND5#3pin@753_polysilicon-1##31 9.881
R6627 XOR1_to_NAND5#3pin@753_polysilicon-1##31 XOR1_to_NAND5#3pin@753_polysilicon-1##32 9.881
R6628 XOR1_to_NAND5#3pin@753_polysilicon-1##32 XOR1_to_NAND5#3pin@753_polysilicon-1##33 9.881
R6629 XOR1_to_NAND5#3pin@753_polysilicon-1##33 XOR1_to_NAND5#3pin@753_polysilicon-1##34 9.881
R6630 XOR1_to_NAND5#3pin@753_polysilicon-1##34 XOR1_to_NAND5#3pin@753_polysilicon-1##35 9.881
R6631 XOR1_to_NAND5#3pin@753_polysilicon-1##35 XOR1_to_NAND5#3pin@753_polysilicon-1##36 9.881
R6632 XOR1_to_NAND5#3pin@753_polysilicon-1##36 XOR1_to_NAND5#3pin@753_polysilicon-1##37 9.881
R6633 XOR1_to_NAND5#3pin@753_polysilicon-1##37 XOR1_to_NAND5#3pin@753_polysilicon-1##38 9.881
R6634 XOR1_to_NAND5#3pin@753_polysilicon-1##38 XOR1_to_NAND5#3pin@753_polysilicon-1##39 9.881
R6635 XOR1_to_NAND5#3pin@753_polysilicon-1##39 XOR1_to_NAND5#3pin@753_polysilicon-1##40 9.881
R6636 XOR1_to_NAND5#3pin@753_polysilicon-1##40 XOR1_to_NAND5#3pin@753_polysilicon-1##41 9.881
R6637 XOR1_to_NAND5#3pin@753_polysilicon-1##41 XOR1_to_NAND5#3pin@753_polysilicon-1##42 9.881
R6638 XOR1_to_NAND5#3pin@753_polysilicon-1##42 XOR1_to_NAND5#3pin@753_polysilicon-1##43 9.881
R6639 XOR1_to_NAND5#3pin@753_polysilicon-1##43 XOR1_to_NAND5#3pin@753_polysilicon-1##44 9.881
R6640 XOR1_to_NAND5#3pin@753_polysilicon-1##44 XOR1_to_NAND5#3pin@753_polysilicon-1##45 9.881
R6641 XOR1_to_NAND5#3pin@753_polysilicon-1##45 XOR1_to_NAND5#3pin@753_polysilicon-1##46 9.881
R6642 XOR1_to_NAND5#3pin@753_polysilicon-1##46 XOR1_to_NAND5#3pin@753_polysilicon-1##47 9.881
R6643 XOR1_to_NAND5#3pin@753_polysilicon-1##47 XOR1_to_NAND5#3pin@753_polysilicon-1##48 9.881
R6644 XOR1_to_NAND5#3pin@753_polysilicon-1##48 XOR1_to_NAND5#3pin@753_polysilicon-1##49 9.881
R6645 XOR1_to_NAND5#3pin@753_polysilicon-1##49 XOR1_to_NAND5#3pin@753_polysilicon-1##50 9.881
R6646 XOR1_to_NAND5#3pin@753_polysilicon-1##50 XOR1_to_NAND5#3pin@753_polysilicon-1##51 9.881
R6647 XOR1_to_NAND5#3pin@753_polysilicon-1##51 XOR1_to_NAND5#3pin@753_polysilicon-1##52 9.881
R6648 XOR1_to_NAND5#3pin@753_polysilicon-1##52 XOR1_to_NAND5#3pin@753_polysilicon-1##53 9.881
R6649 XOR1_to_NAND5#3pin@753_polysilicon-1##53 XOR1_to_NAND5#3pin@753_polysilicon-1##54 9.881
R6650 XOR1_to_NAND5#3pin@753_polysilicon-1##54 XOR1_to_NAND5#24nmos@132_poly-right 9.881
R6651 net@2394#5pmos@132_diff-top net@2394#2pin@742_metal-1 4.81
R6652 net@2394#1pin@752_polysilicon-1 net@2394#1pin@752_polysilicon-1##0 9.85
R6653 net@2394#1pin@752_polysilicon-1##0 net@2394#1pin@752_polysilicon-1##1 9.85
R6654 net@2394#1pin@752_polysilicon-1##1 net@2394#1pin@752_polysilicon-1##2 9.85
R6655 net@2394#1pin@752_polysilicon-1##2 net@2394#1pin@752_polysilicon-1##3 9.85
R6656 net@2394#1pin@752_polysilicon-1##3 net@2394#1pin@752_polysilicon-1##4 9.85
R6657 net@2394#1pin@752_polysilicon-1##4 net@2394#1pin@752_polysilicon-1##5 9.85
R6658 net@2394#1pin@752_polysilicon-1##5 net@2394#1pin@752_polysilicon-1##6 9.85
R6659 net@2394#1pin@752_polysilicon-1##6 net@2394#1pin@752_polysilicon-1##7 9.85
R6660 net@2394#1pin@752_polysilicon-1##7 net@2394#1pin@752_polysilicon-1##8 9.85
R6661 net@2394#1pin@752_polysilicon-1##8 net@2394#1pin@752_polysilicon-1##9 9.85
R6662 net@2394#1pin@752_polysilicon-1##9 net@2394#1pin@752_polysilicon-1##10 9.85
R6663 net@2394#1pin@752_polysilicon-1##10 net@2394#1pin@752_polysilicon-1##11 9.85
R6664 net@2394#1pin@752_polysilicon-1##11 net@2394#1pin@752_polysilicon-1##12 9.85
R6665 net@2394#1pin@752_polysilicon-1##12 net@2394#1pin@752_polysilicon-1##13 9.85
R6666 net@2394#1pin@752_polysilicon-1##13 net@2394#1pin@752_polysilicon-1##14 9.85
R6667 net@2394#1pin@752_polysilicon-1##14 net@2394#1pin@752_polysilicon-1##15 9.85
R6668 net@2394#1pin@752_polysilicon-1##15 net@2394#1pin@752_polysilicon-1##16 9.85
R6669 net@2394#1pin@752_polysilicon-1##16 net@2394#1pin@752_polysilicon-1##17 9.85
R6670 net@2394#1pin@752_polysilicon-1##17 net@2394#1pin@752_polysilicon-1##18 9.85
R6671 net@2394#1pin@752_polysilicon-1##18 net@2394#1pin@752_polysilicon-1##19 9.85
R6672 net@2394#1pin@752_polysilicon-1##19 net@2394#1pin@752_polysilicon-1##20 9.85
R6673 net@2394#1pin@752_polysilicon-1##20 net@2394#1pin@752_polysilicon-1##21 9.85
R6674 net@2394#1pin@752_polysilicon-1##21 net@2394#1pin@752_polysilicon-1##22 9.85
R6675 net@2394#1pin@752_polysilicon-1##22 net@2394#1pin@752_polysilicon-1##23 9.85
R6676 net@2394#1pin@752_polysilicon-1##23 net@2394#1pin@752_polysilicon-1##24 9.85
R6677 net@2394#1pin@752_polysilicon-1##24 net@2394#1pin@752_polysilicon-1##25 9.85
R6678 net@2394#1pin@752_polysilicon-1##25 net@2394#1pin@752_polysilicon-1##26 9.85
R6679 net@2394#1pin@752_polysilicon-1##26 net@2394#1pin@752_polysilicon-1##27 9.85
R6680 net@2394#1pin@752_polysilicon-1##27 net@2394#1pin@752_polysilicon-1##28 9.85
R6681 net@2394#1pin@752_polysilicon-1##28 net@2394#1pin@752_polysilicon-1##29 9.85
R6682 net@2394#1pin@752_polysilicon-1##29 net@2394#1pin@752_polysilicon-1##30 9.85
R6683 net@2394#1pin@752_polysilicon-1##30 net@2394#1pin@752_polysilicon-1##31 9.85
R6684 net@2394#1pin@752_polysilicon-1##31 net@2394#1pin@752_polysilicon-1##32 9.85
R6685 net@2394#1pin@752_polysilicon-1##32 net@2394#1pin@752_polysilicon-1##33 9.85
R6686 net@2394#1pin@752_polysilicon-1##33 net@2394#1pin@752_polysilicon-1##34 9.85
R6687 net@2394#1pin@752_polysilicon-1##34 net@2394#1pin@752_polysilicon-1##35 9.85
R6688 net@2394#1pin@752_polysilicon-1##35 net@2394#1pin@752_polysilicon-1##36 9.85
R6689 net@2394#1pin@752_polysilicon-1##36 net@2394#1pin@752_polysilicon-1##37 9.85
R6690 net@2394#1pin@752_polysilicon-1##37 net@2394#1pin@752_polysilicon-1##38 9.85
R6691 net@2394#1pin@752_polysilicon-1##38 net@2394#1pin@752_polysilicon-1##39 9.85
R6692 net@2394#1pin@752_polysilicon-1##39 net@2394#1pin@752_polysilicon-1##40 9.85
R6693 net@2394#1pin@752_polysilicon-1##40 net@2394#1pin@752_polysilicon-1##41 9.85
R6694 net@2394#1pin@752_polysilicon-1##41 net@2394#1pin@752_polysilicon-1##42 9.85
R6695 net@2394#1pin@752_polysilicon-1##42 net@2394#1pin@752_polysilicon-1##43 9.85
R6696 net@2394#1pin@752_polysilicon-1##43 net@2394#1pin@752_polysilicon-1##44 9.85
R6697 net@2394#1pin@752_polysilicon-1##44 net@2394#1pin@752_polysilicon-1##45 9.85
R6698 net@2394#1pin@752_polysilicon-1##45 net@2394#1pin@752_polysilicon-1##46 9.85
R6699 net@2394#1pin@752_polysilicon-1##46 net@2394#1pin@752_polysilicon-1##47 9.85
R6700 net@2394#1pin@752_polysilicon-1##47 net@2394#1pin@752_polysilicon-1##48 9.85
R6701 net@2394#1pin@752_polysilicon-1##48 net@2394#1pin@752_polysilicon-1##49 9.85
R6702 net@2394#1pin@752_polysilicon-1##49 net@2394#1pin@752_polysilicon-1##50 9.85
R6703 net@2394#1pin@752_polysilicon-1##50 net@2394#1pin@752_polysilicon-1##51 9.85
R6704 net@2394#1pin@752_polysilicon-1##51 net@2394#1pin@752_polysilicon-1##52 9.85
R6705 net@2394#1pin@752_polysilicon-1##52 net@2394#1pin@752_polysilicon-1##53 9.85
R6706 net@2394#1pin@752_polysilicon-1##53 net@2394#1pin@752_polysilicon-1##54 9.85
R6707 net@2394#1pin@752_polysilicon-1##54 net@2394#1pin@752_polysilicon-1##55 9.85
R6708 net@2394#1pin@752_polysilicon-1##55 net@2394#1pin@752_polysilicon-1##56 9.85
R6709 net@2394#1pin@752_polysilicon-1##56 net@2394#1pin@752_polysilicon-1##57 9.85
R6710 net@2394#1pin@752_polysilicon-1##57 net@2394#1pin@752_polysilicon-1##58 9.85
R6711 net@2394#1pin@752_polysilicon-1##58 net@2394#1pin@752_polysilicon-1##59 9.85
R6712 net@2394#1pin@752_polysilicon-1##59 net@2394#1pin@752_polysilicon-1##60 9.85
R6713 net@2394#1pin@752_polysilicon-1##60 net@2394#2pin@742_metal-1 9.85
R6714 Cin_to_XOR2___NAND5#26pmos@131_poly-right Cin_to_XOR2___NAND5#26pmos@131_poly-right##0 9.854
R6715 Cin_to_XOR2___NAND5#26pmos@131_poly-right##0 Cin_to_XOR2___NAND5#26pmos@131_poly-right##1 9.854
R6716 Cin_to_XOR2___NAND5#26pmos@131_poly-right##1 Cin_to_XOR2___NAND5#26pmos@131_poly-right##2 9.854
R6717 Cin_to_XOR2___NAND5#26pmos@131_poly-right##2 Cin_to_XOR2___NAND5#26pmos@131_poly-right##3 9.854
R6718 Cin_to_XOR2___NAND5#26pmos@131_poly-right##3 Cin_to_XOR2___NAND5#26pmos@131_poly-right##4 9.854
R6719 Cin_to_XOR2___NAND5#26pmos@131_poly-right##4 Cin_to_XOR2___NAND5#26pmos@131_poly-right##5 9.854
R6720 Cin_to_XOR2___NAND5#26pmos@131_poly-right##5 Cin_to_XOR2___NAND5#26pmos@131_poly-right##6 9.854
R6721 Cin_to_XOR2___NAND5#26pmos@131_poly-right##6 Cin_to_XOR2___NAND5#26pmos@131_poly-right##7 9.854
R6722 Cin_to_XOR2___NAND5#26pmos@131_poly-right##7 Cin_to_XOR2___NAND5#26pmos@131_poly-right##8 9.854
R6723 Cin_to_XOR2___NAND5#26pmos@131_poly-right##8 Cin_to_XOR2___NAND5#26pmos@131_poly-right##9 9.854
R6724 Cin_to_XOR2___NAND5#26pmos@131_poly-right##9 Cin_to_XOR2___NAND5#26pmos@131_poly-right##10 9.854
R6725 Cin_to_XOR2___NAND5#26pmos@131_poly-right##10 Cin_to_XOR2___NAND5#26pmos@131_poly-right##11 9.854
R6726 Cin_to_XOR2___NAND5#26pmos@131_poly-right##11 Cin_to_XOR2___NAND5#26pmos@131_poly-right##12 9.854
R6727 Cin_to_XOR2___NAND5#26pmos@131_poly-right##12 Cin_to_XOR2___NAND5#26pmos@131_poly-right##13 9.854
R6728 Cin_to_XOR2___NAND5#26pmos@131_poly-right##13 Cin_to_XOR2___NAND5#26pmos@131_poly-right##14 9.854
R6729 Cin_to_XOR2___NAND5#26pmos@131_poly-right##14 Cin_to_XOR2___NAND5#26pmos@131_poly-right##15 9.854
R6730 Cin_to_XOR2___NAND5#26pmos@131_poly-right##15 Cin_to_XOR2___NAND5#26pmos@131_poly-right##16 9.854
R6731 Cin_to_XOR2___NAND5#26pmos@131_poly-right##16 Cin_to_XOR2___NAND5#26pmos@131_poly-right##17 9.854
R6732 Cin_to_XOR2___NAND5#26pmos@131_poly-right##17 Cin_to_XOR2___NAND5#26pmos@131_poly-right##18 9.854
R6733 Cin_to_XOR2___NAND5#26pmos@131_poly-right##18 Cin_to_XOR2___NAND5#26pmos@131_poly-right##19 9.854
R6734 Cin_to_XOR2___NAND5#26pmos@131_poly-right##19 Cin_to_XOR2___NAND5#26pmos@131_poly-right##20 9.854
R6735 Cin_to_XOR2___NAND5#26pmos@131_poly-right##20 Cin_to_XOR2___NAND5#26pmos@131_poly-right##21 9.854
R6736 Cin_to_XOR2___NAND5#26pmos@131_poly-right##21 Cin_to_XOR2___NAND5#26pmos@131_poly-right##22 9.854
R6737 Cin_to_XOR2___NAND5#26pmos@131_poly-right##22 Cin_to_XOR2___NAND5#26pmos@131_poly-right##23 9.854
R6738 Cin_to_XOR2___NAND5#26pmos@131_poly-right##23 Cin_to_XOR2___NAND5#26pmos@131_poly-right##24 9.854
R6739 Cin_to_XOR2___NAND5#26pmos@131_poly-right##24 Cin_to_XOR2___NAND5#26pmos@131_poly-right##25 9.854
R6740 Cin_to_XOR2___NAND5#26pmos@131_poly-right##25 Cin_to_XOR2___NAND5#26pmos@131_poly-right##26 9.854
R6741 Cin_to_XOR2___NAND5#26pmos@131_poly-right##26 Cin_to_XOR2___NAND5#26pmos@131_poly-right##27 9.854
R6742 Cin_to_XOR2___NAND5#26pmos@131_poly-right##27 Cin_to_XOR2___NAND5#26pmos@131_poly-right##28 9.854
R6743 Cin_to_XOR2___NAND5#26pmos@131_poly-right##28 Cin_to_XOR2___NAND5#26pmos@131_poly-right##29 9.854
R6744 Cin_to_XOR2___NAND5#26pmos@131_poly-right##29 Cin_to_XOR2___NAND5#26pmos@131_poly-right##30 9.854
R6745 Cin_to_XOR2___NAND5#26pmos@131_poly-right##30 Cin_to_XOR2___NAND5#26pmos@131_poly-right##31 9.854
R6746 Cin_to_XOR2___NAND5#26pmos@131_poly-right##31 Cin_to_XOR2___NAND5#26pmos@131_poly-right##32 9.854
R6747 Cin_to_XOR2___NAND5#26pmos@131_poly-right##32 Cin_to_XOR2___NAND5#26pmos@131_poly-right##33 9.854
R6748 Cin_to_XOR2___NAND5#26pmos@131_poly-right##33 Cin_to_XOR2___NAND5#26pmos@131_poly-right##34 9.854
R6749 Cin_to_XOR2___NAND5#26pmos@131_poly-right##34 Cin_to_XOR2___NAND5#26pmos@131_poly-right##35 9.854
R6750 Cin_to_XOR2___NAND5#26pmos@131_poly-right##35 Cin_to_XOR2___NAND5#26pmos@131_poly-right##36 9.854
R6751 Cin_to_XOR2___NAND5#26pmos@131_poly-right##36 Cin_to_XOR2___NAND5#26pmos@131_poly-right##37 9.854
R6752 Cin_to_XOR2___NAND5#26pmos@131_poly-right##37 Cin_to_XOR2___NAND5#26pmos@131_poly-right##38 9.854
R6753 Cin_to_XOR2___NAND5#26pmos@131_poly-right##38 Cin_to_XOR2___NAND5#26pmos@131_poly-right##39 9.854
R6754 Cin_to_XOR2___NAND5#26pmos@131_poly-right##39 Cin_to_XOR2___NAND5#26pmos@131_poly-right##40 9.854
R6755 Cin_to_XOR2___NAND5#26pmos@131_poly-right##40 Cin_to_XOR2___NAND5#26pmos@131_poly-right##41 9.854
R6756 Cin_to_XOR2___NAND5#26pmos@131_poly-right##41 Cin_to_XOR2___NAND5#26pmos@131_poly-right##42 9.854
R6757 Cin_to_XOR2___NAND5#26pmos@131_poly-right##42 Cin_to_XOR2___NAND5#26pmos@131_poly-right##43 9.854
R6758 Cin_to_XOR2___NAND5#26pmos@131_poly-right##43 Cin_to_XOR2___NAND5#26pmos@131_poly-right##44 9.854
R6759 Cin_to_XOR2___NAND5#26pmos@131_poly-right##44 Cin_to_XOR2___NAND5#26pmos@131_poly-right##45 9.854
R6760 Cin_to_XOR2___NAND5#26pmos@131_poly-right##45 Cin_to_XOR2___NAND5#26pmos@131_poly-right##46 9.854
R6761 Cin_to_XOR2___NAND5#26pmos@131_poly-right##46 Cin_to_XOR2___NAND5#26pmos@131_poly-right##47 9.854
R6762 Cin_to_XOR2___NAND5#26pmos@131_poly-right##47 Cin_to_XOR2___NAND5#26pmos@131_poly-right##48 9.854
R6763 Cin_to_XOR2___NAND5#26pmos@131_poly-right##48 Cin_to_XOR2___NAND5#26pmos@131_poly-right##49 9.854
R6764 Cin_to_XOR2___NAND5#26pmos@131_poly-right##49 Cin_to_XOR2___NAND5#26pmos@131_poly-right##50 9.854
R6765 Cin_to_XOR2___NAND5#26pmos@131_poly-right##50 Cin_to_XOR2___NAND5#26pmos@131_poly-right##51 9.854
R6766 Cin_to_XOR2___NAND5#26pmos@131_poly-right##51 Cin_to_XOR2___NAND5#26pmos@131_poly-right##52 9.854
R6767 Cin_to_XOR2___NAND5#26pmos@131_poly-right##52 Cin_to_XOR2___NAND5#26pmos@131_poly-right##53 9.854
R6768 Cin_to_XOR2___NAND5#26pmos@131_poly-right##53 Cin_to_XOR2___NAND5#26pmos@131_poly-right##54 9.854
R6769 Cin_to_XOR2___NAND5#26pmos@131_poly-right##54 Cin_to_XOR2___NAND5#15pin@743_polysilicon-1 9.854
R6770 net@2404 net@2404#2contact@836_metal-1-metal-2 4.797
R6771 XOR1_to_NAND5#9pmos@127_poly-left XOR1_to_NAND5#9pmos@127_poly-left##0 9.871
R6772 XOR1_to_NAND5#9pmos@127_poly-left##0 XOR1_to_NAND5#9pmos@127_poly-left##1 9.871
R6773 XOR1_to_NAND5#9pmos@127_poly-left##1 XOR1_to_NAND5#9pmos@127_poly-left##2 9.871
R6774 XOR1_to_NAND5#9pmos@127_poly-left##2 XOR1_to_NAND5#9pmos@127_poly-left##3 9.871
R6775 XOR1_to_NAND5#9pmos@127_poly-left##3 XOR1_to_NAND5#9pmos@127_poly-left##4 9.871
R6776 XOR1_to_NAND5#9pmos@127_poly-left##4 XOR1_to_NAND5#9pmos@127_poly-left##5 9.871
R6777 XOR1_to_NAND5#9pmos@127_poly-left##5 XOR1_to_NAND5#9pmos@127_poly-left##6 9.871
R6778 XOR1_to_NAND5#9pmos@127_poly-left##6 XOR1_to_NAND5#9pmos@127_poly-left##7 9.871
R6779 XOR1_to_NAND5#9pmos@127_poly-left##7 XOR1_to_NAND5#9pmos@127_poly-left##8 9.871
R6780 XOR1_to_NAND5#9pmos@127_poly-left##8 XOR1_to_NAND5#9pmos@127_poly-left##9 9.871
R6781 XOR1_to_NAND5#9pmos@127_poly-left##9 XOR1_to_NAND5#9pmos@127_poly-left##10 9.871
R6782 XOR1_to_NAND5#9pmos@127_poly-left##10 XOR1_to_NAND5#9pmos@127_poly-left##11 9.871
R6783 XOR1_to_NAND5#9pmos@127_poly-left##11 XOR1_to_NAND5#9pmos@127_poly-left##12 9.871
R6784 XOR1_to_NAND5#9pmos@127_poly-left##12 XOR1_to_NAND5#9pmos@127_poly-left##13 9.871
R6785 XOR1_to_NAND5#9pmos@127_poly-left##13 XOR1_to_NAND5#9pmos@127_poly-left##14 9.871
R6786 XOR1_to_NAND5#9pmos@127_poly-left##14 XOR1_to_NAND5#9pmos@127_poly-left##15 9.871
R6787 XOR1_to_NAND5#9pmos@127_poly-left##15 XOR1_to_NAND5#9pmos@127_poly-left##16 9.871
R6788 XOR1_to_NAND5#9pmos@127_poly-left##16 XOR1_to_NAND5#9pmos@127_poly-left##17 9.871
R6789 XOR1_to_NAND5#9pmos@127_poly-left##17 XOR1_to_NAND5#9pmos@127_poly-left##18 9.871
R6790 XOR1_to_NAND5#9pmos@127_poly-left##18 XOR1_to_NAND5#9pmos@127_poly-left##19 9.871
R6791 XOR1_to_NAND5#9pmos@127_poly-left##19 XOR1_to_NAND5#9pmos@127_poly-left##20 9.871
R6792 XOR1_to_NAND5#9pmos@127_poly-left##20 XOR1_to_NAND5#9pmos@127_poly-left##21 9.871
R6793 XOR1_to_NAND5#9pmos@127_poly-left##21 XOR1_to_NAND5#9pmos@127_poly-left##22 9.871
R6794 XOR1_to_NAND5#9pmos@127_poly-left##22 XOR1_to_NAND5#9pmos@127_poly-left##23 9.871
R6795 XOR1_to_NAND5#9pmos@127_poly-left##23 XOR1_to_NAND5#9pmos@127_poly-left##24 9.871
R6796 XOR1_to_NAND5#9pmos@127_poly-left##24 XOR1_to_NAND5#9pmos@127_poly-left##25 9.871
R6797 XOR1_to_NAND5#9pmos@127_poly-left##25 XOR1_to_NAND5#9pmos@127_poly-left##26 9.871
R6798 XOR1_to_NAND5#9pmos@127_poly-left##26 XOR1_to_NAND5#9pmos@127_poly-left##27 9.871
R6799 XOR1_to_NAND5#9pmos@127_poly-left##27 XOR1_to_NAND5#9pmos@127_poly-left##28 9.871
R6800 XOR1_to_NAND5#9pmos@127_poly-left##28 XOR1_to_NAND5#9pmos@127_poly-left##29 9.871
R6801 XOR1_to_NAND5#9pmos@127_poly-left##29 XOR1_to_NAND5#9pmos@127_poly-left##30 9.871
R6802 XOR1_to_NAND5#9pmos@127_poly-left##30 XOR1_to_NAND5#9pmos@127_poly-left##31 9.871
R6803 XOR1_to_NAND5#9pmos@127_poly-left##31 XOR1_to_NAND5#9pmos@127_poly-left##32 9.871
R6804 XOR1_to_NAND5#9pmos@127_poly-left##32 XOR1_to_NAND5#9pmos@127_poly-left##33 9.871
R6805 XOR1_to_NAND5#9pmos@127_poly-left##33 XOR1_to_NAND5#9pmos@127_poly-left##34 9.871
R6806 XOR1_to_NAND5#9pmos@127_poly-left##34 XOR1_to_NAND5#9pmos@127_poly-left##35 9.871
R6807 XOR1_to_NAND5#9pmos@127_poly-left##35 XOR1_to_NAND5#9pmos@127_poly-left##36 9.871
R6808 XOR1_to_NAND5#9pmos@127_poly-left##36 XOR1_to_NAND5#9pmos@127_poly-left##37 9.871
R6809 XOR1_to_NAND5#9pmos@127_poly-left##37 XOR1_to_NAND5#9pmos@127_poly-left##38 9.871
R6810 XOR1_to_NAND5#9pmos@127_poly-left##38 XOR1_to_NAND5#9pmos@127_poly-left##39 9.871
R6811 XOR1_to_NAND5#9pmos@127_poly-left##39 XOR1_to_NAND5#9pmos@127_poly-left##40 9.871
R6812 XOR1_to_NAND5#9pmos@127_poly-left##40 XOR1_to_NAND5#9pmos@127_poly-left##41 9.871
R6813 XOR1_to_NAND5#9pmos@127_poly-left##41 XOR1_to_NAND5#9pmos@127_poly-left##42 9.871
R6814 XOR1_to_NAND5#9pmos@127_poly-left##42 XOR1_to_NAND5#9pmos@127_poly-left##43 9.871
R6815 XOR1_to_NAND5#9pmos@127_poly-left##43 XOR1_to_NAND5#9pmos@127_poly-left##44 9.871
R6816 XOR1_to_NAND5#9pmos@127_poly-left##44 XOR1_to_NAND5#9pmos@127_poly-left##45 9.871
R6817 XOR1_to_NAND5#9pmos@127_poly-left##45 XOR1_to_NAND5#9pmos@127_poly-left##46 9.871
R6818 XOR1_to_NAND5#9pmos@127_poly-left##46 XOR1_to_NAND5#9pmos@127_poly-left##47 9.871
R6819 XOR1_to_NAND5#9pmos@127_poly-left##47 XOR1_to_NAND5#9pmos@127_poly-left##48 9.871
R6820 XOR1_to_NAND5#9pmos@127_poly-left##48 XOR1_to_NAND5#9pmos@127_poly-left##49 9.871
R6821 XOR1_to_NAND5#9pmos@127_poly-left##49 XOR1_to_NAND5#9pmos@127_poly-left##50 9.871
R6822 XOR1_to_NAND5#9pmos@127_poly-left##50 XOR1_to_NAND5#9pmos@127_poly-left##51 9.871
R6823 XOR1_to_NAND5#9pmos@127_poly-left##51 XOR1_to_NAND5#9pmos@127_poly-left##52 9.871
R6824 XOR1_to_NAND5#9pmos@127_poly-left##52 XOR1_to_NAND5#9pmos@127_poly-left##53 9.871
R6825 XOR1_to_NAND5#9pmos@127_poly-left##53 XOR1_to_NAND5#9pmos@127_poly-left##54 9.871
R6826 XOR1_to_NAND5#9pmos@127_poly-left##54 XOR1_to_NAND5#9pmos@127_poly-left##55 9.871
R6827 XOR1_to_NAND5#9pmos@127_poly-left##55 XOR1_to_NAND5#26nmos@127_poly-right 9.871
R6828 net@2394#7pmos@128_poly-left net@2394#7pmos@128_poly-left##0 9.871
R6829 net@2394#7pmos@128_poly-left##0 net@2394#7pmos@128_poly-left##1 9.871
R6830 net@2394#7pmos@128_poly-left##1 net@2394#7pmos@128_poly-left##2 9.871
R6831 net@2394#7pmos@128_poly-left##2 net@2394#7pmos@128_poly-left##3 9.871
R6832 net@2394#7pmos@128_poly-left##3 net@2394#7pmos@128_poly-left##4 9.871
R6833 net@2394#7pmos@128_poly-left##4 net@2394#7pmos@128_poly-left##5 9.871
R6834 net@2394#7pmos@128_poly-left##5 net@2394#7pmos@128_poly-left##6 9.871
R6835 net@2394#7pmos@128_poly-left##6 net@2394#7pmos@128_poly-left##7 9.871
R6836 net@2394#7pmos@128_poly-left##7 net@2394#7pmos@128_poly-left##8 9.871
R6837 net@2394#7pmos@128_poly-left##8 net@2394#7pmos@128_poly-left##9 9.871
R6838 net@2394#7pmos@128_poly-left##9 net@2394#7pmos@128_poly-left##10 9.871
R6839 net@2394#7pmos@128_poly-left##10 net@2394#7pmos@128_poly-left##11 9.871
R6840 net@2394#7pmos@128_poly-left##11 net@2394#7pmos@128_poly-left##12 9.871
R6841 net@2394#7pmos@128_poly-left##12 net@2394#7pmos@128_poly-left##13 9.871
R6842 net@2394#7pmos@128_poly-left##13 net@2394#7pmos@128_poly-left##14 9.871
R6843 net@2394#7pmos@128_poly-left##14 net@2394#7pmos@128_poly-left##15 9.871
R6844 net@2394#7pmos@128_poly-left##15 net@2394#7pmos@128_poly-left##16 9.871
R6845 net@2394#7pmos@128_poly-left##16 net@2394#7pmos@128_poly-left##17 9.871
R6846 net@2394#7pmos@128_poly-left##17 net@2394#7pmos@128_poly-left##18 9.871
R6847 net@2394#7pmos@128_poly-left##18 net@2394#7pmos@128_poly-left##19 9.871
R6848 net@2394#7pmos@128_poly-left##19 net@2394#7pmos@128_poly-left##20 9.871
R6849 net@2394#7pmos@128_poly-left##20 net@2394#7pmos@128_poly-left##21 9.871
R6850 net@2394#7pmos@128_poly-left##21 net@2394#7pmos@128_poly-left##22 9.871
R6851 net@2394#7pmos@128_poly-left##22 net@2394#7pmos@128_poly-left##23 9.871
R6852 net@2394#7pmos@128_poly-left##23 net@2394#7pmos@128_poly-left##24 9.871
R6853 net@2394#7pmos@128_poly-left##24 net@2394#7pmos@128_poly-left##25 9.871
R6854 net@2394#7pmos@128_poly-left##25 net@2394#7pmos@128_poly-left##26 9.871
R6855 net@2394#7pmos@128_poly-left##26 net@2394#7pmos@128_poly-left##27 9.871
R6856 net@2394#7pmos@128_poly-left##27 net@2394#7pmos@128_poly-left##28 9.871
R6857 net@2394#7pmos@128_poly-left##28 net@2394#7pmos@128_poly-left##29 9.871
R6858 net@2394#7pmos@128_poly-left##29 net@2394#7pmos@128_poly-left##30 9.871
R6859 net@2394#7pmos@128_poly-left##30 net@2394#7pmos@128_poly-left##31 9.871
R6860 net@2394#7pmos@128_poly-left##31 net@2394#7pmos@128_poly-left##32 9.871
R6861 net@2394#7pmos@128_poly-left##32 net@2394#7pmos@128_poly-left##33 9.871
R6862 net@2394#7pmos@128_poly-left##33 net@2394#7pmos@128_poly-left##34 9.871
R6863 net@2394#7pmos@128_poly-left##34 net@2394#7pmos@128_poly-left##35 9.871
R6864 net@2394#7pmos@128_poly-left##35 net@2394#7pmos@128_poly-left##36 9.871
R6865 net@2394#7pmos@128_poly-left##36 net@2394#7pmos@128_poly-left##37 9.871
R6866 net@2394#7pmos@128_poly-left##37 net@2394#7pmos@128_poly-left##38 9.871
R6867 net@2394#7pmos@128_poly-left##38 net@2394#7pmos@128_poly-left##39 9.871
R6868 net@2394#7pmos@128_poly-left##39 net@2394#7pmos@128_poly-left##40 9.871
R6869 net@2394#7pmos@128_poly-left##40 net@2394#7pmos@128_poly-left##41 9.871
R6870 net@2394#7pmos@128_poly-left##41 net@2394#7pmos@128_poly-left##42 9.871
R6871 net@2394#7pmos@128_poly-left##42 net@2394#7pmos@128_poly-left##43 9.871
R6872 net@2394#7pmos@128_poly-left##43 net@2394#7pmos@128_poly-left##44 9.871
R6873 net@2394#7pmos@128_poly-left##44 net@2394#7pmos@128_poly-left##45 9.871
R6874 net@2394#7pmos@128_poly-left##45 net@2394#7pmos@128_poly-left##46 9.871
R6875 net@2394#7pmos@128_poly-left##46 net@2394#7pmos@128_poly-left##47 9.871
R6876 net@2394#7pmos@128_poly-left##47 net@2394#7pmos@128_poly-left##48 9.871
R6877 net@2394#7pmos@128_poly-left##48 net@2394#7pmos@128_poly-left##49 9.871
R6878 net@2394#7pmos@128_poly-left##49 net@2394#7pmos@128_poly-left##50 9.871
R6879 net@2394#7pmos@128_poly-left##50 net@2394#7pmos@128_poly-left##51 9.871
R6880 net@2394#7pmos@128_poly-left##51 net@2394#7pmos@128_poly-left##52 9.871
R6881 net@2394#7pmos@128_poly-left##52 net@2394#7pmos@128_poly-left##53 9.871
R6882 net@2394#7pmos@128_poly-left##53 net@2394#7pmos@128_poly-left##54 9.871
R6883 net@2394#7pmos@128_poly-left##54 net@2394#7pmos@128_poly-left##55 9.871
R6884 net@2394#7pmos@128_poly-left##55 net@2394#11nmos@128_poly-right 9.871
R6885 Cin_to_XOR2___NAND5#27pmos@129_poly-right Cin_to_XOR2___NAND5#27pmos@129_poly-right##0 9.871
R6886 Cin_to_XOR2___NAND5#27pmos@129_poly-right##0 Cin_to_XOR2___NAND5#27pmos@129_poly-right##1 9.871
R6887 Cin_to_XOR2___NAND5#27pmos@129_poly-right##1 Cin_to_XOR2___NAND5#27pmos@129_poly-right##2 9.871
R6888 Cin_to_XOR2___NAND5#27pmos@129_poly-right##2 Cin_to_XOR2___NAND5#27pmos@129_poly-right##3 9.871
R6889 Cin_to_XOR2___NAND5#27pmos@129_poly-right##3 Cin_to_XOR2___NAND5#27pmos@129_poly-right##4 9.871
R6890 Cin_to_XOR2___NAND5#27pmos@129_poly-right##4 Cin_to_XOR2___NAND5#27pmos@129_poly-right##5 9.871
R6891 Cin_to_XOR2___NAND5#27pmos@129_poly-right##5 Cin_to_XOR2___NAND5#27pmos@129_poly-right##6 9.871
R6892 Cin_to_XOR2___NAND5#27pmos@129_poly-right##6 Cin_to_XOR2___NAND5#27pmos@129_poly-right##7 9.871
R6893 Cin_to_XOR2___NAND5#27pmos@129_poly-right##7 Cin_to_XOR2___NAND5#27pmos@129_poly-right##8 9.871
R6894 Cin_to_XOR2___NAND5#27pmos@129_poly-right##8 Cin_to_XOR2___NAND5#27pmos@129_poly-right##9 9.871
R6895 Cin_to_XOR2___NAND5#27pmos@129_poly-right##9 Cin_to_XOR2___NAND5#27pmos@129_poly-right##10 9.871
R6896 Cin_to_XOR2___NAND5#27pmos@129_poly-right##10 Cin_to_XOR2___NAND5#27pmos@129_poly-right##11 9.871
R6897 Cin_to_XOR2___NAND5#27pmos@129_poly-right##11 Cin_to_XOR2___NAND5#27pmos@129_poly-right##12 9.871
R6898 Cin_to_XOR2___NAND5#27pmos@129_poly-right##12 Cin_to_XOR2___NAND5#27pmos@129_poly-right##13 9.871
R6899 Cin_to_XOR2___NAND5#27pmos@129_poly-right##13 Cin_to_XOR2___NAND5#27pmos@129_poly-right##14 9.871
R6900 Cin_to_XOR2___NAND5#27pmos@129_poly-right##14 Cin_to_XOR2___NAND5#27pmos@129_poly-right##15 9.871
R6901 Cin_to_XOR2___NAND5#27pmos@129_poly-right##15 Cin_to_XOR2___NAND5#27pmos@129_poly-right##16 9.871
R6902 Cin_to_XOR2___NAND5#27pmos@129_poly-right##16 Cin_to_XOR2___NAND5#27pmos@129_poly-right##17 9.871
R6903 Cin_to_XOR2___NAND5#27pmos@129_poly-right##17 Cin_to_XOR2___NAND5#27pmos@129_poly-right##18 9.871
R6904 Cin_to_XOR2___NAND5#27pmos@129_poly-right##18 Cin_to_XOR2___NAND5#27pmos@129_poly-right##19 9.871
R6905 Cin_to_XOR2___NAND5#27pmos@129_poly-right##19 Cin_to_XOR2___NAND5#27pmos@129_poly-right##20 9.871
R6906 Cin_to_XOR2___NAND5#27pmos@129_poly-right##20 Cin_to_XOR2___NAND5#27pmos@129_poly-right##21 9.871
R6907 Cin_to_XOR2___NAND5#27pmos@129_poly-right##21 Cin_to_XOR2___NAND5#27pmos@129_poly-right##22 9.871
R6908 Cin_to_XOR2___NAND5#27pmos@129_poly-right##22 Cin_to_XOR2___NAND5#27pmos@129_poly-right##23 9.871
R6909 Cin_to_XOR2___NAND5#27pmos@129_poly-right##23 Cin_to_XOR2___NAND5#27pmos@129_poly-right##24 9.871
R6910 Cin_to_XOR2___NAND5#27pmos@129_poly-right##24 Cin_to_XOR2___NAND5#27pmos@129_poly-right##25 9.871
R6911 Cin_to_XOR2___NAND5#27pmos@129_poly-right##25 Cin_to_XOR2___NAND5#27pmos@129_poly-right##26 9.871
R6912 Cin_to_XOR2___NAND5#27pmos@129_poly-right##26 Cin_to_XOR2___NAND5#27pmos@129_poly-right##27 9.871
R6913 Cin_to_XOR2___NAND5#27pmos@129_poly-right##27 Cin_to_XOR2___NAND5#27pmos@129_poly-right##28 9.871
R6914 Cin_to_XOR2___NAND5#27pmos@129_poly-right##28 Cin_to_XOR2___NAND5#27pmos@129_poly-right##29 9.871
R6915 Cin_to_XOR2___NAND5#27pmos@129_poly-right##29 Cin_to_XOR2___NAND5#27pmos@129_poly-right##30 9.871
R6916 Cin_to_XOR2___NAND5#27pmos@129_poly-right##30 Cin_to_XOR2___NAND5#27pmos@129_poly-right##31 9.871
R6917 Cin_to_XOR2___NAND5#27pmos@129_poly-right##31 Cin_to_XOR2___NAND5#27pmos@129_poly-right##32 9.871
R6918 Cin_to_XOR2___NAND5#27pmos@129_poly-right##32 Cin_to_XOR2___NAND5#27pmos@129_poly-right##33 9.871
R6919 Cin_to_XOR2___NAND5#27pmos@129_poly-right##33 Cin_to_XOR2___NAND5#27pmos@129_poly-right##34 9.871
R6920 Cin_to_XOR2___NAND5#27pmos@129_poly-right##34 Cin_to_XOR2___NAND5#27pmos@129_poly-right##35 9.871
R6921 Cin_to_XOR2___NAND5#27pmos@129_poly-right##35 Cin_to_XOR2___NAND5#27pmos@129_poly-right##36 9.871
R6922 Cin_to_XOR2___NAND5#27pmos@129_poly-right##36 Cin_to_XOR2___NAND5#27pmos@129_poly-right##37 9.871
R6923 Cin_to_XOR2___NAND5#27pmos@129_poly-right##37 Cin_to_XOR2___NAND5#27pmos@129_poly-right##38 9.871
R6924 Cin_to_XOR2___NAND5#27pmos@129_poly-right##38 Cin_to_XOR2___NAND5#27pmos@129_poly-right##39 9.871
R6925 Cin_to_XOR2___NAND5#27pmos@129_poly-right##39 Cin_to_XOR2___NAND5#27pmos@129_poly-right##40 9.871
R6926 Cin_to_XOR2___NAND5#27pmos@129_poly-right##40 Cin_to_XOR2___NAND5#27pmos@129_poly-right##41 9.871
R6927 Cin_to_XOR2___NAND5#27pmos@129_poly-right##41 Cin_to_XOR2___NAND5#27pmos@129_poly-right##42 9.871
R6928 Cin_to_XOR2___NAND5#27pmos@129_poly-right##42 Cin_to_XOR2___NAND5#27pmos@129_poly-right##43 9.871
R6929 Cin_to_XOR2___NAND5#27pmos@129_poly-right##43 Cin_to_XOR2___NAND5#27pmos@129_poly-right##44 9.871
R6930 Cin_to_XOR2___NAND5#27pmos@129_poly-right##44 Cin_to_XOR2___NAND5#27pmos@129_poly-right##45 9.871
R6931 Cin_to_XOR2___NAND5#27pmos@129_poly-right##45 Cin_to_XOR2___NAND5#27pmos@129_poly-right##46 9.871
R6932 Cin_to_XOR2___NAND5#27pmos@129_poly-right##46 Cin_to_XOR2___NAND5#27pmos@129_poly-right##47 9.871
R6933 Cin_to_XOR2___NAND5#27pmos@129_poly-right##47 Cin_to_XOR2___NAND5#27pmos@129_poly-right##48 9.871
R6934 Cin_to_XOR2___NAND5#27pmos@129_poly-right##48 Cin_to_XOR2___NAND5#27pmos@129_poly-right##49 9.871
R6935 Cin_to_XOR2___NAND5#27pmos@129_poly-right##49 Cin_to_XOR2___NAND5#27pmos@129_poly-right##50 9.871
R6936 Cin_to_XOR2___NAND5#27pmos@129_poly-right##50 Cin_to_XOR2___NAND5#27pmos@129_poly-right##51 9.871
R6937 Cin_to_XOR2___NAND5#27pmos@129_poly-right##51 Cin_to_XOR2___NAND5#27pmos@129_poly-right##52 9.871
R6938 Cin_to_XOR2___NAND5#27pmos@129_poly-right##52 Cin_to_XOR2___NAND5#27pmos@129_poly-right##53 9.871
R6939 Cin_to_XOR2___NAND5#27pmos@129_poly-right##53 Cin_to_XOR2___NAND5#27pmos@129_poly-right##54 9.871
R6940 Cin_to_XOR2___NAND5#27pmos@129_poly-right##54 Cin_to_XOR2___NAND5#27pmos@129_poly-right##55 9.871
R6941 Cin_to_XOR2___NAND5#27pmos@129_poly-right##55 Cin_to_XOR2___NAND5#18nmos@129_poly-left 9.871
R6942 net@2404#14pmos@130_poly-right net@2404#14pmos@130_poly-right##0 9.871
R6943 net@2404#14pmos@130_poly-right##0 net@2404#14pmos@130_poly-right##1 9.871
R6944 net@2404#14pmos@130_poly-right##1 net@2404#14pmos@130_poly-right##2 9.871
R6945 net@2404#14pmos@130_poly-right##2 net@2404#14pmos@130_poly-right##3 9.871
R6946 net@2404#14pmos@130_poly-right##3 net@2404#14pmos@130_poly-right##4 9.871
R6947 net@2404#14pmos@130_poly-right##4 net@2404#14pmos@130_poly-right##5 9.871
R6948 net@2404#14pmos@130_poly-right##5 net@2404#14pmos@130_poly-right##6 9.871
R6949 net@2404#14pmos@130_poly-right##6 net@2404#14pmos@130_poly-right##7 9.871
R6950 net@2404#14pmos@130_poly-right##7 net@2404#14pmos@130_poly-right##8 9.871
R6951 net@2404#14pmos@130_poly-right##8 net@2404#14pmos@130_poly-right##9 9.871
R6952 net@2404#14pmos@130_poly-right##9 net@2404#14pmos@130_poly-right##10 9.871
R6953 net@2404#14pmos@130_poly-right##10 net@2404#14pmos@130_poly-right##11 9.871
R6954 net@2404#14pmos@130_poly-right##11 net@2404#14pmos@130_poly-right##12 9.871
R6955 net@2404#14pmos@130_poly-right##12 net@2404#14pmos@130_poly-right##13 9.871
R6956 net@2404#14pmos@130_poly-right##13 net@2404#14pmos@130_poly-right##14 9.871
R6957 net@2404#14pmos@130_poly-right##14 net@2404#14pmos@130_poly-right##15 9.871
R6958 net@2404#14pmos@130_poly-right##15 net@2404#14pmos@130_poly-right##16 9.871
R6959 net@2404#14pmos@130_poly-right##16 net@2404#14pmos@130_poly-right##17 9.871
R6960 net@2404#14pmos@130_poly-right##17 net@2404#14pmos@130_poly-right##18 9.871
R6961 net@2404#14pmos@130_poly-right##18 net@2404#14pmos@130_poly-right##19 9.871
R6962 net@2404#14pmos@130_poly-right##19 net@2404#14pmos@130_poly-right##20 9.871
R6963 net@2404#14pmos@130_poly-right##20 net@2404#14pmos@130_poly-right##21 9.871
R6964 net@2404#14pmos@130_poly-right##21 net@2404#14pmos@130_poly-right##22 9.871
R6965 net@2404#14pmos@130_poly-right##22 net@2404#14pmos@130_poly-right##23 9.871
R6966 net@2404#14pmos@130_poly-right##23 net@2404#14pmos@130_poly-right##24 9.871
R6967 net@2404#14pmos@130_poly-right##24 net@2404#14pmos@130_poly-right##25 9.871
R6968 net@2404#14pmos@130_poly-right##25 net@2404#14pmos@130_poly-right##26 9.871
R6969 net@2404#14pmos@130_poly-right##26 net@2404#14pmos@130_poly-right##27 9.871
R6970 net@2404#14pmos@130_poly-right##27 net@2404#14pmos@130_poly-right##28 9.871
R6971 net@2404#14pmos@130_poly-right##28 net@2404#14pmos@130_poly-right##29 9.871
R6972 net@2404#14pmos@130_poly-right##29 net@2404#14pmos@130_poly-right##30 9.871
R6973 net@2404#14pmos@130_poly-right##30 net@2404#14pmos@130_poly-right##31 9.871
R6974 net@2404#14pmos@130_poly-right##31 net@2404#14pmos@130_poly-right##32 9.871
R6975 net@2404#14pmos@130_poly-right##32 net@2404#14pmos@130_poly-right##33 9.871
R6976 net@2404#14pmos@130_poly-right##33 net@2404#14pmos@130_poly-right##34 9.871
R6977 net@2404#14pmos@130_poly-right##34 net@2404#14pmos@130_poly-right##35 9.871
R6978 net@2404#14pmos@130_poly-right##35 net@2404#14pmos@130_poly-right##36 9.871
R6979 net@2404#14pmos@130_poly-right##36 net@2404#14pmos@130_poly-right##37 9.871
R6980 net@2404#14pmos@130_poly-right##37 net@2404#14pmos@130_poly-right##38 9.871
R6981 net@2404#14pmos@130_poly-right##38 net@2404#14pmos@130_poly-right##39 9.871
R6982 net@2404#14pmos@130_poly-right##39 net@2404#14pmos@130_poly-right##40 9.871
R6983 net@2404#14pmos@130_poly-right##40 net@2404#14pmos@130_poly-right##41 9.871
R6984 net@2404#14pmos@130_poly-right##41 net@2404#14pmos@130_poly-right##42 9.871
R6985 net@2404#14pmos@130_poly-right##42 net@2404#14pmos@130_poly-right##43 9.871
R6986 net@2404#14pmos@130_poly-right##43 net@2404#14pmos@130_poly-right##44 9.871
R6987 net@2404#14pmos@130_poly-right##44 net@2404#14pmos@130_poly-right##45 9.871
R6988 net@2404#14pmos@130_poly-right##45 net@2404#14pmos@130_poly-right##46 9.871
R6989 net@2404#14pmos@130_poly-right##46 net@2404#14pmos@130_poly-right##47 9.871
R6990 net@2404#14pmos@130_poly-right##47 net@2404#14pmos@130_poly-right##48 9.871
R6991 net@2404#14pmos@130_poly-right##48 net@2404#14pmos@130_poly-right##49 9.871
R6992 net@2404#14pmos@130_poly-right##49 net@2404#14pmos@130_poly-right##50 9.871
R6993 net@2404#14pmos@130_poly-right##50 net@2404#14pmos@130_poly-right##51 9.871
R6994 net@2404#14pmos@130_poly-right##51 net@2404#14pmos@130_poly-right##52 9.871
R6995 net@2404#14pmos@130_poly-right##52 net@2404#14pmos@130_poly-right##53 9.871
R6996 net@2404#14pmos@130_poly-right##53 net@2404#14pmos@130_poly-right##54 9.871
R6997 net@2404#14pmos@130_poly-right##54 net@2404#14pmos@130_poly-right##55 9.871
R6998 net@2404#14pmos@130_poly-right##55 net@2404#9nmos@130_poly-left 9.871
R6999 net@2403#2contact@861_metal-1-polysilicon-1 net@2403 4.654
R7000 net@2403#12pmos@133_poly-right net@2403#12pmos@133_poly-right##0 9.931
R7001 net@2403#12pmos@133_poly-right##0 net@2403#12pmos@133_poly-right##1 9.931
R7002 net@2403#12pmos@133_poly-right##1 net@2403#12pmos@133_poly-right##2 9.931
R7003 net@2403#12pmos@133_poly-right##2 net@2403#12pmos@133_poly-right##3 9.931
R7004 net@2403#12pmos@133_poly-right##3 net@2403#12pmos@133_poly-right##4 9.931
R7005 net@2403#12pmos@133_poly-right##4 net@2403#12pmos@133_poly-right##5 9.931
R7006 net@2403#12pmos@133_poly-right##5 net@2403#12pmos@133_poly-right##6 9.931
R7007 net@2403#12pmos@133_poly-right##6 net@2403#12pmos@133_poly-right##7 9.931
R7008 net@2403#12pmos@133_poly-right##7 net@2403#12pmos@133_poly-right##8 9.931
R7009 net@2403#12pmos@133_poly-right##8 net@2403#12pmos@133_poly-right##9 9.931
R7010 net@2403#12pmos@133_poly-right##9 net@2403#12pmos@133_poly-right##10 9.931
R7011 net@2403#12pmos@133_poly-right##10 net@2403#12pmos@133_poly-right##11 9.931
R7012 net@2403#12pmos@133_poly-right##11 net@2403#12pmos@133_poly-right##12 9.931
R7013 net@2403#12pmos@133_poly-right##12 net@2403#12pmos@133_poly-right##13 9.931
R7014 net@2403#12pmos@133_poly-right##13 net@2403#12pmos@133_poly-right##14 9.931
R7015 net@2403#12pmos@133_poly-right##14 net@2403#12pmos@133_poly-right##15 9.931
R7016 net@2403#12pmos@133_poly-right##15 net@2403#12pmos@133_poly-right##16 9.931
R7017 net@2403#12pmos@133_poly-right##16 net@2403#12pmos@133_poly-right##17 9.931
R7018 net@2403#12pmos@133_poly-right##17 net@2403#12pmos@133_poly-right##18 9.931
R7019 net@2403#12pmos@133_poly-right##18 net@2403#12pmos@133_poly-right##19 9.931
R7020 net@2403#12pmos@133_poly-right##19 net@2403#12pmos@133_poly-right##20 9.931
R7021 net@2403#12pmos@133_poly-right##20 net@2403#12pmos@133_poly-right##21 9.931
R7022 net@2403#12pmos@133_poly-right##21 net@2403#12pmos@133_poly-right##22 9.931
R7023 net@2403#12pmos@133_poly-right##22 net@2403#12pmos@133_poly-right##23 9.931
R7024 net@2403#12pmos@133_poly-right##23 net@2403#12pmos@133_poly-right##24 9.931
R7025 net@2403#12pmos@133_poly-right##24 net@2403#12pmos@133_poly-right##25 9.931
R7026 net@2403#12pmos@133_poly-right##25 net@2403#12pmos@133_poly-right##26 9.931
R7027 net@2403#12pmos@133_poly-right##26 net@2403#12pmos@133_poly-right##27 9.931
R7028 net@2403#12pmos@133_poly-right##27 net@2403#12pmos@133_poly-right##28 9.931
R7029 net@2403#12pmos@133_poly-right##28 net@2403#12pmos@133_poly-right##29 9.931
R7030 net@2403#12pmos@133_poly-right##29 net@2403#12pmos@133_poly-right##30 9.931
R7031 net@2403#12pmos@133_poly-right##30 net@2403#12pmos@133_poly-right##31 9.931
R7032 net@2403#12pmos@133_poly-right##31 net@2403#12pmos@133_poly-right##32 9.931
R7033 net@2403#12pmos@133_poly-right##32 net@2403#12pmos@133_poly-right##33 9.931
R7034 net@2403#12pmos@133_poly-right##33 net@2403#12pmos@133_poly-right##34 9.931
R7035 net@2403#12pmos@133_poly-right##34 net@2403#12pmos@133_poly-right##35 9.931
R7036 net@2403#12pmos@133_poly-right##35 net@2403#12pmos@133_poly-right##36 9.931
R7037 net@2403#12pmos@133_poly-right##36 net@2403#12pmos@133_poly-right##37 9.931
R7038 net@2403#12pmos@133_poly-right##37 net@2403#12pmos@133_poly-right##38 9.931
R7039 net@2403#12pmos@133_poly-right##38 net@2403#12pmos@133_poly-right##39 9.931
R7040 net@2403#12pmos@133_poly-right##39 net@2403#12pmos@133_poly-right##40 9.931
R7041 net@2403#12pmos@133_poly-right##40 net@2403#12pmos@133_poly-right##41 9.931
R7042 net@2403#12pmos@133_poly-right##41 net@2403#12pmos@133_poly-right##42 9.931
R7043 net@2403#12pmos@133_poly-right##42 net@2403#12pmos@133_poly-right##43 9.931
R7044 net@2403#12pmos@133_poly-right##43 net@2403#12pmos@133_poly-right##44 9.931
R7045 net@2403#12pmos@133_poly-right##44 net@2403#12pmos@133_poly-right##45 9.931
R7046 net@2403#12pmos@133_poly-right##45 net@2403#12pmos@133_poly-right##46 9.931
R7047 net@2403#12pmos@133_poly-right##46 net@2403#12pmos@133_poly-right##47 9.931
R7048 net@2403#12pmos@133_poly-right##47 net@2403#12pmos@133_poly-right##48 9.931
R7049 net@2403#12pmos@133_poly-right##48 net@2403#12pmos@133_poly-right##49 9.931
R7050 net@2403#12pmos@133_poly-right##49 net@2403#12pmos@133_poly-right##50 9.931
R7051 net@2403#12pmos@133_poly-right##50 net@2403#12pmos@133_poly-right##51 9.931
R7052 net@2403#12pmos@133_poly-right##51 net@2403#12pmos@133_poly-right##52 9.931
R7053 net@2403#12pmos@133_poly-right##52 net@2403#5pin@745_polysilicon-1 9.931
R7054 Sum4#4pmos@133_diff-top Sum4 4.823
R7055 XOR1_to_NAND5#14pin@757_polysilicon-1 XOR1_to_NAND5#14pin@757_polysilicon-1##0 9.854
R7056 XOR1_to_NAND5#14pin@757_polysilicon-1##0 XOR1_to_NAND5#14pin@757_polysilicon-1##1 9.854
R7057 XOR1_to_NAND5#14pin@757_polysilicon-1##1 XOR1_to_NAND5#14pin@757_polysilicon-1##2 9.854
R7058 XOR1_to_NAND5#14pin@757_polysilicon-1##2 XOR1_to_NAND5#14pin@757_polysilicon-1##3 9.854
R7059 XOR1_to_NAND5#14pin@757_polysilicon-1##3 XOR1_to_NAND5#14pin@757_polysilicon-1##4 9.854
R7060 XOR1_to_NAND5#14pin@757_polysilicon-1##4 XOR1_to_NAND5#14pin@757_polysilicon-1##5 9.854
R7061 XOR1_to_NAND5#14pin@757_polysilicon-1##5 XOR1_to_NAND5#14pin@757_polysilicon-1##6 9.854
R7062 XOR1_to_NAND5#14pin@757_polysilicon-1##6 XOR1_to_NAND5#14pin@757_polysilicon-1##7 9.854
R7063 XOR1_to_NAND5#14pin@757_polysilicon-1##7 XOR1_to_NAND5#14pin@757_polysilicon-1##8 9.854
R7064 XOR1_to_NAND5#14pin@757_polysilicon-1##8 XOR1_to_NAND5#14pin@757_polysilicon-1##9 9.854
R7065 XOR1_to_NAND5#14pin@757_polysilicon-1##9 XOR1_to_NAND5#14pin@757_polysilicon-1##10 9.854
R7066 XOR1_to_NAND5#14pin@757_polysilicon-1##10 XOR1_to_NAND5#14pin@757_polysilicon-1##11 9.854
R7067 XOR1_to_NAND5#14pin@757_polysilicon-1##11 XOR1_to_NAND5#14pin@757_polysilicon-1##12 9.854
R7068 XOR1_to_NAND5#14pin@757_polysilicon-1##12 XOR1_to_NAND5#14pin@757_polysilicon-1##13 9.854
R7069 XOR1_to_NAND5#14pin@757_polysilicon-1##13 XOR1_to_NAND5#14pin@757_polysilicon-1##14 9.854
R7070 XOR1_to_NAND5#14pin@757_polysilicon-1##14 XOR1_to_NAND5#14pin@757_polysilicon-1##15 9.854
R7071 XOR1_to_NAND5#14pin@757_polysilicon-1##15 XOR1_to_NAND5#14pin@757_polysilicon-1##16 9.854
R7072 XOR1_to_NAND5#14pin@757_polysilicon-1##16 XOR1_to_NAND5#14pin@757_polysilicon-1##17 9.854
R7073 XOR1_to_NAND5#14pin@757_polysilicon-1##17 XOR1_to_NAND5#14pin@757_polysilicon-1##18 9.854
R7074 XOR1_to_NAND5#14pin@757_polysilicon-1##18 XOR1_to_NAND5#14pin@757_polysilicon-1##19 9.854
R7075 XOR1_to_NAND5#14pin@757_polysilicon-1##19 XOR1_to_NAND5#14pin@757_polysilicon-1##20 9.854
R7076 XOR1_to_NAND5#14pin@757_polysilicon-1##20 XOR1_to_NAND5#14pin@757_polysilicon-1##21 9.854
R7077 XOR1_to_NAND5#14pin@757_polysilicon-1##21 XOR1_to_NAND5#14pin@757_polysilicon-1##22 9.854
R7078 XOR1_to_NAND5#14pin@757_polysilicon-1##22 XOR1_to_NAND5#14pin@757_polysilicon-1##23 9.854
R7079 XOR1_to_NAND5#14pin@757_polysilicon-1##23 XOR1_to_NAND5#14pin@757_polysilicon-1##24 9.854
R7080 XOR1_to_NAND5#14pin@757_polysilicon-1##24 XOR1_to_NAND5#14pin@757_polysilicon-1##25 9.854
R7081 XOR1_to_NAND5#14pin@757_polysilicon-1##25 XOR1_to_NAND5#14pin@757_polysilicon-1##26 9.854
R7082 XOR1_to_NAND5#14pin@757_polysilicon-1##26 XOR1_to_NAND5#14pin@757_polysilicon-1##27 9.854
R7083 XOR1_to_NAND5#14pin@757_polysilicon-1##27 XOR1_to_NAND5#14pin@757_polysilicon-1##28 9.854
R7084 XOR1_to_NAND5#14pin@757_polysilicon-1##28 XOR1_to_NAND5#14pin@757_polysilicon-1##29 9.854
R7085 XOR1_to_NAND5#14pin@757_polysilicon-1##29 XOR1_to_NAND5#14pin@757_polysilicon-1##30 9.854
R7086 XOR1_to_NAND5#14pin@757_polysilicon-1##30 XOR1_to_NAND5#14pin@757_polysilicon-1##31 9.854
R7087 XOR1_to_NAND5#14pin@757_polysilicon-1##31 XOR1_to_NAND5#14pin@757_polysilicon-1##32 9.854
R7088 XOR1_to_NAND5#14pin@757_polysilicon-1##32 XOR1_to_NAND5#14pin@757_polysilicon-1##33 9.854
R7089 XOR1_to_NAND5#14pin@757_polysilicon-1##33 XOR1_to_NAND5#14pin@757_polysilicon-1##34 9.854
R7090 XOR1_to_NAND5#14pin@757_polysilicon-1##34 XOR1_to_NAND5#14pin@757_polysilicon-1##35 9.854
R7091 XOR1_to_NAND5#14pin@757_polysilicon-1##35 XOR1_to_NAND5#14pin@757_polysilicon-1##36 9.854
R7092 XOR1_to_NAND5#14pin@757_polysilicon-1##36 XOR1_to_NAND5#14pin@757_polysilicon-1##37 9.854
R7093 XOR1_to_NAND5#14pin@757_polysilicon-1##37 XOR1_to_NAND5#14pin@757_polysilicon-1##38 9.854
R7094 XOR1_to_NAND5#14pin@757_polysilicon-1##38 XOR1_to_NAND5#14pin@757_polysilicon-1##39 9.854
R7095 XOR1_to_NAND5#14pin@757_polysilicon-1##39 XOR1_to_NAND5#14pin@757_polysilicon-1##40 9.854
R7096 XOR1_to_NAND5#14pin@757_polysilicon-1##40 XOR1_to_NAND5#14pin@757_polysilicon-1##41 9.854
R7097 XOR1_to_NAND5#14pin@757_polysilicon-1##41 XOR1_to_NAND5#14pin@757_polysilicon-1##42 9.854
R7098 XOR1_to_NAND5#14pin@757_polysilicon-1##42 XOR1_to_NAND5#14pin@757_polysilicon-1##43 9.854
R7099 XOR1_to_NAND5#14pin@757_polysilicon-1##43 XOR1_to_NAND5#14pin@757_polysilicon-1##44 9.854
R7100 XOR1_to_NAND5#14pin@757_polysilicon-1##44 XOR1_to_NAND5#14pin@757_polysilicon-1##45 9.854
R7101 XOR1_to_NAND5#14pin@757_polysilicon-1##45 XOR1_to_NAND5#14pin@757_polysilicon-1##46 9.854
R7102 XOR1_to_NAND5#14pin@757_polysilicon-1##46 XOR1_to_NAND5#14pin@757_polysilicon-1##47 9.854
R7103 XOR1_to_NAND5#14pin@757_polysilicon-1##47 XOR1_to_NAND5#14pin@757_polysilicon-1##48 9.854
R7104 XOR1_to_NAND5#14pin@757_polysilicon-1##48 XOR1_to_NAND5#14pin@757_polysilicon-1##49 9.854
R7105 XOR1_to_NAND5#14pin@757_polysilicon-1##49 XOR1_to_NAND5#14pin@757_polysilicon-1##50 9.854
R7106 XOR1_to_NAND5#14pin@757_polysilicon-1##50 XOR1_to_NAND5#14pin@757_polysilicon-1##51 9.854
R7107 XOR1_to_NAND5#14pin@757_polysilicon-1##51 XOR1_to_NAND5#14pin@757_polysilicon-1##52 9.854
R7108 XOR1_to_NAND5#14pin@757_polysilicon-1##52 XOR1_to_NAND5#14pin@757_polysilicon-1##53 9.854
R7109 XOR1_to_NAND5#14pin@757_polysilicon-1##53 XOR1_to_NAND5#14pin@757_polysilicon-1##54 9.854
R7110 XOR1_to_NAND5#14pin@757_polysilicon-1##54 XOR1_to_NAND5#27nmos@134_poly-right 9.854
R7111 Cin_to_XOR2___NAND5#29pmos@135_poly-right Cin_to_XOR2___NAND5#29pmos@135_poly-right##0 9.877
R7112 Cin_to_XOR2___NAND5#29pmos@135_poly-right##0 Cin_to_XOR2___NAND5#29pmos@135_poly-right##1 9.877
R7113 Cin_to_XOR2___NAND5#29pmos@135_poly-right##1 Cin_to_XOR2___NAND5#29pmos@135_poly-right##2 9.877
R7114 Cin_to_XOR2___NAND5#29pmos@135_poly-right##2 Cin_to_XOR2___NAND5#29pmos@135_poly-right##3 9.877
R7115 Cin_to_XOR2___NAND5#29pmos@135_poly-right##3 Cin_to_XOR2___NAND5#29pmos@135_poly-right##4 9.877
R7116 Cin_to_XOR2___NAND5#29pmos@135_poly-right##4 Cin_to_XOR2___NAND5#29pmos@135_poly-right##5 9.877
R7117 Cin_to_XOR2___NAND5#29pmos@135_poly-right##5 Cin_to_XOR2___NAND5#29pmos@135_poly-right##6 9.877
R7118 Cin_to_XOR2___NAND5#29pmos@135_poly-right##6 Cin_to_XOR2___NAND5#29pmos@135_poly-right##7 9.877
R7119 Cin_to_XOR2___NAND5#29pmos@135_poly-right##7 Cin_to_XOR2___NAND5#29pmos@135_poly-right##8 9.877
R7120 Cin_to_XOR2___NAND5#29pmos@135_poly-right##8 Cin_to_XOR2___NAND5#29pmos@135_poly-right##9 9.877
R7121 Cin_to_XOR2___NAND5#29pmos@135_poly-right##9 Cin_to_XOR2___NAND5#29pmos@135_poly-right##10 9.877
R7122 Cin_to_XOR2___NAND5#29pmos@135_poly-right##10 Cin_to_XOR2___NAND5#29pmos@135_poly-right##11 9.877
R7123 Cin_to_XOR2___NAND5#29pmos@135_poly-right##11 Cin_to_XOR2___NAND5#29pmos@135_poly-right##12 9.877
R7124 Cin_to_XOR2___NAND5#29pmos@135_poly-right##12 Cin_to_XOR2___NAND5#29pmos@135_poly-right##13 9.877
R7125 Cin_to_XOR2___NAND5#29pmos@135_poly-right##13 Cin_to_XOR2___NAND5#29pmos@135_poly-right##14 9.877
R7126 Cin_to_XOR2___NAND5#29pmos@135_poly-right##14 Cin_to_XOR2___NAND5#29pmos@135_poly-right##15 9.877
R7127 Cin_to_XOR2___NAND5#29pmos@135_poly-right##15 Cin_to_XOR2___NAND5#29pmos@135_poly-right##16 9.877
R7128 Cin_to_XOR2___NAND5#29pmos@135_poly-right##16 Cin_to_XOR2___NAND5#29pmos@135_poly-right##17 9.877
R7129 Cin_to_XOR2___NAND5#29pmos@135_poly-right##17 Cin_to_XOR2___NAND5#29pmos@135_poly-right##18 9.877
R7130 Cin_to_XOR2___NAND5#29pmos@135_poly-right##18 Cin_to_XOR2___NAND5#29pmos@135_poly-right##19 9.877
R7131 Cin_to_XOR2___NAND5#29pmos@135_poly-right##19 Cin_to_XOR2___NAND5#29pmos@135_poly-right##20 9.877
R7132 Cin_to_XOR2___NAND5#29pmos@135_poly-right##20 Cin_to_XOR2___NAND5#29pmos@135_poly-right##21 9.877
R7133 Cin_to_XOR2___NAND5#29pmos@135_poly-right##21 Cin_to_XOR2___NAND5#29pmos@135_poly-right##22 9.877
R7134 Cin_to_XOR2___NAND5#29pmos@135_poly-right##22 Cin_to_XOR2___NAND5#29pmos@135_poly-right##23 9.877
R7135 Cin_to_XOR2___NAND5#29pmos@135_poly-right##23 Cin_to_XOR2___NAND5#29pmos@135_poly-right##24 9.877
R7136 Cin_to_XOR2___NAND5#29pmos@135_poly-right##24 Cin_to_XOR2___NAND5#29pmos@135_poly-right##25 9.877
R7137 Cin_to_XOR2___NAND5#29pmos@135_poly-right##25 Cin_to_XOR2___NAND5#29pmos@135_poly-right##26 9.877
R7138 Cin_to_XOR2___NAND5#29pmos@135_poly-right##26 Cin_to_XOR2___NAND5#29pmos@135_poly-right##27 9.877
R7139 Cin_to_XOR2___NAND5#29pmos@135_poly-right##27 Cin_to_XOR2___NAND5#29pmos@135_poly-right##28 9.877
R7140 Cin_to_XOR2___NAND5#29pmos@135_poly-right##28 Cin_to_XOR2___NAND5#29pmos@135_poly-right##29 9.877
R7141 Cin_to_XOR2___NAND5#29pmos@135_poly-right##29 Cin_to_XOR2___NAND5#29pmos@135_poly-right##30 9.877
R7142 Cin_to_XOR2___NAND5#29pmos@135_poly-right##30 Cin_to_XOR2___NAND5#29pmos@135_poly-right##31 9.877
R7143 Cin_to_XOR2___NAND5#29pmos@135_poly-right##31 Cin_to_XOR2___NAND5#29pmos@135_poly-right##32 9.877
R7144 Cin_to_XOR2___NAND5#29pmos@135_poly-right##32 Cin_to_XOR2___NAND5#29pmos@135_poly-right##33 9.877
R7145 Cin_to_XOR2___NAND5#29pmos@135_poly-right##33 Cin_to_XOR2___NAND5#29pmos@135_poly-right##34 9.877
R7146 Cin_to_XOR2___NAND5#29pmos@135_poly-right##34 Cin_to_XOR2___NAND5#29pmos@135_poly-right##35 9.877
R7147 Cin_to_XOR2___NAND5#29pmos@135_poly-right##35 Cin_to_XOR2___NAND5#29pmos@135_poly-right##36 9.877
R7148 Cin_to_XOR2___NAND5#29pmos@135_poly-right##36 Cin_to_XOR2___NAND5#29pmos@135_poly-right##37 9.877
R7149 Cin_to_XOR2___NAND5#29pmos@135_poly-right##37 Cin_to_XOR2___NAND5#29pmos@135_poly-right##38 9.877
R7150 Cin_to_XOR2___NAND5#29pmos@135_poly-right##38 Cin_to_XOR2___NAND5#29pmos@135_poly-right##39 9.877
R7151 Cin_to_XOR2___NAND5#29pmos@135_poly-right##39 Cin_to_XOR2___NAND5#29pmos@135_poly-right##40 9.877
R7152 Cin_to_XOR2___NAND5#29pmos@135_poly-right##40 Cin_to_XOR2___NAND5#29pmos@135_poly-right##41 9.877
R7153 Cin_to_XOR2___NAND5#29pmos@135_poly-right##41 Cin_to_XOR2___NAND5#29pmos@135_poly-right##42 9.877
R7154 Cin_to_XOR2___NAND5#29pmos@135_poly-right##42 Cin_to_XOR2___NAND5#29pmos@135_poly-right##43 9.877
R7155 Cin_to_XOR2___NAND5#29pmos@135_poly-right##43 Cin_to_XOR2___NAND5#29pmos@135_poly-right##44 9.877
R7156 Cin_to_XOR2___NAND5#29pmos@135_poly-right##44 Cin_to_XOR2___NAND5#29pmos@135_poly-right##45 9.877
R7157 Cin_to_XOR2___NAND5#29pmos@135_poly-right##45 Cin_to_XOR2___NAND5#29pmos@135_poly-right##46 9.877
R7158 Cin_to_XOR2___NAND5#29pmos@135_poly-right##46 Cin_to_XOR2___NAND5#29pmos@135_poly-right##47 9.877
R7159 Cin_to_XOR2___NAND5#29pmos@135_poly-right##47 Cin_to_XOR2___NAND5#29pmos@135_poly-right##48 9.877
R7160 Cin_to_XOR2___NAND5#29pmos@135_poly-right##48 Cin_to_XOR2___NAND5#29pmos@135_poly-right##49 9.877
R7161 Cin_to_XOR2___NAND5#29pmos@135_poly-right##49 Cin_to_XOR2___NAND5#23pin@761_polysilicon-1 9.877
R7162 NAND1_to_NAND7 NAND1_to_NAND7#4nmos@135_diff-bottom 4.823
R7163 A4#10pin@764_polysilicon-1 A4#10pin@764_polysilicon-1##0 9.938
R7164 A4#10pin@764_polysilicon-1##0 A4#10pin@764_polysilicon-1##1 9.938
R7165 A4#10pin@764_polysilicon-1##1 A4#10pin@764_polysilicon-1##2 9.938
R7166 A4#10pin@764_polysilicon-1##2 A4#10pin@764_polysilicon-1##3 9.938
R7167 A4#10pin@764_polysilicon-1##3 A4#10pin@764_polysilicon-1##4 9.938
R7168 A4#10pin@764_polysilicon-1##4 A4#10pin@764_polysilicon-1##5 9.938
R7169 A4#10pin@764_polysilicon-1##5 A4#10pin@764_polysilicon-1##6 9.938
R7170 A4#10pin@764_polysilicon-1##6 A4#10pin@764_polysilicon-1##7 9.938
R7171 A4#10pin@764_polysilicon-1##7 A4#10pin@764_polysilicon-1##8 9.938
R7172 A4#10pin@764_polysilicon-1##8 A4#10pin@764_polysilicon-1##9 9.938
R7173 A4#10pin@764_polysilicon-1##9 A4#10pin@764_polysilicon-1##10 9.938
R7174 A4#10pin@764_polysilicon-1##10 A4#10pin@764_polysilicon-1##11 9.938
R7175 A4#10pin@764_polysilicon-1##11 A4#10pin@764_polysilicon-1##12 9.938
R7176 A4#10pin@764_polysilicon-1##12 A4#10pin@764_polysilicon-1##13 9.938
R7177 A4#10pin@764_polysilicon-1##13 A4#10pin@764_polysilicon-1##14 9.938
R7178 A4#10pin@764_polysilicon-1##14 A4#10pin@764_polysilicon-1##15 9.938
R7179 A4#10pin@764_polysilicon-1##15 A4#10pin@764_polysilicon-1##16 9.938
R7180 A4#10pin@764_polysilicon-1##16 A4#10pin@764_polysilicon-1##17 9.938
R7181 A4#10pin@764_polysilicon-1##17 A4#10pin@764_polysilicon-1##18 9.938
R7182 A4#10pin@764_polysilicon-1##18 A4#10pin@764_polysilicon-1##19 9.938
R7183 A4#10pin@764_polysilicon-1##19 A4#10pin@764_polysilicon-1##20 9.938
R7184 A4#10pin@764_polysilicon-1##20 A4#10pin@764_polysilicon-1##21 9.938
R7185 A4#10pin@764_polysilicon-1##21 A4#10pin@764_polysilicon-1##22 9.938
R7186 A4#10pin@764_polysilicon-1##22 A4#10pin@764_polysilicon-1##23 9.938
R7187 A4#10pin@764_polysilicon-1##23 A4#10pin@764_polysilicon-1##24 9.938
R7188 A4#10pin@764_polysilicon-1##24 A4#10pin@764_polysilicon-1##25 9.938
R7189 A4#10pin@764_polysilicon-1##25 A4#10pin@764_polysilicon-1##26 9.938
R7190 A4#10pin@764_polysilicon-1##26 A4#10pin@764_polysilicon-1##27 9.938
R7191 A4#10pin@764_polysilicon-1##27 A4#10pin@764_polysilicon-1##28 9.938
R7192 A4#10pin@764_polysilicon-1##28 A4#10pin@764_polysilicon-1##29 9.938
R7193 A4#10pin@764_polysilicon-1##29 A4#10pin@764_polysilicon-1##30 9.938
R7194 A4#10pin@764_polysilicon-1##30 A4#10pin@764_polysilicon-1##31 9.938
R7195 A4#10pin@764_polysilicon-1##31 A4#10pin@764_polysilicon-1##32 9.938
R7196 A4#10pin@764_polysilicon-1##32 A4#10pin@764_polysilicon-1##33 9.938
R7197 A4#10pin@764_polysilicon-1##33 A4#10pin@764_polysilicon-1##34 9.938
R7198 A4#10pin@764_polysilicon-1##34 A4#10pin@764_polysilicon-1##35 9.938
R7199 A4#10pin@764_polysilicon-1##35 A4#10pin@764_polysilicon-1##36 9.938
R7200 A4#10pin@764_polysilicon-1##36 A4#10pin@764_polysilicon-1##37 9.938
R7201 A4#10pin@764_polysilicon-1##37 A4#10pin@764_polysilicon-1##38 9.938
R7202 A4#10pin@764_polysilicon-1##38 A4#10pin@764_polysilicon-1##39 9.938
R7203 A4#10pin@764_polysilicon-1##39 A4#10pin@764_polysilicon-1##40 9.938
R7204 A4#10pin@764_polysilicon-1##40 A4#10pin@764_polysilicon-1##41 9.938
R7205 A4#10pin@764_polysilicon-1##41 A4#10pin@764_polysilicon-1##42 9.938
R7206 A4#10pin@764_polysilicon-1##42 A4#10pin@764_polysilicon-1##43 9.938
R7207 A4#10pin@764_polysilicon-1##43 A4#10pin@764_polysilicon-1##44 9.938
R7208 A4#10pin@764_polysilicon-1##44 A4#10pin@764_polysilicon-1##45 9.938
R7209 A4#10pin@764_polysilicon-1##45 A4#10pin@764_polysilicon-1##46 9.938
R7210 A4#10pin@764_polysilicon-1##46 A4#10pin@764_polysilicon-1##47 9.938
R7211 A4#10pin@764_polysilicon-1##47 A4#10pin@764_polysilicon-1##48 9.938
R7212 A4#10pin@764_polysilicon-1##48 A4#10pin@764_polysilicon-1##49 9.938
R7213 A4#10pin@764_polysilicon-1##49 A4#19nmos@136_poly-right 9.938
R7214 B4#20pmos@137_poly-right B4#20pmos@137_poly-right##0 9.869
R7215 B4#20pmos@137_poly-right##0 B4#20pmos@137_poly-right##1 9.869
R7216 B4#20pmos@137_poly-right##1 B4#20pmos@137_poly-right##2 9.869
R7217 B4#20pmos@137_poly-right##2 B4#20pmos@137_poly-right##3 9.869
R7218 B4#20pmos@137_poly-right##3 B4#20pmos@137_poly-right##4 9.869
R7219 B4#20pmos@137_poly-right##4 B4#20pmos@137_poly-right##5 9.869
R7220 B4#20pmos@137_poly-right##5 B4#20pmos@137_poly-right##6 9.869
R7221 B4#20pmos@137_poly-right##6 B4#20pmos@137_poly-right##7 9.869
R7222 B4#20pmos@137_poly-right##7 B4#20pmos@137_poly-right##8 9.869
R7223 B4#20pmos@137_poly-right##8 B4#20pmos@137_poly-right##9 9.869
R7224 B4#20pmos@137_poly-right##9 B4#20pmos@137_poly-right##10 9.869
R7225 B4#20pmos@137_poly-right##10 B4#20pmos@137_poly-right##11 9.869
R7226 B4#20pmos@137_poly-right##11 B4#20pmos@137_poly-right##12 9.869
R7227 B4#20pmos@137_poly-right##12 B4#20pmos@137_poly-right##13 9.869
R7228 B4#20pmos@137_poly-right##13 B4#20pmos@137_poly-right##14 9.869
R7229 B4#20pmos@137_poly-right##14 B4#20pmos@137_poly-right##15 9.869
R7230 B4#20pmos@137_poly-right##15 B4#20pmos@137_poly-right##16 9.869
R7231 B4#20pmos@137_poly-right##16 B4#20pmos@137_poly-right##17 9.869
R7232 B4#20pmos@137_poly-right##17 B4#20pmos@137_poly-right##18 9.869
R7233 B4#20pmos@137_poly-right##18 B4#20pmos@137_poly-right##19 9.869
R7234 B4#20pmos@137_poly-right##19 B4#20pmos@137_poly-right##20 9.869
R7235 B4#20pmos@137_poly-right##20 B4#20pmos@137_poly-right##21 9.869
R7236 B4#20pmos@137_poly-right##21 B4#20pmos@137_poly-right##22 9.869
R7237 B4#20pmos@137_poly-right##22 B4#20pmos@137_poly-right##23 9.869
R7238 B4#20pmos@137_poly-right##23 B4#20pmos@137_poly-right##24 9.869
R7239 B4#20pmos@137_poly-right##24 B4#20pmos@137_poly-right##25 9.869
R7240 B4#20pmos@137_poly-right##25 B4#20pmos@137_poly-right##26 9.869
R7241 B4#20pmos@137_poly-right##26 B4#20pmos@137_poly-right##27 9.869
R7242 B4#20pmos@137_poly-right##27 B4#20pmos@137_poly-right##28 9.869
R7243 B4#20pmos@137_poly-right##28 B4#20pmos@137_poly-right##29 9.869
R7244 B4#20pmos@137_poly-right##29 B4#20pmos@137_poly-right##30 9.869
R7245 B4#20pmos@137_poly-right##30 B4#20pmos@137_poly-right##31 9.869
R7246 B4#20pmos@137_poly-right##31 B4#20pmos@137_poly-right##32 9.869
R7247 B4#20pmos@137_poly-right##32 B4#20pmos@137_poly-right##33 9.869
R7248 B4#20pmos@137_poly-right##33 B4#20pmos@137_poly-right##34 9.869
R7249 B4#20pmos@137_poly-right##34 B4#20pmos@137_poly-right##35 9.869
R7250 B4#20pmos@137_poly-right##35 B4#20pmos@137_poly-right##36 9.869
R7251 B4#20pmos@137_poly-right##36 B4#20pmos@137_poly-right##37 9.869
R7252 B4#20pmos@137_poly-right##37 B4#20pmos@137_poly-right##38 9.869
R7253 B4#20pmos@137_poly-right##38 B4#20pmos@137_poly-right##39 9.869
R7254 B4#20pmos@137_poly-right##39 B4#20pmos@137_poly-right##40 9.869
R7255 B4#20pmos@137_poly-right##40 B4#20pmos@137_poly-right##41 9.869
R7256 B4#20pmos@137_poly-right##41 B4#20pmos@137_poly-right##42 9.869
R7257 B4#20pmos@137_poly-right##42 B4#20pmos@137_poly-right##43 9.869
R7258 B4#20pmos@137_poly-right##43 B4#20pmos@137_poly-right##44 9.869
R7259 B4#20pmos@137_poly-right##44 B4#20pmos@137_poly-right##45 9.869
R7260 B4#20pmos@137_poly-right##45 B4#20pmos@137_poly-right##46 9.869
R7261 B4#20pmos@137_poly-right##46 B4#20pmos@137_poly-right##47 9.869
R7262 B4#20pmos@137_poly-right##47 B4#10pin@768_polysilicon-1 9.869
R7263 NAND2_to_Nand7#9pin@770_polysilicon-1 NAND2_to_Nand7#9pin@770_polysilicon-1##0 9.938
R7264 NAND2_to_Nand7#9pin@770_polysilicon-1##0 NAND2_to_Nand7#9pin@770_polysilicon-1##1 9.938
R7265 NAND2_to_Nand7#9pin@770_polysilicon-1##1 NAND2_to_Nand7#9pin@770_polysilicon-1##2 9.938
R7266 NAND2_to_Nand7#9pin@770_polysilicon-1##2 NAND2_to_Nand7#9pin@770_polysilicon-1##3 9.938
R7267 NAND2_to_Nand7#9pin@770_polysilicon-1##3 NAND2_to_Nand7#9pin@770_polysilicon-1##4 9.938
R7268 NAND2_to_Nand7#9pin@770_polysilicon-1##4 NAND2_to_Nand7#9pin@770_polysilicon-1##5 9.938
R7269 NAND2_to_Nand7#9pin@770_polysilicon-1##5 NAND2_to_Nand7#9pin@770_polysilicon-1##6 9.938
R7270 NAND2_to_Nand7#9pin@770_polysilicon-1##6 NAND2_to_Nand7#9pin@770_polysilicon-1##7 9.938
R7271 NAND2_to_Nand7#9pin@770_polysilicon-1##7 NAND2_to_Nand7#9pin@770_polysilicon-1##8 9.938
R7272 NAND2_to_Nand7#9pin@770_polysilicon-1##8 NAND2_to_Nand7#9pin@770_polysilicon-1##9 9.938
R7273 NAND2_to_Nand7#9pin@770_polysilicon-1##9 NAND2_to_Nand7#9pin@770_polysilicon-1##10 9.938
R7274 NAND2_to_Nand7#9pin@770_polysilicon-1##10 NAND2_to_Nand7#9pin@770_polysilicon-1##11 9.938
R7275 NAND2_to_Nand7#9pin@770_polysilicon-1##11 NAND2_to_Nand7#9pin@770_polysilicon-1##12 9.938
R7276 NAND2_to_Nand7#9pin@770_polysilicon-1##12 NAND2_to_Nand7#9pin@770_polysilicon-1##13 9.938
R7277 NAND2_to_Nand7#9pin@770_polysilicon-1##13 NAND2_to_Nand7#9pin@770_polysilicon-1##14 9.938
R7278 NAND2_to_Nand7#9pin@770_polysilicon-1##14 NAND2_to_Nand7#9pin@770_polysilicon-1##15 9.938
R7279 NAND2_to_Nand7#9pin@770_polysilicon-1##15 NAND2_to_Nand7#9pin@770_polysilicon-1##16 9.938
R7280 NAND2_to_Nand7#9pin@770_polysilicon-1##16 NAND2_to_Nand7#9pin@770_polysilicon-1##17 9.938
R7281 NAND2_to_Nand7#9pin@770_polysilicon-1##17 NAND2_to_Nand7#9pin@770_polysilicon-1##18 9.938
R7282 NAND2_to_Nand7#9pin@770_polysilicon-1##18 NAND2_to_Nand7#9pin@770_polysilicon-1##19 9.938
R7283 NAND2_to_Nand7#9pin@770_polysilicon-1##19 NAND2_to_Nand7#9pin@770_polysilicon-1##20 9.938
R7284 NAND2_to_Nand7#9pin@770_polysilicon-1##20 NAND2_to_Nand7#9pin@770_polysilicon-1##21 9.938
R7285 NAND2_to_Nand7#9pin@770_polysilicon-1##21 NAND2_to_Nand7#9pin@770_polysilicon-1##22 9.938
R7286 NAND2_to_Nand7#9pin@770_polysilicon-1##22 NAND2_to_Nand7#9pin@770_polysilicon-1##23 9.938
R7287 NAND2_to_Nand7#9pin@770_polysilicon-1##23 NAND2_to_Nand7#9pin@770_polysilicon-1##24 9.938
R7288 NAND2_to_Nand7#9pin@770_polysilicon-1##24 NAND2_to_Nand7#9pin@770_polysilicon-1##25 9.938
R7289 NAND2_to_Nand7#9pin@770_polysilicon-1##25 NAND2_to_Nand7#9pin@770_polysilicon-1##26 9.938
R7290 NAND2_to_Nand7#9pin@770_polysilicon-1##26 NAND2_to_Nand7#9pin@770_polysilicon-1##27 9.938
R7291 NAND2_to_Nand7#9pin@770_polysilicon-1##27 NAND2_to_Nand7#9pin@770_polysilicon-1##28 9.938
R7292 NAND2_to_Nand7#9pin@770_polysilicon-1##28 NAND2_to_Nand7#9pin@770_polysilicon-1##29 9.938
R7293 NAND2_to_Nand7#9pin@770_polysilicon-1##29 NAND2_to_Nand7#9pin@770_polysilicon-1##30 9.938
R7294 NAND2_to_Nand7#9pin@770_polysilicon-1##30 NAND2_to_Nand7#9pin@770_polysilicon-1##31 9.938
R7295 NAND2_to_Nand7#9pin@770_polysilicon-1##31 NAND2_to_Nand7#9pin@770_polysilicon-1##32 9.938
R7296 NAND2_to_Nand7#9pin@770_polysilicon-1##32 NAND2_to_Nand7#9pin@770_polysilicon-1##33 9.938
R7297 NAND2_to_Nand7#9pin@770_polysilicon-1##33 NAND2_to_Nand7#9pin@770_polysilicon-1##34 9.938
R7298 NAND2_to_Nand7#9pin@770_polysilicon-1##34 NAND2_to_Nand7#9pin@770_polysilicon-1##35 9.938
R7299 NAND2_to_Nand7#9pin@770_polysilicon-1##35 NAND2_to_Nand7#9pin@770_polysilicon-1##36 9.938
R7300 NAND2_to_Nand7#9pin@770_polysilicon-1##36 NAND2_to_Nand7#9pin@770_polysilicon-1##37 9.938
R7301 NAND2_to_Nand7#9pin@770_polysilicon-1##37 NAND2_to_Nand7#9pin@770_polysilicon-1##38 9.938
R7302 NAND2_to_Nand7#9pin@770_polysilicon-1##38 NAND2_to_Nand7#9pin@770_polysilicon-1##39 9.938
R7303 NAND2_to_Nand7#9pin@770_polysilicon-1##39 NAND2_to_Nand7#9pin@770_polysilicon-1##40 9.938
R7304 NAND2_to_Nand7#9pin@770_polysilicon-1##40 NAND2_to_Nand7#9pin@770_polysilicon-1##41 9.938
R7305 NAND2_to_Nand7#9pin@770_polysilicon-1##41 NAND2_to_Nand7#9pin@770_polysilicon-1##42 9.938
R7306 NAND2_to_Nand7#9pin@770_polysilicon-1##42 NAND2_to_Nand7#9pin@770_polysilicon-1##43 9.938
R7307 NAND2_to_Nand7#9pin@770_polysilicon-1##43 NAND2_to_Nand7#9pin@770_polysilicon-1##44 9.938
R7308 NAND2_to_Nand7#9pin@770_polysilicon-1##44 NAND2_to_Nand7#9pin@770_polysilicon-1##45 9.938
R7309 NAND2_to_Nand7#9pin@770_polysilicon-1##45 NAND2_to_Nand7#9pin@770_polysilicon-1##46 9.938
R7310 NAND2_to_Nand7#9pin@770_polysilicon-1##46 NAND2_to_Nand7#9pin@770_polysilicon-1##47 9.938
R7311 NAND2_to_Nand7#9pin@770_polysilicon-1##47 NAND2_to_Nand7#9pin@770_polysilicon-1##48 9.938
R7312 NAND2_to_Nand7#9pin@770_polysilicon-1##48 NAND2_to_Nand7#9pin@770_polysilicon-1##49 9.938
R7313 NAND2_to_Nand7#9pin@770_polysilicon-1##49 NAND2_to_Nand7#11nmos@138_poly-right 9.938
R7314 NAND1_to_NAND7#14nmos@139_poly-right NAND1_to_NAND7#14nmos@139_poly-right##0 9.898
R7315 NAND1_to_NAND7#14nmos@139_poly-right##0 NAND1_to_NAND7#14nmos@139_poly-right##1 9.898
R7316 NAND1_to_NAND7#14nmos@139_poly-right##1 NAND1_to_NAND7#14nmos@139_poly-right##2 9.898
R7317 NAND1_to_NAND7#14nmos@139_poly-right##2 NAND1_to_NAND7#14nmos@139_poly-right##3 9.898
R7318 NAND1_to_NAND7#14nmos@139_poly-right##3 NAND1_to_NAND7#14nmos@139_poly-right##4 9.898
R7319 NAND1_to_NAND7#14nmos@139_poly-right##4 NAND1_to_NAND7#14nmos@139_poly-right##5 9.898
R7320 NAND1_to_NAND7#14nmos@139_poly-right##5 NAND1_to_NAND7#14nmos@139_poly-right##6 9.898
R7321 NAND1_to_NAND7#14nmos@139_poly-right##6 NAND1_to_NAND7#14nmos@139_poly-right##7 9.898
R7322 NAND1_to_NAND7#14nmos@139_poly-right##7 NAND1_to_NAND7#14nmos@139_poly-right##8 9.898
R7323 NAND1_to_NAND7#14nmos@139_poly-right##8 NAND1_to_NAND7#14nmos@139_poly-right##9 9.898
R7324 NAND1_to_NAND7#14nmos@139_poly-right##9 NAND1_to_NAND7#14nmos@139_poly-right##10 9.898
R7325 NAND1_to_NAND7#14nmos@139_poly-right##10 NAND1_to_NAND7#14nmos@139_poly-right##11 9.898
R7326 NAND1_to_NAND7#14nmos@139_poly-right##11 NAND1_to_NAND7#14nmos@139_poly-right##12 9.898
R7327 NAND1_to_NAND7#14nmos@139_poly-right##12 NAND1_to_NAND7#14nmos@139_poly-right##13 9.898
R7328 NAND1_to_NAND7#14nmos@139_poly-right##13 NAND1_to_NAND7#14nmos@139_poly-right##14 9.898
R7329 NAND1_to_NAND7#14nmos@139_poly-right##14 NAND1_to_NAND7#14nmos@139_poly-right##15 9.898
R7330 NAND1_to_NAND7#14nmos@139_poly-right##15 NAND1_to_NAND7#14nmos@139_poly-right##16 9.898
R7331 NAND1_to_NAND7#14nmos@139_poly-right##16 NAND1_to_NAND7#14nmos@139_poly-right##17 9.898
R7332 NAND1_to_NAND7#14nmos@139_poly-right##17 NAND1_to_NAND7#14nmos@139_poly-right##18 9.898
R7333 NAND1_to_NAND7#14nmos@139_poly-right##18 NAND1_to_NAND7#14nmos@139_poly-right##19 9.898
R7334 NAND1_to_NAND7#14nmos@139_poly-right##19 NAND1_to_NAND7#14nmos@139_poly-right##20 9.898
R7335 NAND1_to_NAND7#14nmos@139_poly-right##20 NAND1_to_NAND7#14nmos@139_poly-right##21 9.898
R7336 NAND1_to_NAND7#14nmos@139_poly-right##21 NAND1_to_NAND7#14nmos@139_poly-right##22 9.898
R7337 NAND1_to_NAND7#14nmos@139_poly-right##22 NAND1_to_NAND7#14nmos@139_poly-right##23 9.898
R7338 NAND1_to_NAND7#14nmos@139_poly-right##23 NAND1_to_NAND7#14nmos@139_poly-right##24 9.898
R7339 NAND1_to_NAND7#14nmos@139_poly-right##24 NAND1_to_NAND7#14nmos@139_poly-right##25 9.898
R7340 NAND1_to_NAND7#14nmos@139_poly-right##25 NAND1_to_NAND7#14nmos@139_poly-right##26 9.898
R7341 NAND1_to_NAND7#14nmos@139_poly-right##26 NAND1_to_NAND7#14nmos@139_poly-right##27 9.898
R7342 NAND1_to_NAND7#14nmos@139_poly-right##27 NAND1_to_NAND7#14nmos@139_poly-right##28 9.898
R7343 NAND1_to_NAND7#14nmos@139_poly-right##28 NAND1_to_NAND7#14nmos@139_poly-right##29 9.898
R7344 NAND1_to_NAND7#14nmos@139_poly-right##29 NAND1_to_NAND7#14nmos@139_poly-right##30 9.898
R7345 NAND1_to_NAND7#14nmos@139_poly-right##30 NAND1_to_NAND7#14nmos@139_poly-right##31 9.898
R7346 NAND1_to_NAND7#14nmos@139_poly-right##31 NAND1_to_NAND7#14nmos@139_poly-right##32 9.898
R7347 NAND1_to_NAND7#14nmos@139_poly-right##32 NAND1_to_NAND7#14nmos@139_poly-right##33 9.898
R7348 NAND1_to_NAND7#14nmos@139_poly-right##33 NAND1_to_NAND7#14nmos@139_poly-right##34 9.898
R7349 NAND1_to_NAND7#14nmos@139_poly-right##34 NAND1_to_NAND7#14nmos@139_poly-right##35 9.898
R7350 NAND1_to_NAND7#14nmos@139_poly-right##35 NAND1_to_NAND7#14nmos@139_poly-right##36 9.898
R7351 NAND1_to_NAND7#14nmos@139_poly-right##36 NAND1_to_NAND7#14nmos@139_poly-right##37 9.898
R7352 NAND1_to_NAND7#14nmos@139_poly-right##37 NAND1_to_NAND7#14nmos@139_poly-right##38 9.898
R7353 NAND1_to_NAND7#14nmos@139_poly-right##38 NAND1_to_NAND7#14nmos@139_poly-right##39 9.898
R7354 NAND1_to_NAND7#14nmos@139_poly-right##39 NAND1_to_NAND7#14nmos@139_poly-right##40 9.898
R7355 NAND1_to_NAND7#14nmos@139_poly-right##40 NAND1_to_NAND7#14nmos@139_poly-right##41 9.898
R7356 NAND1_to_NAND7#14nmos@139_poly-right##41 NAND1_to_NAND7#14nmos@139_poly-right##42 9.898
R7357 NAND1_to_NAND7#14nmos@139_poly-right##42 NAND1_to_NAND7#14nmos@139_poly-right##43 9.898
R7358 NAND1_to_NAND7#14nmos@139_poly-right##43 NAND1_to_NAND7#14nmos@139_poly-right##44 9.898
R7359 NAND1_to_NAND7#14nmos@139_poly-right##44 NAND1_to_NAND7#14nmos@139_poly-right##45 9.898
R7360 NAND1_to_NAND7#14nmos@139_poly-right##45 NAND1_to_NAND7#14nmos@139_poly-right##46 9.898
R7361 NAND1_to_NAND7#14nmos@139_poly-right##46 NAND1_to_NAND7#14nmos@139_poly-right##47 9.898
R7362 NAND1_to_NAND7#14nmos@139_poly-right##47 NAND1_to_NAND7#14nmos@139_poly-right##48 9.898
R7363 NAND1_to_NAND7#14nmos@139_poly-right##48 NAND1_to_NAND7#14nmos@139_poly-right##49 9.898
R7364 NAND1_to_NAND7#14nmos@139_poly-right##49 NAND1_to_NAND7#14nmos@139_poly-right##50 9.898
R7365 NAND1_to_NAND7#14nmos@139_poly-right##50 NAND1_to_NAND7#14nmos@139_poly-right##51 9.898
R7366 NAND1_to_NAND7#14nmos@139_poly-right##51 NAND1_to_NAND7#14nmos@139_poly-right##52 9.898
R7367 NAND1_to_NAND7#14nmos@139_poly-right##52 NAND1_to_NAND7#14nmos@139_poly-right##53 9.898
R7368 NAND1_to_NAND7#14nmos@139_poly-right##53 NAND1_to_NAND7#14nmos@139_poly-right##54 9.898
R7369 NAND1_to_NAND7#14nmos@139_poly-right##54 NAND1_to_NAND7#14nmos@139_poly-right##55 9.898
R7370 NAND1_to_NAND7#14nmos@139_poly-right##55 NAND1_to_NAND7#11pmos@139_poly-right 9.898
R7371 NAND2_to_Nand7 NAND2_to_Nand7#4nmos@137_diff-bottom 4.42
R7372 A3 A3##0 7.79
C550 A3##0 0 10.028fF
R7373 A3##0 A3##1 7.79
C551 A3##1 0 10.028fF
R7374 A3##1 A3##2 7.79
C552 A3##2 0 10.028fF
R7375 A3##2 A3#1pin@681_metal-2 7.79
R7376 B3 B3##0 7.767
C553 B3##0 0 9.999fF
R7377 B3##0 B3##1 7.767
C554 B3##1 0 9.999fF
R7378 B3##1 B3##2 7.767
C555 B3##2 0 9.999fF
R7379 B3##2 B3#1pin@683_metal-2 7.767
R7380 B4 B4##0 8.523
C556 B4##0 0 11.428fF
R7381 B4##0 B4##1 8.523
C557 B4##1 0 11.428fF
R7382 B4##1 B4##2 8.523
C558 B4##2 0 11.428fF
R7383 B4##2 B4##3 8.523
C559 B4##3 0 11.428fF
R7384 B4##3 B4#1pin@769_metal-2 8.523
R7385 A4 A4##0 8.541
C560 A4##0 0 11.452fF
R7386 A4##0 A4##1 8.541
C561 A4##1 0 11.452fF
R7387 A4##1 A4##2 8.541
C562 A4##2 0 11.452fF
R7388 A4##2 A4##3 8.541
C563 A4##3 0 11.452fF
R7389 A4##3 A4#1pin@767_metal-2 8.541
R7390 XOR1_to_NAND6#7pmos@154_poly-right XOR1_to_NAND6#7pmos@154_poly-right##0 6.2
R7391 XOR1_to_NAND6#7pmos@154_poly-right##0 XOR1_to_NAND6#8pin@868_polysilicon-1 6.2
R7392 Cin_to_XOR2___NAND6#12pin@872_polysilicon-1 Cin_to_XOR2___NAND6#12pin@872_polysilicon-1##0 9.688
R7393 Cin_to_XOR2___NAND6#12pin@872_polysilicon-1##0 Cin_to_XOR2___NAND6#12pin@872_polysilicon-1##1 9.688
R7394 Cin_to_XOR2___NAND6#12pin@872_polysilicon-1##1 Cin_to_XOR2___NAND6#12pin@872_polysilicon-1##2 9.688
R7395 Cin_to_XOR2___NAND6#12pin@872_polysilicon-1##2 Cin_to_XOR2___NAND6#9contact@983_metal-1-metal-2 9.688
R7396 Cin_to_XOR2___NAND6#9contact@983_metal-1-metal-2 Cin_to_XOR2___NAND6 4.953
R7397 A5#0contact@992_metal-1-metal-2 A5#0contact@992_metal-1-metal-2##0 6.717
R7398 A5#0contact@992_metal-1-metal-2##0 A5#0contact@992_metal-1-metal-2##1 6.717
R7399 A5#0contact@992_metal-1-metal-2##1 A5#4pin@875_polysilicon-1 6.717
R7400 A5#5pmos@156_poly-right A5#5pmos@156_poly-right##0 9.558
R7401 A5#5pmos@156_poly-right##0 A5#5pmos@156_poly-right##1 9.558
R7402 A5#5pmos@156_poly-right##1 A5#5pmos@156_poly-right##2 9.558
R7403 A5#5pmos@156_poly-right##2 A5#5pmos@156_poly-right##3 9.558
R7404 A5#5pmos@156_poly-right##3 A5#5pmos@156_poly-right##4 9.558
R7405 A5#5pmos@156_poly-right##4 A5#4pin@875_polysilicon-1 9.558
R7406 B5#9pin@879_polysilicon-1 B5#9pin@879_polysilicon-1##0 8.138
R7407 B5#9pin@879_polysilicon-1##0 B5#9pin@879_polysilicon-1##1 8.138
R7408 B5#9pin@879_polysilicon-1##1 B5#9pin@879_polysilicon-1##2 8.138
R7409 B5#9pin@879_polysilicon-1##2 B5#0contact@993_metal-1-metal-2 8.138
R7410 B5#10nmos@144_poly-right B5#10nmos@144_poly-right##0 5.425
R7411 B5#10nmos@144_poly-right##0 B5#11pin@829_polysilicon-1 5.425
R7412 NAND2_to_Nand8 NAND2_to_Nand8##0 6.717
R7413 NAND2_to_Nand8##0 NAND2_to_Nand8##1 6.717
R7414 NAND2_to_Nand8##1 NAND2_to_Nand8#9pin@881_polysilicon-1 6.717
R7415 NAND2_to_Nand8#10pmos@158_poly-right NAND2_to_Nand8#10pmos@158_poly-right##0 9.558
R7416 NAND2_to_Nand8#10pmos@158_poly-right##0 NAND2_to_Nand8#10pmos@158_poly-right##1 9.558
R7417 NAND2_to_Nand8#10pmos@158_poly-right##1 NAND2_to_Nand8#10pmos@158_poly-right##2 9.558
R7418 NAND2_to_Nand8#10pmos@158_poly-right##2 NAND2_to_Nand8#10pmos@158_poly-right##3 9.558
R7419 NAND2_to_Nand8#10pmos@158_poly-right##3 NAND2_to_Nand8#10pmos@158_poly-right##4 9.558
R7420 NAND2_to_Nand8#10pmos@158_poly-right##4 NAND2_to_Nand8#9pin@881_polysilicon-1 9.558
R7421 B5#1pin@880_metal-2 B5#1pin@880_metal-2##0 8.99
R7422 B5#1pin@880_metal-2##0 B5#1pin@880_metal-2##1 8.99
R7423 B5#1pin@880_metal-2##1 B5#1pin@880_metal-2##2 8.99
R7424 B5#1pin@880_metal-2##2 B5#1pin@880_metal-2##3 8.99
R7425 B5#1pin@880_metal-2##3 B5#11pin@829_polysilicon-1 8.99
R7426 NAND1_to_NAND8#8pmos@159_poly-right NAND1_to_NAND8#8pmos@159_poly-right##0 5.425
R7427 NAND1_to_NAND8#8pmos@159_poly-right##0 NAND1_to_NAND8#9pin@885_polysilicon-1 5.425
R7428 NAND1_to_NAND8#9pin@885_polysilicon-1 NAND1_to_NAND8#9pin@885_polysilicon-1##0 9.3
R7429 NAND1_to_NAND8#9pin@885_polysilicon-1##0 NAND1_to_NAND8#9pin@885_polysilicon-1##1 9.3
R7430 NAND1_to_NAND8#9pin@885_polysilicon-1##1 NAND1_to_NAND8 9.3
R7431 Cin_to_XOR2___NAND6#19nmos@155_poly-right Cin_to_XOR2___NAND6#19nmos@155_poly-right##0 8.636
R7432 Cin_to_XOR2___NAND6#19nmos@155_poly-right##0 Cin_to_XOR2___NAND6#19nmos@155_poly-right##1 8.636
R7433 Cin_to_XOR2___NAND6#19nmos@155_poly-right##1 Cin_to_XOR2___NAND6#19nmos@155_poly-right##2 8.636
R7434 Cin_to_XOR2___NAND6#19nmos@155_poly-right##2 Cin_to_XOR2___NAND6#19nmos@155_poly-right##3 8.636
R7435 Cin_to_XOR2___NAND6#19nmos@155_poly-right##3 Cin_to_XOR2___NAND6#19nmos@155_poly-right##4 8.636
R7436 Cin_to_XOR2___NAND6#19nmos@155_poly-right##4 Cin_to_XOR2___NAND6#19nmos@155_poly-right##5 8.636
R7437 Cin_to_XOR2___NAND6#19nmos@155_poly-right##5 Cin_to_XOR2___NAND6#12pin@872_polysilicon-1 8.636
R7438 B5#12nmos@157_poly-right B5#12nmos@157_poly-right##0 8.956
R7439 B5#12nmos@157_poly-right##0 B5#12nmos@157_poly-right##1 8.956
R7440 B5#12nmos@157_poly-right##1 B5#12nmos@157_poly-right##2 8.956
R7441 B5#12nmos@157_poly-right##2 B5#12nmos@157_poly-right##3 8.956
R7442 B5#12nmos@157_poly-right##3 B5#12nmos@157_poly-right##4 8.956
R7443 B5#12nmos@157_poly-right##4 B5#12nmos@157_poly-right##5 8.956
R7444 B5#12nmos@157_poly-right##5 B5#12nmos@157_poly-right##6 8.956
R7445 B5#12nmos@157_poly-right##6 B5#12nmos@157_poly-right##7 8.956
R7446 B5#12nmos@157_poly-right##7 B5#9pin@879_polysilicon-1 8.956
R7447 A5#8pmos@140_poly-left A5#8pmos@140_poly-left##0 8.138
R7448 A5#8pmos@140_poly-left##0 A5#8pmos@140_poly-left##1 8.138
R7449 A5#8pmos@140_poly-left##1 A5#8pmos@140_poly-left##2 8.138
R7450 A5#8pmos@140_poly-left##2 A5#9pin@826_polysilicon-1 8.138
R7451 B5#13pin@819_polysilicon-1 B5#13pin@819_polysilicon-1##0 9.843
R7452 B5#13pin@819_polysilicon-1##0 B5#13pin@819_polysilicon-1##1 9.843
R7453 B5#13pin@819_polysilicon-1##1 B5#13pin@819_polysilicon-1##2 9.843
R7454 B5#13pin@819_polysilicon-1##2 B5#13pin@819_polysilicon-1##3 9.843
R7455 B5#13pin@819_polysilicon-1##3 B5#13pin@819_polysilicon-1##4 9.843
R7456 B5#13pin@819_polysilicon-1##4 B5#13pin@819_polysilicon-1##5 9.843
R7457 B5#13pin@819_polysilicon-1##5 B5#13pin@819_polysilicon-1##6 9.843
R7458 B5#13pin@819_polysilicon-1##6 B5#13pin@819_polysilicon-1##7 9.843
R7459 B5#13pin@819_polysilicon-1##7 B5#13pin@819_polysilicon-1##8 9.843
R7460 B5#13pin@819_polysilicon-1##8 B5#13pin@819_polysilicon-1##9 9.843
R7461 B5#13pin@819_polysilicon-1##9 B5#13pin@819_polysilicon-1##10 9.843
R7462 B5#13pin@819_polysilicon-1##10 B5#13pin@819_polysilicon-1##11 9.843
R7463 B5#13pin@819_polysilicon-1##11 B5#13pin@819_polysilicon-1##12 9.843
R7464 B5#13pin@819_polysilicon-1##12 B5#13pin@819_polysilicon-1##13 9.843
R7465 B5#13pin@819_polysilicon-1##13 B5#13pin@819_polysilicon-1##14 9.843
R7466 B5#13pin@819_polysilicon-1##14 B5#13pin@819_polysilicon-1##15 9.843
R7467 B5#13pin@819_polysilicon-1##15 B5#13pin@819_polysilicon-1##16 9.843
R7468 B5#13pin@819_polysilicon-1##16 B5#13pin@819_polysilicon-1##17 9.843
R7469 B5#13pin@819_polysilicon-1##17 B5#13pin@819_polysilicon-1##18 9.843
R7470 B5#13pin@819_polysilicon-1##18 B5#14pin@836_polysilicon-1 9.843
R7471 net@2725#4nmos@146_poly-right net@2725#4nmos@146_poly-right##0 7.233
R7472 net@2725#4nmos@146_poly-right##0 net@2725#4nmos@146_poly-right##1 7.233
R7473 net@2725#4nmos@146_poly-right##1 net@2725#5pin@831_polysilicon-1 7.233
R7474 net@2725#2contact@931_metal-1-polysilicon-1 net@2725#2contact@931_metal-1-polysilicon-1##0 8.99
R7475 net@2725#2contact@931_metal-1-polysilicon-1##0 net@2725#2contact@931_metal-1-polysilicon-1##1 8.99
R7476 net@2725#2contact@931_metal-1-polysilicon-1##1 net@2725#2contact@931_metal-1-polysilicon-1##2 8.99
R7477 net@2725#2contact@931_metal-1-polysilicon-1##2 net@2725#2contact@931_metal-1-polysilicon-1##3 8.99
R7478 net@2725#2contact@931_metal-1-polysilicon-1##3 net@2725#5pin@831_polysilicon-1 8.99
R7479 A5#1pin@878_metal-2 A5#1pin@878_metal-2##0 6.717
R7480 A5#1pin@878_metal-2##0 A5#1pin@878_metal-2##1 6.717
R7481 A5#1pin@878_metal-2##1 A5#11pin@827_polysilicon-1 6.717
R7482 A5#9pin@826_polysilicon-1 A5#9pin@826_polysilicon-1##0 7.75
R7483 A5#9pin@826_polysilicon-1##0 A5#9pin@826_polysilicon-1##1 7.75
R7484 A5#9pin@826_polysilicon-1##1 A5#11pin@827_polysilicon-1 7.75
R7485 B5#14pin@836_polysilicon-1 B5#14pin@836_polysilicon-1##0 9.743
R7486 B5#14pin@836_polysilicon-1##0 B5#14pin@836_polysilicon-1##1 9.743
R7487 B5#14pin@836_polysilicon-1##1 B5#14pin@836_polysilicon-1##2 9.743
R7488 B5#14pin@836_polysilicon-1##2 B5#14pin@836_polysilicon-1##3 9.743
R7489 B5#14pin@836_polysilicon-1##3 B5#14pin@836_polysilicon-1##4 9.743
R7490 B5#14pin@836_polysilicon-1##4 B5#14pin@836_polysilicon-1##5 9.743
R7491 B5#14pin@836_polysilicon-1##5 B5#1pin@880_metal-2 9.743
R7492 net@2742#5pmos@141_poly-left net@2742#5pmos@141_poly-left##0 7.75
R7493 net@2742#5pmos@141_poly-left##0 net@2742#6pin@837_polysilicon-1 7.75
R7494 B5#15nmos@142_poly-left B5#15nmos@142_poly-left##0 6.2
R7495 B5#15nmos@142_poly-left##0 B5#13pin@819_polysilicon-1 6.2
R7496 net@2732#9nmos@143_poly-left net@2732#9nmos@143_poly-left##0 8.37
R7497 net@2732#9nmos@143_poly-left##0 net@2732#9nmos@143_poly-left##1 8.37
R7498 net@2732#9nmos@143_poly-left##1 net@2732#9nmos@143_poly-left##2 8.37
R7499 net@2732#9nmos@143_poly-left##2 net@2732#9nmos@143_poly-left##3 8.37
R7500 net@2732#9nmos@143_poly-left##3 net@2732#2contact@907_metal-1-metal-2 8.37
R7501 A5#13pin@839_polysilicon-1 A5#13pin@839_polysilicon-1##0 9.881
R7502 A5#13pin@839_polysilicon-1##0 A5#13pin@839_polysilicon-1##1 9.881
R7503 A5#13pin@839_polysilicon-1##1 A5#13pin@839_polysilicon-1##2 9.881
R7504 A5#13pin@839_polysilicon-1##2 A5#13pin@839_polysilicon-1##3 9.881
R7505 A5#13pin@839_polysilicon-1##3 A5#13pin@839_polysilicon-1##4 9.881
R7506 A5#13pin@839_polysilicon-1##4 A5#13pin@839_polysilicon-1##5 9.881
R7507 A5#13pin@839_polysilicon-1##5 A5#13pin@839_polysilicon-1##6 9.881
R7508 A5#13pin@839_polysilicon-1##6 A5#13pin@839_polysilicon-1##7 9.881
R7509 A5#13pin@839_polysilicon-1##7 A5#13pin@839_polysilicon-1##8 9.881
R7510 A5#13pin@839_polysilicon-1##8 A5#13pin@839_polysilicon-1##9 9.881
R7511 A5#13pin@839_polysilicon-1##9 A5#13pin@839_polysilicon-1##10 9.881
R7512 A5#13pin@839_polysilicon-1##10 A5#13pin@839_polysilicon-1##11 9.881
R7513 A5#13pin@839_polysilicon-1##11 A5#13pin@839_polysilicon-1##12 9.881
R7514 A5#13pin@839_polysilicon-1##12 A5#13pin@839_polysilicon-1##13 9.881
R7515 A5#13pin@839_polysilicon-1##13 A5#13pin@839_polysilicon-1##14 9.881
R7516 A5#13pin@839_polysilicon-1##14 A5#13pin@839_polysilicon-1##15 9.881
R7517 A5#13pin@839_polysilicon-1##15 A5#13pin@839_polysilicon-1##16 9.881
R7518 A5#13pin@839_polysilicon-1##16 A5#13pin@839_polysilicon-1##17 9.881
R7519 A5#13pin@839_polysilicon-1##17 A5#13pin@839_polysilicon-1##18 9.881
R7520 A5#13pin@839_polysilicon-1##18 A5#13pin@839_polysilicon-1##19 9.881
R7521 A5#13pin@839_polysilicon-1##19 A5#13pin@839_polysilicon-1##20 9.881
R7522 A5#13pin@839_polysilicon-1##20 A5#13pin@839_polysilicon-1##21 9.881
R7523 A5#13pin@839_polysilicon-1##21 A5#13pin@839_polysilicon-1##22 9.881
R7524 A5#13pin@839_polysilicon-1##22 A5#13pin@839_polysilicon-1##23 9.881
R7525 A5#13pin@839_polysilicon-1##23 A5#13pin@839_polysilicon-1##24 9.881
R7526 A5#13pin@839_polysilicon-1##24 A5#13pin@839_polysilicon-1##25 9.881
R7527 A5#13pin@839_polysilicon-1##25 A5#13pin@839_polysilicon-1##26 9.881
R7528 A5#13pin@839_polysilicon-1##26 A5#13pin@839_polysilicon-1##27 9.881
R7529 A5#13pin@839_polysilicon-1##27 A5#13pin@839_polysilicon-1##28 9.881
R7530 A5#13pin@839_polysilicon-1##28 A5#13pin@839_polysilicon-1##29 9.881
R7531 A5#13pin@839_polysilicon-1##29 A5#13pin@839_polysilicon-1##30 9.881
R7532 A5#13pin@839_polysilicon-1##30 A5#13pin@839_polysilicon-1##31 9.881
R7533 A5#13pin@839_polysilicon-1##31 A5#13pin@839_polysilicon-1##32 9.881
R7534 A5#13pin@839_polysilicon-1##32 A5#13pin@839_polysilicon-1##33 9.881
R7535 A5#13pin@839_polysilicon-1##33 A5#13pin@839_polysilicon-1##34 9.881
R7536 A5#13pin@839_polysilicon-1##34 A5#13pin@839_polysilicon-1##35 9.881
R7537 A5#13pin@839_polysilicon-1##35 A5#13pin@839_polysilicon-1##36 9.881
R7538 A5#13pin@839_polysilicon-1##36 A5#13pin@839_polysilicon-1##37 9.881
R7539 A5#13pin@839_polysilicon-1##37 A5#13pin@839_polysilicon-1##38 9.881
R7540 A5#13pin@839_polysilicon-1##38 A5#13pin@839_polysilicon-1##39 9.881
R7541 A5#13pin@839_polysilicon-1##39 A5#13pin@839_polysilicon-1##40 9.881
R7542 A5#13pin@839_polysilicon-1##40 A5#13pin@839_polysilicon-1##41 9.881
R7543 A5#13pin@839_polysilicon-1##41 A5#13pin@839_polysilicon-1##42 9.881
R7544 A5#13pin@839_polysilicon-1##42 A5#13pin@839_polysilicon-1##43 9.881
R7545 A5#13pin@839_polysilicon-1##43 A5#13pin@839_polysilicon-1##44 9.881
R7546 A5#13pin@839_polysilicon-1##44 A5#13pin@839_polysilicon-1##45 9.881
R7547 A5#13pin@839_polysilicon-1##45 A5#13pin@839_polysilicon-1##46 9.881
R7548 A5#13pin@839_polysilicon-1##46 A5#13pin@839_polysilicon-1##47 9.881
R7549 A5#13pin@839_polysilicon-1##47 A5#13pin@839_polysilicon-1##48 9.881
R7550 A5#13pin@839_polysilicon-1##48 A5#13pin@839_polysilicon-1##49 9.881
R7551 A5#13pin@839_polysilicon-1##49 A5#13pin@839_polysilicon-1##50 9.881
R7552 A5#13pin@839_polysilicon-1##50 A5#13pin@839_polysilicon-1##51 9.881
R7553 A5#13pin@839_polysilicon-1##51 A5#13pin@839_polysilicon-1##52 9.881
R7554 A5#13pin@839_polysilicon-1##52 A5#13pin@839_polysilicon-1##53 9.881
R7555 A5#13pin@839_polysilicon-1##53 A5#13pin@839_polysilicon-1##54 9.881
R7556 A5#13pin@839_polysilicon-1##54 A5#14nmos@145_poly-right 9.881
R7557 net@2742#3pmos@145_diff-top net@2742 4.81
R7558 net@2742#9pin@838_polysilicon-1 net@2742#9pin@838_polysilicon-1##0 9.85
R7559 net@2742#9pin@838_polysilicon-1##0 net@2742#9pin@838_polysilicon-1##1 9.85
R7560 net@2742#9pin@838_polysilicon-1##1 net@2742#9pin@838_polysilicon-1##2 9.85
R7561 net@2742#9pin@838_polysilicon-1##2 net@2742#9pin@838_polysilicon-1##3 9.85
R7562 net@2742#9pin@838_polysilicon-1##3 net@2742#9pin@838_polysilicon-1##4 9.85
R7563 net@2742#9pin@838_polysilicon-1##4 net@2742#9pin@838_polysilicon-1##5 9.85
R7564 net@2742#9pin@838_polysilicon-1##5 net@2742#9pin@838_polysilicon-1##6 9.85
R7565 net@2742#9pin@838_polysilicon-1##6 net@2742#9pin@838_polysilicon-1##7 9.85
R7566 net@2742#9pin@838_polysilicon-1##7 net@2742#9pin@838_polysilicon-1##8 9.85
R7567 net@2742#9pin@838_polysilicon-1##8 net@2742#9pin@838_polysilicon-1##9 9.85
R7568 net@2742#9pin@838_polysilicon-1##9 net@2742#9pin@838_polysilicon-1##10 9.85
R7569 net@2742#9pin@838_polysilicon-1##10 net@2742#9pin@838_polysilicon-1##11 9.85
R7570 net@2742#9pin@838_polysilicon-1##11 net@2742#9pin@838_polysilicon-1##12 9.85
R7571 net@2742#9pin@838_polysilicon-1##12 net@2742#9pin@838_polysilicon-1##13 9.85
R7572 net@2742#9pin@838_polysilicon-1##13 net@2742#9pin@838_polysilicon-1##14 9.85
R7573 net@2742#9pin@838_polysilicon-1##14 net@2742#9pin@838_polysilicon-1##15 9.85
R7574 net@2742#9pin@838_polysilicon-1##15 net@2742#9pin@838_polysilicon-1##16 9.85
R7575 net@2742#9pin@838_polysilicon-1##16 net@2742#9pin@838_polysilicon-1##17 9.85
R7576 net@2742#9pin@838_polysilicon-1##17 net@2742#9pin@838_polysilicon-1##18 9.85
R7577 net@2742#9pin@838_polysilicon-1##18 net@2742#9pin@838_polysilicon-1##19 9.85
R7578 net@2742#9pin@838_polysilicon-1##19 net@2742#9pin@838_polysilicon-1##20 9.85
R7579 net@2742#9pin@838_polysilicon-1##20 net@2742#9pin@838_polysilicon-1##21 9.85
R7580 net@2742#9pin@838_polysilicon-1##21 net@2742#9pin@838_polysilicon-1##22 9.85
R7581 net@2742#9pin@838_polysilicon-1##22 net@2742#9pin@838_polysilicon-1##23 9.85
R7582 net@2742#9pin@838_polysilicon-1##23 net@2742#9pin@838_polysilicon-1##24 9.85
R7583 net@2742#9pin@838_polysilicon-1##24 net@2742#9pin@838_polysilicon-1##25 9.85
R7584 net@2742#9pin@838_polysilicon-1##25 net@2742#9pin@838_polysilicon-1##26 9.85
R7585 net@2742#9pin@838_polysilicon-1##26 net@2742#9pin@838_polysilicon-1##27 9.85
R7586 net@2742#9pin@838_polysilicon-1##27 net@2742#9pin@838_polysilicon-1##28 9.85
R7587 net@2742#9pin@838_polysilicon-1##28 net@2742#9pin@838_polysilicon-1##29 9.85
R7588 net@2742#9pin@838_polysilicon-1##29 net@2742#9pin@838_polysilicon-1##30 9.85
R7589 net@2742#9pin@838_polysilicon-1##30 net@2742#9pin@838_polysilicon-1##31 9.85
R7590 net@2742#9pin@838_polysilicon-1##31 net@2742#9pin@838_polysilicon-1##32 9.85
R7591 net@2742#9pin@838_polysilicon-1##32 net@2742#9pin@838_polysilicon-1##33 9.85
R7592 net@2742#9pin@838_polysilicon-1##33 net@2742#9pin@838_polysilicon-1##34 9.85
R7593 net@2742#9pin@838_polysilicon-1##34 net@2742#9pin@838_polysilicon-1##35 9.85
R7594 net@2742#9pin@838_polysilicon-1##35 net@2742#9pin@838_polysilicon-1##36 9.85
R7595 net@2742#9pin@838_polysilicon-1##36 net@2742#9pin@838_polysilicon-1##37 9.85
R7596 net@2742#9pin@838_polysilicon-1##37 net@2742#9pin@838_polysilicon-1##38 9.85
R7597 net@2742#9pin@838_polysilicon-1##38 net@2742#9pin@838_polysilicon-1##39 9.85
R7598 net@2742#9pin@838_polysilicon-1##39 net@2742#9pin@838_polysilicon-1##40 9.85
R7599 net@2742#9pin@838_polysilicon-1##40 net@2742#9pin@838_polysilicon-1##41 9.85
R7600 net@2742#9pin@838_polysilicon-1##41 net@2742#9pin@838_polysilicon-1##42 9.85
R7601 net@2742#9pin@838_polysilicon-1##42 net@2742#9pin@838_polysilicon-1##43 9.85
R7602 net@2742#9pin@838_polysilicon-1##43 net@2742#9pin@838_polysilicon-1##44 9.85
R7603 net@2742#9pin@838_polysilicon-1##44 net@2742#9pin@838_polysilicon-1##45 9.85
R7604 net@2742#9pin@838_polysilicon-1##45 net@2742#9pin@838_polysilicon-1##46 9.85
R7605 net@2742#9pin@838_polysilicon-1##46 net@2742#9pin@838_polysilicon-1##47 9.85
R7606 net@2742#9pin@838_polysilicon-1##47 net@2742#9pin@838_polysilicon-1##48 9.85
R7607 net@2742#9pin@838_polysilicon-1##48 net@2742#9pin@838_polysilicon-1##49 9.85
R7608 net@2742#9pin@838_polysilicon-1##49 net@2742#9pin@838_polysilicon-1##50 9.85
R7609 net@2742#9pin@838_polysilicon-1##50 net@2742#9pin@838_polysilicon-1##51 9.85
R7610 net@2742#9pin@838_polysilicon-1##51 net@2742#9pin@838_polysilicon-1##52 9.85
R7611 net@2742#9pin@838_polysilicon-1##52 net@2742#9pin@838_polysilicon-1##53 9.85
R7612 net@2742#9pin@838_polysilicon-1##53 net@2742#9pin@838_polysilicon-1##54 9.85
R7613 net@2742#9pin@838_polysilicon-1##54 net@2742#9pin@838_polysilicon-1##55 9.85
R7614 net@2742#9pin@838_polysilicon-1##55 net@2742#9pin@838_polysilicon-1##56 9.85
R7615 net@2742#9pin@838_polysilicon-1##56 net@2742#9pin@838_polysilicon-1##57 9.85
R7616 net@2742#9pin@838_polysilicon-1##57 net@2742#9pin@838_polysilicon-1##58 9.85
R7617 net@2742#9pin@838_polysilicon-1##58 net@2742#9pin@838_polysilicon-1##59 9.85
R7618 net@2742#9pin@838_polysilicon-1##59 net@2742#9pin@838_polysilicon-1##60 9.85
R7619 net@2742#9pin@838_polysilicon-1##60 net@2742 9.85
R7620 B5#16pmos@144_poly-right B5#16pmos@144_poly-right##0 9.854
R7621 B5#16pmos@144_poly-right##0 B5#16pmos@144_poly-right##1 9.854
R7622 B5#16pmos@144_poly-right##1 B5#16pmos@144_poly-right##2 9.854
R7623 B5#16pmos@144_poly-right##2 B5#16pmos@144_poly-right##3 9.854
R7624 B5#16pmos@144_poly-right##3 B5#16pmos@144_poly-right##4 9.854
R7625 B5#16pmos@144_poly-right##4 B5#16pmos@144_poly-right##5 9.854
R7626 B5#16pmos@144_poly-right##5 B5#16pmos@144_poly-right##6 9.854
R7627 B5#16pmos@144_poly-right##6 B5#16pmos@144_poly-right##7 9.854
R7628 B5#16pmos@144_poly-right##7 B5#16pmos@144_poly-right##8 9.854
R7629 B5#16pmos@144_poly-right##8 B5#16pmos@144_poly-right##9 9.854
R7630 B5#16pmos@144_poly-right##9 B5#16pmos@144_poly-right##10 9.854
R7631 B5#16pmos@144_poly-right##10 B5#16pmos@144_poly-right##11 9.854
R7632 B5#16pmos@144_poly-right##11 B5#16pmos@144_poly-right##12 9.854
R7633 B5#16pmos@144_poly-right##12 B5#16pmos@144_poly-right##13 9.854
R7634 B5#16pmos@144_poly-right##13 B5#16pmos@144_poly-right##14 9.854
R7635 B5#16pmos@144_poly-right##14 B5#16pmos@144_poly-right##15 9.854
R7636 B5#16pmos@144_poly-right##15 B5#16pmos@144_poly-right##16 9.854
R7637 B5#16pmos@144_poly-right##16 B5#16pmos@144_poly-right##17 9.854
R7638 B5#16pmos@144_poly-right##17 B5#16pmos@144_poly-right##18 9.854
R7639 B5#16pmos@144_poly-right##18 B5#16pmos@144_poly-right##19 9.854
R7640 B5#16pmos@144_poly-right##19 B5#16pmos@144_poly-right##20 9.854
R7641 B5#16pmos@144_poly-right##20 B5#16pmos@144_poly-right##21 9.854
R7642 B5#16pmos@144_poly-right##21 B5#16pmos@144_poly-right##22 9.854
R7643 B5#16pmos@144_poly-right##22 B5#16pmos@144_poly-right##23 9.854
R7644 B5#16pmos@144_poly-right##23 B5#16pmos@144_poly-right##24 9.854
R7645 B5#16pmos@144_poly-right##24 B5#16pmos@144_poly-right##25 9.854
R7646 B5#16pmos@144_poly-right##25 B5#16pmos@144_poly-right##26 9.854
R7647 B5#16pmos@144_poly-right##26 B5#16pmos@144_poly-right##27 9.854
R7648 B5#16pmos@144_poly-right##27 B5#16pmos@144_poly-right##28 9.854
R7649 B5#16pmos@144_poly-right##28 B5#16pmos@144_poly-right##29 9.854
R7650 B5#16pmos@144_poly-right##29 B5#16pmos@144_poly-right##30 9.854
R7651 B5#16pmos@144_poly-right##30 B5#16pmos@144_poly-right##31 9.854
R7652 B5#16pmos@144_poly-right##31 B5#16pmos@144_poly-right##32 9.854
R7653 B5#16pmos@144_poly-right##32 B5#16pmos@144_poly-right##33 9.854
R7654 B5#16pmos@144_poly-right##33 B5#16pmos@144_poly-right##34 9.854
R7655 B5#16pmos@144_poly-right##34 B5#16pmos@144_poly-right##35 9.854
R7656 B5#16pmos@144_poly-right##35 B5#16pmos@144_poly-right##36 9.854
R7657 B5#16pmos@144_poly-right##36 B5#16pmos@144_poly-right##37 9.854
R7658 B5#16pmos@144_poly-right##37 B5#16pmos@144_poly-right##38 9.854
R7659 B5#16pmos@144_poly-right##38 B5#16pmos@144_poly-right##39 9.854
R7660 B5#16pmos@144_poly-right##39 B5#16pmos@144_poly-right##40 9.854
R7661 B5#16pmos@144_poly-right##40 B5#16pmos@144_poly-right##41 9.854
R7662 B5#16pmos@144_poly-right##41 B5#16pmos@144_poly-right##42 9.854
R7663 B5#16pmos@144_poly-right##42 B5#16pmos@144_poly-right##43 9.854
R7664 B5#16pmos@144_poly-right##43 B5#16pmos@144_poly-right##44 9.854
R7665 B5#16pmos@144_poly-right##44 B5#16pmos@144_poly-right##45 9.854
R7666 B5#16pmos@144_poly-right##45 B5#16pmos@144_poly-right##46 9.854
R7667 B5#16pmos@144_poly-right##46 B5#16pmos@144_poly-right##47 9.854
R7668 B5#16pmos@144_poly-right##47 B5#16pmos@144_poly-right##48 9.854
R7669 B5#16pmos@144_poly-right##48 B5#16pmos@144_poly-right##49 9.854
R7670 B5#16pmos@144_poly-right##49 B5#16pmos@144_poly-right##50 9.854
R7671 B5#16pmos@144_poly-right##50 B5#16pmos@144_poly-right##51 9.854
R7672 B5#16pmos@144_poly-right##51 B5#16pmos@144_poly-right##52 9.854
R7673 B5#16pmos@144_poly-right##52 B5#16pmos@144_poly-right##53 9.854
R7674 B5#16pmos@144_poly-right##53 B5#16pmos@144_poly-right##54 9.854
R7675 B5#16pmos@144_poly-right##54 B5#11pin@829_polysilicon-1 9.854
R7676 net@2732 net@2732#2contact@907_metal-1-metal-2 4.797
R7677 A5#15nmos@140_poly-right A5#15nmos@140_poly-right##0 9.871
R7678 A5#15nmos@140_poly-right##0 A5#15nmos@140_poly-right##1 9.871
R7679 A5#15nmos@140_poly-right##1 A5#15nmos@140_poly-right##2 9.871
R7680 A5#15nmos@140_poly-right##2 A5#15nmos@140_poly-right##3 9.871
R7681 A5#15nmos@140_poly-right##3 A5#15nmos@140_poly-right##4 9.871
R7682 A5#15nmos@140_poly-right##4 A5#15nmos@140_poly-right##5 9.871
R7683 A5#15nmos@140_poly-right##5 A5#15nmos@140_poly-right##6 9.871
R7684 A5#15nmos@140_poly-right##6 A5#15nmos@140_poly-right##7 9.871
R7685 A5#15nmos@140_poly-right##7 A5#15nmos@140_poly-right##8 9.871
R7686 A5#15nmos@140_poly-right##8 A5#15nmos@140_poly-right##9 9.871
R7687 A5#15nmos@140_poly-right##9 A5#15nmos@140_poly-right##10 9.871
R7688 A5#15nmos@140_poly-right##10 A5#15nmos@140_poly-right##11 9.871
R7689 A5#15nmos@140_poly-right##11 A5#15nmos@140_poly-right##12 9.871
R7690 A5#15nmos@140_poly-right##12 A5#15nmos@140_poly-right##13 9.871
R7691 A5#15nmos@140_poly-right##13 A5#15nmos@140_poly-right##14 9.871
R7692 A5#15nmos@140_poly-right##14 A5#15nmos@140_poly-right##15 9.871
R7693 A5#15nmos@140_poly-right##15 A5#15nmos@140_poly-right##16 9.871
R7694 A5#15nmos@140_poly-right##16 A5#15nmos@140_poly-right##17 9.871
R7695 A5#15nmos@140_poly-right##17 A5#15nmos@140_poly-right##18 9.871
R7696 A5#15nmos@140_poly-right##18 A5#15nmos@140_poly-right##19 9.871
R7697 A5#15nmos@140_poly-right##19 A5#15nmos@140_poly-right##20 9.871
R7698 A5#15nmos@140_poly-right##20 A5#15nmos@140_poly-right##21 9.871
R7699 A5#15nmos@140_poly-right##21 A5#15nmos@140_poly-right##22 9.871
R7700 A5#15nmos@140_poly-right##22 A5#15nmos@140_poly-right##23 9.871
R7701 A5#15nmos@140_poly-right##23 A5#15nmos@140_poly-right##24 9.871
R7702 A5#15nmos@140_poly-right##24 A5#15nmos@140_poly-right##25 9.871
R7703 A5#15nmos@140_poly-right##25 A5#15nmos@140_poly-right##26 9.871
R7704 A5#15nmos@140_poly-right##26 A5#15nmos@140_poly-right##27 9.871
R7705 A5#15nmos@140_poly-right##27 A5#15nmos@140_poly-right##28 9.871
R7706 A5#15nmos@140_poly-right##28 A5#15nmos@140_poly-right##29 9.871
R7707 A5#15nmos@140_poly-right##29 A5#15nmos@140_poly-right##30 9.871
R7708 A5#15nmos@140_poly-right##30 A5#15nmos@140_poly-right##31 9.871
R7709 A5#15nmos@140_poly-right##31 A5#15nmos@140_poly-right##32 9.871
R7710 A5#15nmos@140_poly-right##32 A5#15nmos@140_poly-right##33 9.871
R7711 A5#15nmos@140_poly-right##33 A5#15nmos@140_poly-right##34 9.871
R7712 A5#15nmos@140_poly-right##34 A5#15nmos@140_poly-right##35 9.871
R7713 A5#15nmos@140_poly-right##35 A5#15nmos@140_poly-right##36 9.871
R7714 A5#15nmos@140_poly-right##36 A5#15nmos@140_poly-right##37 9.871
R7715 A5#15nmos@140_poly-right##37 A5#15nmos@140_poly-right##38 9.871
R7716 A5#15nmos@140_poly-right##38 A5#15nmos@140_poly-right##39 9.871
R7717 A5#15nmos@140_poly-right##39 A5#15nmos@140_poly-right##40 9.871
R7718 A5#15nmos@140_poly-right##40 A5#15nmos@140_poly-right##41 9.871
R7719 A5#15nmos@140_poly-right##41 A5#15nmos@140_poly-right##42 9.871
R7720 A5#15nmos@140_poly-right##42 A5#15nmos@140_poly-right##43 9.871
R7721 A5#15nmos@140_poly-right##43 A5#15nmos@140_poly-right##44 9.871
R7722 A5#15nmos@140_poly-right##44 A5#15nmos@140_poly-right##45 9.871
R7723 A5#15nmos@140_poly-right##45 A5#15nmos@140_poly-right##46 9.871
R7724 A5#15nmos@140_poly-right##46 A5#15nmos@140_poly-right##47 9.871
R7725 A5#15nmos@140_poly-right##47 A5#15nmos@140_poly-right##48 9.871
R7726 A5#15nmos@140_poly-right##48 A5#15nmos@140_poly-right##49 9.871
R7727 A5#15nmos@140_poly-right##49 A5#15nmos@140_poly-right##50 9.871
R7728 A5#15nmos@140_poly-right##50 A5#15nmos@140_poly-right##51 9.871
R7729 A5#15nmos@140_poly-right##51 A5#15nmos@140_poly-right##52 9.871
R7730 A5#15nmos@140_poly-right##52 A5#15nmos@140_poly-right##53 9.871
R7731 A5#15nmos@140_poly-right##53 A5#15nmos@140_poly-right##54 9.871
R7732 A5#15nmos@140_poly-right##54 A5#15nmos@140_poly-right##55 9.871
R7733 A5#15nmos@140_poly-right##55 A5#8pmos@140_poly-left 9.871
R7734 net@2742#5pmos@141_poly-left net@2742#5pmos@141_poly-left##0 9.871
R7735 net@2742#5pmos@141_poly-left##0 net@2742#5pmos@141_poly-left##1 9.871
R7736 net@2742#5pmos@141_poly-left##1 net@2742#5pmos@141_poly-left##2 9.871
R7737 net@2742#5pmos@141_poly-left##2 net@2742#5pmos@141_poly-left##3 9.871
R7738 net@2742#5pmos@141_poly-left##3 net@2742#5pmos@141_poly-left##4 9.871
R7739 net@2742#5pmos@141_poly-left##4 net@2742#5pmos@141_poly-left##5 9.871
R7740 net@2742#5pmos@141_poly-left##5 net@2742#5pmos@141_poly-left##6 9.871
R7741 net@2742#5pmos@141_poly-left##6 net@2742#5pmos@141_poly-left##7 9.871
R7742 net@2742#5pmos@141_poly-left##7 net@2742#5pmos@141_poly-left##8 9.871
R7743 net@2742#5pmos@141_poly-left##8 net@2742#5pmos@141_poly-left##9 9.871
R7744 net@2742#5pmos@141_poly-left##9 net@2742#5pmos@141_poly-left##10 9.871
R7745 net@2742#5pmos@141_poly-left##10 net@2742#5pmos@141_poly-left##11 9.871
R7746 net@2742#5pmos@141_poly-left##11 net@2742#5pmos@141_poly-left##12 9.871
R7747 net@2742#5pmos@141_poly-left##12 net@2742#5pmos@141_poly-left##13 9.871
R7748 net@2742#5pmos@141_poly-left##13 net@2742#5pmos@141_poly-left##14 9.871
R7749 net@2742#5pmos@141_poly-left##14 net@2742#5pmos@141_poly-left##15 9.871
R7750 net@2742#5pmos@141_poly-left##15 net@2742#5pmos@141_poly-left##16 9.871
R7751 net@2742#5pmos@141_poly-left##16 net@2742#5pmos@141_poly-left##17 9.871
R7752 net@2742#5pmos@141_poly-left##17 net@2742#5pmos@141_poly-left##18 9.871
R7753 net@2742#5pmos@141_poly-left##18 net@2742#5pmos@141_poly-left##19 9.871
R7754 net@2742#5pmos@141_poly-left##19 net@2742#5pmos@141_poly-left##20 9.871
R7755 net@2742#5pmos@141_poly-left##20 net@2742#5pmos@141_poly-left##21 9.871
R7756 net@2742#5pmos@141_poly-left##21 net@2742#5pmos@141_poly-left##22 9.871
R7757 net@2742#5pmos@141_poly-left##22 net@2742#5pmos@141_poly-left##23 9.871
R7758 net@2742#5pmos@141_poly-left##23 net@2742#5pmos@141_poly-left##24 9.871
R7759 net@2742#5pmos@141_poly-left##24 net@2742#5pmos@141_poly-left##25 9.871
R7760 net@2742#5pmos@141_poly-left##25 net@2742#5pmos@141_poly-left##26 9.871
R7761 net@2742#5pmos@141_poly-left##26 net@2742#5pmos@141_poly-left##27 9.871
R7762 net@2742#5pmos@141_poly-left##27 net@2742#5pmos@141_poly-left##28 9.871
R7763 net@2742#5pmos@141_poly-left##28 net@2742#5pmos@141_poly-left##29 9.871
R7764 net@2742#5pmos@141_poly-left##29 net@2742#5pmos@141_poly-left##30 9.871
R7765 net@2742#5pmos@141_poly-left##30 net@2742#5pmos@141_poly-left##31 9.871
R7766 net@2742#5pmos@141_poly-left##31 net@2742#5pmos@141_poly-left##32 9.871
R7767 net@2742#5pmos@141_poly-left##32 net@2742#5pmos@141_poly-left##33 9.871
R7768 net@2742#5pmos@141_poly-left##33 net@2742#5pmos@141_poly-left##34 9.871
R7769 net@2742#5pmos@141_poly-left##34 net@2742#5pmos@141_poly-left##35 9.871
R7770 net@2742#5pmos@141_poly-left##35 net@2742#5pmos@141_poly-left##36 9.871
R7771 net@2742#5pmos@141_poly-left##36 net@2742#5pmos@141_poly-left##37 9.871
R7772 net@2742#5pmos@141_poly-left##37 net@2742#5pmos@141_poly-left##38 9.871
R7773 net@2742#5pmos@141_poly-left##38 net@2742#5pmos@141_poly-left##39 9.871
R7774 net@2742#5pmos@141_poly-left##39 net@2742#5pmos@141_poly-left##40 9.871
R7775 net@2742#5pmos@141_poly-left##40 net@2742#5pmos@141_poly-left##41 9.871
R7776 net@2742#5pmos@141_poly-left##41 net@2742#5pmos@141_poly-left##42 9.871
R7777 net@2742#5pmos@141_poly-left##42 net@2742#5pmos@141_poly-left##43 9.871
R7778 net@2742#5pmos@141_poly-left##43 net@2742#5pmos@141_poly-left##44 9.871
R7779 net@2742#5pmos@141_poly-left##44 net@2742#5pmos@141_poly-left##45 9.871
R7780 net@2742#5pmos@141_poly-left##45 net@2742#5pmos@141_poly-left##46 9.871
R7781 net@2742#5pmos@141_poly-left##46 net@2742#5pmos@141_poly-left##47 9.871
R7782 net@2742#5pmos@141_poly-left##47 net@2742#5pmos@141_poly-left##48 9.871
R7783 net@2742#5pmos@141_poly-left##48 net@2742#5pmos@141_poly-left##49 9.871
R7784 net@2742#5pmos@141_poly-left##49 net@2742#5pmos@141_poly-left##50 9.871
R7785 net@2742#5pmos@141_poly-left##50 net@2742#5pmos@141_poly-left##51 9.871
R7786 net@2742#5pmos@141_poly-left##51 net@2742#5pmos@141_poly-left##52 9.871
R7787 net@2742#5pmos@141_poly-left##52 net@2742#5pmos@141_poly-left##53 9.871
R7788 net@2742#5pmos@141_poly-left##53 net@2742#5pmos@141_poly-left##54 9.871
R7789 net@2742#5pmos@141_poly-left##54 net@2742#5pmos@141_poly-left##55 9.871
R7790 net@2742#5pmos@141_poly-left##55 net@2742#11nmos@141_poly-right 9.871
R7791 B5#17pmos@142_poly-right B5#17pmos@142_poly-right##0 9.871
R7792 B5#17pmos@142_poly-right##0 B5#17pmos@142_poly-right##1 9.871
R7793 B5#17pmos@142_poly-right##1 B5#17pmos@142_poly-right##2 9.871
R7794 B5#17pmos@142_poly-right##2 B5#17pmos@142_poly-right##3 9.871
R7795 B5#17pmos@142_poly-right##3 B5#17pmos@142_poly-right##4 9.871
R7796 B5#17pmos@142_poly-right##4 B5#17pmos@142_poly-right##5 9.871
R7797 B5#17pmos@142_poly-right##5 B5#17pmos@142_poly-right##6 9.871
R7798 B5#17pmos@142_poly-right##6 B5#17pmos@142_poly-right##7 9.871
R7799 B5#17pmos@142_poly-right##7 B5#17pmos@142_poly-right##8 9.871
R7800 B5#17pmos@142_poly-right##8 B5#17pmos@142_poly-right##9 9.871
R7801 B5#17pmos@142_poly-right##9 B5#17pmos@142_poly-right##10 9.871
R7802 B5#17pmos@142_poly-right##10 B5#17pmos@142_poly-right##11 9.871
R7803 B5#17pmos@142_poly-right##11 B5#17pmos@142_poly-right##12 9.871
R7804 B5#17pmos@142_poly-right##12 B5#17pmos@142_poly-right##13 9.871
R7805 B5#17pmos@142_poly-right##13 B5#17pmos@142_poly-right##14 9.871
R7806 B5#17pmos@142_poly-right##14 B5#17pmos@142_poly-right##15 9.871
R7807 B5#17pmos@142_poly-right##15 B5#17pmos@142_poly-right##16 9.871
R7808 B5#17pmos@142_poly-right##16 B5#17pmos@142_poly-right##17 9.871
R7809 B5#17pmos@142_poly-right##17 B5#17pmos@142_poly-right##18 9.871
R7810 B5#17pmos@142_poly-right##18 B5#17pmos@142_poly-right##19 9.871
R7811 B5#17pmos@142_poly-right##19 B5#17pmos@142_poly-right##20 9.871
R7812 B5#17pmos@142_poly-right##20 B5#17pmos@142_poly-right##21 9.871
R7813 B5#17pmos@142_poly-right##21 B5#17pmos@142_poly-right##22 9.871
R7814 B5#17pmos@142_poly-right##22 B5#17pmos@142_poly-right##23 9.871
R7815 B5#17pmos@142_poly-right##23 B5#17pmos@142_poly-right##24 9.871
R7816 B5#17pmos@142_poly-right##24 B5#17pmos@142_poly-right##25 9.871
R7817 B5#17pmos@142_poly-right##25 B5#17pmos@142_poly-right##26 9.871
R7818 B5#17pmos@142_poly-right##26 B5#17pmos@142_poly-right##27 9.871
R7819 B5#17pmos@142_poly-right##27 B5#17pmos@142_poly-right##28 9.871
R7820 B5#17pmos@142_poly-right##28 B5#17pmos@142_poly-right##29 9.871
R7821 B5#17pmos@142_poly-right##29 B5#17pmos@142_poly-right##30 9.871
R7822 B5#17pmos@142_poly-right##30 B5#17pmos@142_poly-right##31 9.871
R7823 B5#17pmos@142_poly-right##31 B5#17pmos@142_poly-right##32 9.871
R7824 B5#17pmos@142_poly-right##32 B5#17pmos@142_poly-right##33 9.871
R7825 B5#17pmos@142_poly-right##33 B5#17pmos@142_poly-right##34 9.871
R7826 B5#17pmos@142_poly-right##34 B5#17pmos@142_poly-right##35 9.871
R7827 B5#17pmos@142_poly-right##35 B5#17pmos@142_poly-right##36 9.871
R7828 B5#17pmos@142_poly-right##36 B5#17pmos@142_poly-right##37 9.871
R7829 B5#17pmos@142_poly-right##37 B5#17pmos@142_poly-right##38 9.871
R7830 B5#17pmos@142_poly-right##38 B5#17pmos@142_poly-right##39 9.871
R7831 B5#17pmos@142_poly-right##39 B5#17pmos@142_poly-right##40 9.871
R7832 B5#17pmos@142_poly-right##40 B5#17pmos@142_poly-right##41 9.871
R7833 B5#17pmos@142_poly-right##41 B5#17pmos@142_poly-right##42 9.871
R7834 B5#17pmos@142_poly-right##42 B5#17pmos@142_poly-right##43 9.871
R7835 B5#17pmos@142_poly-right##43 B5#17pmos@142_poly-right##44 9.871
R7836 B5#17pmos@142_poly-right##44 B5#17pmos@142_poly-right##45 9.871
R7837 B5#17pmos@142_poly-right##45 B5#17pmos@142_poly-right##46 9.871
R7838 B5#17pmos@142_poly-right##46 B5#17pmos@142_poly-right##47 9.871
R7839 B5#17pmos@142_poly-right##47 B5#17pmos@142_poly-right##48 9.871
R7840 B5#17pmos@142_poly-right##48 B5#17pmos@142_poly-right##49 9.871
R7841 B5#17pmos@142_poly-right##49 B5#17pmos@142_poly-right##50 9.871
R7842 B5#17pmos@142_poly-right##50 B5#17pmos@142_poly-right##51 9.871
R7843 B5#17pmos@142_poly-right##51 B5#17pmos@142_poly-right##52 9.871
R7844 B5#17pmos@142_poly-right##52 B5#17pmos@142_poly-right##53 9.871
R7845 B5#17pmos@142_poly-right##53 B5#17pmos@142_poly-right##54 9.871
R7846 B5#17pmos@142_poly-right##54 B5#17pmos@142_poly-right##55 9.871
R7847 B5#17pmos@142_poly-right##55 B5#15nmos@142_poly-left 9.871
R7848 net@2732#14pmos@143_poly-right net@2732#14pmos@143_poly-right##0 9.871
R7849 net@2732#14pmos@143_poly-right##0 net@2732#14pmos@143_poly-right##1 9.871
R7850 net@2732#14pmos@143_poly-right##1 net@2732#14pmos@143_poly-right##2 9.871
R7851 net@2732#14pmos@143_poly-right##2 net@2732#14pmos@143_poly-right##3 9.871
R7852 net@2732#14pmos@143_poly-right##3 net@2732#14pmos@143_poly-right##4 9.871
R7853 net@2732#14pmos@143_poly-right##4 net@2732#14pmos@143_poly-right##5 9.871
R7854 net@2732#14pmos@143_poly-right##5 net@2732#14pmos@143_poly-right##6 9.871
R7855 net@2732#14pmos@143_poly-right##6 net@2732#14pmos@143_poly-right##7 9.871
R7856 net@2732#14pmos@143_poly-right##7 net@2732#14pmos@143_poly-right##8 9.871
R7857 net@2732#14pmos@143_poly-right##8 net@2732#14pmos@143_poly-right##9 9.871
R7858 net@2732#14pmos@143_poly-right##9 net@2732#14pmos@143_poly-right##10 9.871
R7859 net@2732#14pmos@143_poly-right##10 net@2732#14pmos@143_poly-right##11 9.871
R7860 net@2732#14pmos@143_poly-right##11 net@2732#14pmos@143_poly-right##12 9.871
R7861 net@2732#14pmos@143_poly-right##12 net@2732#14pmos@143_poly-right##13 9.871
R7862 net@2732#14pmos@143_poly-right##13 net@2732#14pmos@143_poly-right##14 9.871
R7863 net@2732#14pmos@143_poly-right##14 net@2732#14pmos@143_poly-right##15 9.871
R7864 net@2732#14pmos@143_poly-right##15 net@2732#14pmos@143_poly-right##16 9.871
R7865 net@2732#14pmos@143_poly-right##16 net@2732#14pmos@143_poly-right##17 9.871
R7866 net@2732#14pmos@143_poly-right##17 net@2732#14pmos@143_poly-right##18 9.871
R7867 net@2732#14pmos@143_poly-right##18 net@2732#14pmos@143_poly-right##19 9.871
R7868 net@2732#14pmos@143_poly-right##19 net@2732#14pmos@143_poly-right##20 9.871
R7869 net@2732#14pmos@143_poly-right##20 net@2732#14pmos@143_poly-right##21 9.871
R7870 net@2732#14pmos@143_poly-right##21 net@2732#14pmos@143_poly-right##22 9.871
R7871 net@2732#14pmos@143_poly-right##22 net@2732#14pmos@143_poly-right##23 9.871
R7872 net@2732#14pmos@143_poly-right##23 net@2732#14pmos@143_poly-right##24 9.871
R7873 net@2732#14pmos@143_poly-right##24 net@2732#14pmos@143_poly-right##25 9.871
R7874 net@2732#14pmos@143_poly-right##25 net@2732#14pmos@143_poly-right##26 9.871
R7875 net@2732#14pmos@143_poly-right##26 net@2732#14pmos@143_poly-right##27 9.871
R7876 net@2732#14pmos@143_poly-right##27 net@2732#14pmos@143_poly-right##28 9.871
R7877 net@2732#14pmos@143_poly-right##28 net@2732#14pmos@143_poly-right##29 9.871
R7878 net@2732#14pmos@143_poly-right##29 net@2732#14pmos@143_poly-right##30 9.871
R7879 net@2732#14pmos@143_poly-right##30 net@2732#14pmos@143_poly-right##31 9.871
R7880 net@2732#14pmos@143_poly-right##31 net@2732#14pmos@143_poly-right##32 9.871
R7881 net@2732#14pmos@143_poly-right##32 net@2732#14pmos@143_poly-right##33 9.871
R7882 net@2732#14pmos@143_poly-right##33 net@2732#14pmos@143_poly-right##34 9.871
R7883 net@2732#14pmos@143_poly-right##34 net@2732#14pmos@143_poly-right##35 9.871
R7884 net@2732#14pmos@143_poly-right##35 net@2732#14pmos@143_poly-right##36 9.871
R7885 net@2732#14pmos@143_poly-right##36 net@2732#14pmos@143_poly-right##37 9.871
R7886 net@2732#14pmos@143_poly-right##37 net@2732#14pmos@143_poly-right##38 9.871
R7887 net@2732#14pmos@143_poly-right##38 net@2732#14pmos@143_poly-right##39 9.871
R7888 net@2732#14pmos@143_poly-right##39 net@2732#14pmos@143_poly-right##40 9.871
R7889 net@2732#14pmos@143_poly-right##40 net@2732#14pmos@143_poly-right##41 9.871
R7890 net@2732#14pmos@143_poly-right##41 net@2732#14pmos@143_poly-right##42 9.871
R7891 net@2732#14pmos@143_poly-right##42 net@2732#14pmos@143_poly-right##43 9.871
R7892 net@2732#14pmos@143_poly-right##43 net@2732#14pmos@143_poly-right##44 9.871
R7893 net@2732#14pmos@143_poly-right##44 net@2732#14pmos@143_poly-right##45 9.871
R7894 net@2732#14pmos@143_poly-right##45 net@2732#14pmos@143_poly-right##46 9.871
R7895 net@2732#14pmos@143_poly-right##46 net@2732#14pmos@143_poly-right##47 9.871
R7896 net@2732#14pmos@143_poly-right##47 net@2732#14pmos@143_poly-right##48 9.871
R7897 net@2732#14pmos@143_poly-right##48 net@2732#14pmos@143_poly-right##49 9.871
R7898 net@2732#14pmos@143_poly-right##49 net@2732#14pmos@143_poly-right##50 9.871
R7899 net@2732#14pmos@143_poly-right##50 net@2732#14pmos@143_poly-right##51 9.871
R7900 net@2732#14pmos@143_poly-right##51 net@2732#14pmos@143_poly-right##52 9.871
R7901 net@2732#14pmos@143_poly-right##52 net@2732#14pmos@143_poly-right##53 9.871
R7902 net@2732#14pmos@143_poly-right##53 net@2732#14pmos@143_poly-right##54 9.871
R7903 net@2732#14pmos@143_poly-right##54 net@2732#14pmos@143_poly-right##55 9.871
R7904 net@2732#14pmos@143_poly-right##55 net@2732#9nmos@143_poly-left 9.871
R7905 Cin_to_XOR2___NAND6#20nmos@151_poly-right Cin_to_XOR2___NAND6#20nmos@151_poly-right##0 5.425
R7906 Cin_to_XOR2___NAND6#20nmos@151_poly-right##0 Cin_to_XOR2___NAND6#21pin@854_polysilicon-1 5.425
R7907 net@2725#2contact@931_metal-1-polysilicon-1 net@2725 4.706
R7908 net@2725#12pmos@146_poly-right net@2725#12pmos@146_poly-right##0 9.864
R7909 net@2725#12pmos@146_poly-right##0 net@2725#12pmos@146_poly-right##1 9.864
R7910 net@2725#12pmos@146_poly-right##1 net@2725#12pmos@146_poly-right##2 9.864
R7911 net@2725#12pmos@146_poly-right##2 net@2725#12pmos@146_poly-right##3 9.864
R7912 net@2725#12pmos@146_poly-right##3 net@2725#12pmos@146_poly-right##4 9.864
R7913 net@2725#12pmos@146_poly-right##4 net@2725#12pmos@146_poly-right##5 9.864
R7914 net@2725#12pmos@146_poly-right##5 net@2725#12pmos@146_poly-right##6 9.864
R7915 net@2725#12pmos@146_poly-right##6 net@2725#12pmos@146_poly-right##7 9.864
R7916 net@2725#12pmos@146_poly-right##7 net@2725#12pmos@146_poly-right##8 9.864
R7917 net@2725#12pmos@146_poly-right##8 net@2725#12pmos@146_poly-right##9 9.864
R7918 net@2725#12pmos@146_poly-right##9 net@2725#12pmos@146_poly-right##10 9.864
R7919 net@2725#12pmos@146_poly-right##10 net@2725#12pmos@146_poly-right##11 9.864
R7920 net@2725#12pmos@146_poly-right##11 net@2725#12pmos@146_poly-right##12 9.864
R7921 net@2725#12pmos@146_poly-right##12 net@2725#12pmos@146_poly-right##13 9.864
R7922 net@2725#12pmos@146_poly-right##13 net@2725#12pmos@146_poly-right##14 9.864
R7923 net@2725#12pmos@146_poly-right##14 net@2725#12pmos@146_poly-right##15 9.864
R7924 net@2725#12pmos@146_poly-right##15 net@2725#12pmos@146_poly-right##16 9.864
R7925 net@2725#12pmos@146_poly-right##16 net@2725#12pmos@146_poly-right##17 9.864
R7926 net@2725#12pmos@146_poly-right##17 net@2725#12pmos@146_poly-right##18 9.864
R7927 net@2725#12pmos@146_poly-right##18 net@2725#12pmos@146_poly-right##19 9.864
R7928 net@2725#12pmos@146_poly-right##19 net@2725#12pmos@146_poly-right##20 9.864
R7929 net@2725#12pmos@146_poly-right##20 net@2725#12pmos@146_poly-right##21 9.864
R7930 net@2725#12pmos@146_poly-right##21 net@2725#12pmos@146_poly-right##22 9.864
R7931 net@2725#12pmos@146_poly-right##22 net@2725#12pmos@146_poly-right##23 9.864
R7932 net@2725#12pmos@146_poly-right##23 net@2725#12pmos@146_poly-right##24 9.864
R7933 net@2725#12pmos@146_poly-right##24 net@2725#12pmos@146_poly-right##25 9.864
R7934 net@2725#12pmos@146_poly-right##25 net@2725#12pmos@146_poly-right##26 9.864
R7935 net@2725#12pmos@146_poly-right##26 net@2725#12pmos@146_poly-right##27 9.864
R7936 net@2725#12pmos@146_poly-right##27 net@2725#12pmos@146_poly-right##28 9.864
R7937 net@2725#12pmos@146_poly-right##28 net@2725#12pmos@146_poly-right##29 9.864
R7938 net@2725#12pmos@146_poly-right##29 net@2725#12pmos@146_poly-right##30 9.864
R7939 net@2725#12pmos@146_poly-right##30 net@2725#12pmos@146_poly-right##31 9.864
R7940 net@2725#12pmos@146_poly-right##31 net@2725#12pmos@146_poly-right##32 9.864
R7941 net@2725#12pmos@146_poly-right##32 net@2725#12pmos@146_poly-right##33 9.864
R7942 net@2725#12pmos@146_poly-right##33 net@2725#12pmos@146_poly-right##34 9.864
R7943 net@2725#12pmos@146_poly-right##34 net@2725#12pmos@146_poly-right##35 9.864
R7944 net@2725#12pmos@146_poly-right##35 net@2725#12pmos@146_poly-right##36 9.864
R7945 net@2725#12pmos@146_poly-right##36 net@2725#12pmos@146_poly-right##37 9.864
R7946 net@2725#12pmos@146_poly-right##37 net@2725#12pmos@146_poly-right##38 9.864
R7947 net@2725#12pmos@146_poly-right##38 net@2725#12pmos@146_poly-right##39 9.864
R7948 net@2725#12pmos@146_poly-right##39 net@2725#12pmos@146_poly-right##40 9.864
R7949 net@2725#12pmos@146_poly-right##40 net@2725#12pmos@146_poly-right##41 9.864
R7950 net@2725#12pmos@146_poly-right##41 net@2725#12pmos@146_poly-right##42 9.864
R7951 net@2725#12pmos@146_poly-right##42 net@2725#12pmos@146_poly-right##43 9.864
R7952 net@2725#12pmos@146_poly-right##43 net@2725#12pmos@146_poly-right##44 9.864
R7953 net@2725#12pmos@146_poly-right##44 net@2725#12pmos@146_poly-right##45 9.864
R7954 net@2725#12pmos@146_poly-right##45 net@2725#12pmos@146_poly-right##46 9.864
R7955 net@2725#12pmos@146_poly-right##46 net@2725#12pmos@146_poly-right##47 9.864
R7956 net@2725#12pmos@146_poly-right##47 net@2725#12pmos@146_poly-right##48 9.864
R7957 net@2725#12pmos@146_poly-right##48 net@2725#12pmos@146_poly-right##49 9.864
R7958 net@2725#12pmos@146_poly-right##49 net@2725#12pmos@146_poly-right##50 9.864
R7959 net@2725#12pmos@146_poly-right##50 net@2725#12pmos@146_poly-right##51 9.864
R7960 net@2725#12pmos@146_poly-right##51 net@2725#12pmos@146_poly-right##52 9.864
R7961 net@2725#12pmos@146_poly-right##52 net@2725#12pmos@146_poly-right##53 9.864
R7962 net@2725#12pmos@146_poly-right##53 net@2725#5pin@831_polysilicon-1 9.864
R7963 XOR1_to_NAND6#15pmos@146_diff-top XOR1_to_NAND6#1contact@984_metal-1-metal-2 4.862
R7964 XOR1_to_NAND6#18pin@864_polysilicon-1 XOR1_to_NAND6#18pin@864_polysilicon-1##0 9.881
R7965 XOR1_to_NAND6#18pin@864_polysilicon-1##0 XOR1_to_NAND6#18pin@864_polysilicon-1##1 9.881
R7966 XOR1_to_NAND6#18pin@864_polysilicon-1##1 XOR1_to_NAND6#18pin@864_polysilicon-1##2 9.881
R7967 XOR1_to_NAND6#18pin@864_polysilicon-1##2 XOR1_to_NAND6#18pin@864_polysilicon-1##3 9.881
R7968 XOR1_to_NAND6#18pin@864_polysilicon-1##3 XOR1_to_NAND6#18pin@864_polysilicon-1##4 9.881
R7969 XOR1_to_NAND6#18pin@864_polysilicon-1##4 XOR1_to_NAND6#18pin@864_polysilicon-1##5 9.881
R7970 XOR1_to_NAND6#18pin@864_polysilicon-1##5 XOR1_to_NAND6#18pin@864_polysilicon-1##6 9.881
R7971 XOR1_to_NAND6#18pin@864_polysilicon-1##6 XOR1_to_NAND6#18pin@864_polysilicon-1##7 9.881
R7972 XOR1_to_NAND6#18pin@864_polysilicon-1##7 XOR1_to_NAND6#18pin@864_polysilicon-1##8 9.881
R7973 XOR1_to_NAND6#18pin@864_polysilicon-1##8 XOR1_to_NAND6#18pin@864_polysilicon-1##9 9.881
R7974 XOR1_to_NAND6#18pin@864_polysilicon-1##9 XOR1_to_NAND6#18pin@864_polysilicon-1##10 9.881
R7975 XOR1_to_NAND6#18pin@864_polysilicon-1##10 XOR1_to_NAND6#18pin@864_polysilicon-1##11 9.881
R7976 XOR1_to_NAND6#18pin@864_polysilicon-1##11 XOR1_to_NAND6#18pin@864_polysilicon-1##12 9.881
R7977 XOR1_to_NAND6#18pin@864_polysilicon-1##12 XOR1_to_NAND6#18pin@864_polysilicon-1##13 9.881
R7978 XOR1_to_NAND6#18pin@864_polysilicon-1##13 XOR1_to_NAND6#18pin@864_polysilicon-1##14 9.881
R7979 XOR1_to_NAND6#18pin@864_polysilicon-1##14 XOR1_to_NAND6#18pin@864_polysilicon-1##15 9.881
R7980 XOR1_to_NAND6#18pin@864_polysilicon-1##15 XOR1_to_NAND6#18pin@864_polysilicon-1##16 9.881
R7981 XOR1_to_NAND6#18pin@864_polysilicon-1##16 XOR1_to_NAND6#18pin@864_polysilicon-1##17 9.881
R7982 XOR1_to_NAND6#18pin@864_polysilicon-1##17 XOR1_to_NAND6#18pin@864_polysilicon-1##18 9.881
R7983 XOR1_to_NAND6#18pin@864_polysilicon-1##18 XOR1_to_NAND6#18pin@864_polysilicon-1##19 9.881
R7984 XOR1_to_NAND6#18pin@864_polysilicon-1##19 XOR1_to_NAND6#18pin@864_polysilicon-1##20 9.881
R7985 XOR1_to_NAND6#18pin@864_polysilicon-1##20 XOR1_to_NAND6#18pin@864_polysilicon-1##21 9.881
R7986 XOR1_to_NAND6#18pin@864_polysilicon-1##21 XOR1_to_NAND6#18pin@864_polysilicon-1##22 9.881
R7987 XOR1_to_NAND6#18pin@864_polysilicon-1##22 XOR1_to_NAND6#18pin@864_polysilicon-1##23 9.881
R7988 XOR1_to_NAND6#18pin@864_polysilicon-1##23 XOR1_to_NAND6#18pin@864_polysilicon-1##24 9.881
R7989 XOR1_to_NAND6#18pin@864_polysilicon-1##24 XOR1_to_NAND6#18pin@864_polysilicon-1##25 9.881
R7990 XOR1_to_NAND6#18pin@864_polysilicon-1##25 XOR1_to_NAND6#18pin@864_polysilicon-1##26 9.881
R7991 XOR1_to_NAND6#18pin@864_polysilicon-1##26 XOR1_to_NAND6#18pin@864_polysilicon-1##27 9.881
R7992 XOR1_to_NAND6#18pin@864_polysilicon-1##27 XOR1_to_NAND6#18pin@864_polysilicon-1##28 9.881
R7993 XOR1_to_NAND6#18pin@864_polysilicon-1##28 XOR1_to_NAND6#18pin@864_polysilicon-1##29 9.881
R7994 XOR1_to_NAND6#18pin@864_polysilicon-1##29 XOR1_to_NAND6#18pin@864_polysilicon-1##30 9.881
R7995 XOR1_to_NAND6#18pin@864_polysilicon-1##30 XOR1_to_NAND6#18pin@864_polysilicon-1##31 9.881
R7996 XOR1_to_NAND6#18pin@864_polysilicon-1##31 XOR1_to_NAND6#18pin@864_polysilicon-1##32 9.881
R7997 XOR1_to_NAND6#18pin@864_polysilicon-1##32 XOR1_to_NAND6#18pin@864_polysilicon-1##33 9.881
R7998 XOR1_to_NAND6#18pin@864_polysilicon-1##33 XOR1_to_NAND6#18pin@864_polysilicon-1##34 9.881
R7999 XOR1_to_NAND6#18pin@864_polysilicon-1##34 XOR1_to_NAND6#18pin@864_polysilicon-1##35 9.881
R8000 XOR1_to_NAND6#18pin@864_polysilicon-1##35 XOR1_to_NAND6#18pin@864_polysilicon-1##36 9.881
R8001 XOR1_to_NAND6#18pin@864_polysilicon-1##36 XOR1_to_NAND6#18pin@864_polysilicon-1##37 9.881
R8002 XOR1_to_NAND6#18pin@864_polysilicon-1##37 XOR1_to_NAND6#18pin@864_polysilicon-1##38 9.881
R8003 XOR1_to_NAND6#18pin@864_polysilicon-1##38 XOR1_to_NAND6#18pin@864_polysilicon-1##39 9.881
R8004 XOR1_to_NAND6#18pin@864_polysilicon-1##39 XOR1_to_NAND6#18pin@864_polysilicon-1##40 9.881
R8005 XOR1_to_NAND6#18pin@864_polysilicon-1##40 XOR1_to_NAND6#18pin@864_polysilicon-1##41 9.881
R8006 XOR1_to_NAND6#18pin@864_polysilicon-1##41 XOR1_to_NAND6#18pin@864_polysilicon-1##42 9.881
R8007 XOR1_to_NAND6#18pin@864_polysilicon-1##42 XOR1_to_NAND6#18pin@864_polysilicon-1##43 9.881
R8008 XOR1_to_NAND6#18pin@864_polysilicon-1##43 XOR1_to_NAND6#18pin@864_polysilicon-1##44 9.881
R8009 XOR1_to_NAND6#18pin@864_polysilicon-1##44 XOR1_to_NAND6#18pin@864_polysilicon-1##45 9.881
R8010 XOR1_to_NAND6#18pin@864_polysilicon-1##45 XOR1_to_NAND6#18pin@864_polysilicon-1##46 9.881
R8011 XOR1_to_NAND6#18pin@864_polysilicon-1##46 XOR1_to_NAND6#18pin@864_polysilicon-1##47 9.881
R8012 XOR1_to_NAND6#18pin@864_polysilicon-1##47 XOR1_to_NAND6#18pin@864_polysilicon-1##48 9.881
R8013 XOR1_to_NAND6#18pin@864_polysilicon-1##48 XOR1_to_NAND6#18pin@864_polysilicon-1##49 9.881
R8014 XOR1_to_NAND6#18pin@864_polysilicon-1##49 XOR1_to_NAND6#18pin@864_polysilicon-1##50 9.881
R8015 XOR1_to_NAND6#18pin@864_polysilicon-1##50 XOR1_to_NAND6#18pin@864_polysilicon-1##51 9.881
R8016 XOR1_to_NAND6#18pin@864_polysilicon-1##51 XOR1_to_NAND6#18pin@864_polysilicon-1##52 9.881
R8017 XOR1_to_NAND6#18pin@864_polysilicon-1##52 XOR1_to_NAND6#18pin@864_polysilicon-1##53 9.881
R8018 XOR1_to_NAND6#18pin@864_polysilicon-1##53 XOR1_to_NAND6#18pin@864_polysilicon-1##54 9.881
R8019 XOR1_to_NAND6#18pin@864_polysilicon-1##54 XOR1_to_NAND6#19nmos@152_poly-right 9.881
R8020 net@2789#3contact@960_metal-1-p-act net@2789 4.81
R8021 net@2789#4pin@863_polysilicon-1 net@2789#4pin@863_polysilicon-1##0 9.85
R8022 net@2789#4pin@863_polysilicon-1##0 net@2789#4pin@863_polysilicon-1##1 9.85
R8023 net@2789#4pin@863_polysilicon-1##1 net@2789#4pin@863_polysilicon-1##2 9.85
R8024 net@2789#4pin@863_polysilicon-1##2 net@2789#4pin@863_polysilicon-1##3 9.85
R8025 net@2789#4pin@863_polysilicon-1##3 net@2789#4pin@863_polysilicon-1##4 9.85
R8026 net@2789#4pin@863_polysilicon-1##4 net@2789#4pin@863_polysilicon-1##5 9.85
R8027 net@2789#4pin@863_polysilicon-1##5 net@2789#4pin@863_polysilicon-1##6 9.85
R8028 net@2789#4pin@863_polysilicon-1##6 net@2789#4pin@863_polysilicon-1##7 9.85
R8029 net@2789#4pin@863_polysilicon-1##7 net@2789#4pin@863_polysilicon-1##8 9.85
R8030 net@2789#4pin@863_polysilicon-1##8 net@2789#4pin@863_polysilicon-1##9 9.85
R8031 net@2789#4pin@863_polysilicon-1##9 net@2789#4pin@863_polysilicon-1##10 9.85
R8032 net@2789#4pin@863_polysilicon-1##10 net@2789#4pin@863_polysilicon-1##11 9.85
R8033 net@2789#4pin@863_polysilicon-1##11 net@2789#4pin@863_polysilicon-1##12 9.85
R8034 net@2789#4pin@863_polysilicon-1##12 net@2789#4pin@863_polysilicon-1##13 9.85
R8035 net@2789#4pin@863_polysilicon-1##13 net@2789#4pin@863_polysilicon-1##14 9.85
R8036 net@2789#4pin@863_polysilicon-1##14 net@2789#4pin@863_polysilicon-1##15 9.85
R8037 net@2789#4pin@863_polysilicon-1##15 net@2789#4pin@863_polysilicon-1##16 9.85
R8038 net@2789#4pin@863_polysilicon-1##16 net@2789#4pin@863_polysilicon-1##17 9.85
R8039 net@2789#4pin@863_polysilicon-1##17 net@2789#4pin@863_polysilicon-1##18 9.85
R8040 net@2789#4pin@863_polysilicon-1##18 net@2789#4pin@863_polysilicon-1##19 9.85
R8041 net@2789#4pin@863_polysilicon-1##19 net@2789#4pin@863_polysilicon-1##20 9.85
R8042 net@2789#4pin@863_polysilicon-1##20 net@2789#4pin@863_polysilicon-1##21 9.85
R8043 net@2789#4pin@863_polysilicon-1##21 net@2789#4pin@863_polysilicon-1##22 9.85
R8044 net@2789#4pin@863_polysilicon-1##22 net@2789#4pin@863_polysilicon-1##23 9.85
R8045 net@2789#4pin@863_polysilicon-1##23 net@2789#4pin@863_polysilicon-1##24 9.85
R8046 net@2789#4pin@863_polysilicon-1##24 net@2789#4pin@863_polysilicon-1##25 9.85
R8047 net@2789#4pin@863_polysilicon-1##25 net@2789#4pin@863_polysilicon-1##26 9.85
R8048 net@2789#4pin@863_polysilicon-1##26 net@2789#4pin@863_polysilicon-1##27 9.85
R8049 net@2789#4pin@863_polysilicon-1##27 net@2789#4pin@863_polysilicon-1##28 9.85
R8050 net@2789#4pin@863_polysilicon-1##28 net@2789#4pin@863_polysilicon-1##29 9.85
R8051 net@2789#4pin@863_polysilicon-1##29 net@2789#4pin@863_polysilicon-1##30 9.85
R8052 net@2789#4pin@863_polysilicon-1##30 net@2789#4pin@863_polysilicon-1##31 9.85
R8053 net@2789#4pin@863_polysilicon-1##31 net@2789#4pin@863_polysilicon-1##32 9.85
R8054 net@2789#4pin@863_polysilicon-1##32 net@2789#4pin@863_polysilicon-1##33 9.85
R8055 net@2789#4pin@863_polysilicon-1##33 net@2789#4pin@863_polysilicon-1##34 9.85
R8056 net@2789#4pin@863_polysilicon-1##34 net@2789#4pin@863_polysilicon-1##35 9.85
R8057 net@2789#4pin@863_polysilicon-1##35 net@2789#4pin@863_polysilicon-1##36 9.85
R8058 net@2789#4pin@863_polysilicon-1##36 net@2789#4pin@863_polysilicon-1##37 9.85
R8059 net@2789#4pin@863_polysilicon-1##37 net@2789#4pin@863_polysilicon-1##38 9.85
R8060 net@2789#4pin@863_polysilicon-1##38 net@2789#4pin@863_polysilicon-1##39 9.85
R8061 net@2789#4pin@863_polysilicon-1##39 net@2789#4pin@863_polysilicon-1##40 9.85
R8062 net@2789#4pin@863_polysilicon-1##40 net@2789#4pin@863_polysilicon-1##41 9.85
R8063 net@2789#4pin@863_polysilicon-1##41 net@2789#4pin@863_polysilicon-1##42 9.85
R8064 net@2789#4pin@863_polysilicon-1##42 net@2789#4pin@863_polysilicon-1##43 9.85
R8065 net@2789#4pin@863_polysilicon-1##43 net@2789#4pin@863_polysilicon-1##44 9.85
R8066 net@2789#4pin@863_polysilicon-1##44 net@2789#4pin@863_polysilicon-1##45 9.85
R8067 net@2789#4pin@863_polysilicon-1##45 net@2789#4pin@863_polysilicon-1##46 9.85
R8068 net@2789#4pin@863_polysilicon-1##46 net@2789#4pin@863_polysilicon-1##47 9.85
R8069 net@2789#4pin@863_polysilicon-1##47 net@2789#4pin@863_polysilicon-1##48 9.85
R8070 net@2789#4pin@863_polysilicon-1##48 net@2789#4pin@863_polysilicon-1##49 9.85
R8071 net@2789#4pin@863_polysilicon-1##49 net@2789#4pin@863_polysilicon-1##50 9.85
R8072 net@2789#4pin@863_polysilicon-1##50 net@2789#4pin@863_polysilicon-1##51 9.85
R8073 net@2789#4pin@863_polysilicon-1##51 net@2789#4pin@863_polysilicon-1##52 9.85
R8074 net@2789#4pin@863_polysilicon-1##52 net@2789#4pin@863_polysilicon-1##53 9.85
R8075 net@2789#4pin@863_polysilicon-1##53 net@2789#4pin@863_polysilicon-1##54 9.85
R8076 net@2789#4pin@863_polysilicon-1##54 net@2789#4pin@863_polysilicon-1##55 9.85
R8077 net@2789#4pin@863_polysilicon-1##55 net@2789#4pin@863_polysilicon-1##56 9.85
R8078 net@2789#4pin@863_polysilicon-1##56 net@2789#4pin@863_polysilicon-1##57 9.85
R8079 net@2789#4pin@863_polysilicon-1##57 net@2789#4pin@863_polysilicon-1##58 9.85
R8080 net@2789#4pin@863_polysilicon-1##58 net@2789#4pin@863_polysilicon-1##59 9.85
R8081 net@2789#4pin@863_polysilicon-1##59 net@2789#4pin@863_polysilicon-1##60 9.85
R8082 net@2789#4pin@863_polysilicon-1##60 net@2789 9.85
R8083 Cin_to_XOR2___NAND6#22pmos@151_poly-right Cin_to_XOR2___NAND6#22pmos@151_poly-right##0 9.854
R8084 Cin_to_XOR2___NAND6#22pmos@151_poly-right##0 Cin_to_XOR2___NAND6#22pmos@151_poly-right##1 9.854
R8085 Cin_to_XOR2___NAND6#22pmos@151_poly-right##1 Cin_to_XOR2___NAND6#22pmos@151_poly-right##2 9.854
R8086 Cin_to_XOR2___NAND6#22pmos@151_poly-right##2 Cin_to_XOR2___NAND6#22pmos@151_poly-right##3 9.854
R8087 Cin_to_XOR2___NAND6#22pmos@151_poly-right##3 Cin_to_XOR2___NAND6#22pmos@151_poly-right##4 9.854
R8088 Cin_to_XOR2___NAND6#22pmos@151_poly-right##4 Cin_to_XOR2___NAND6#22pmos@151_poly-right##5 9.854
R8089 Cin_to_XOR2___NAND6#22pmos@151_poly-right##5 Cin_to_XOR2___NAND6#22pmos@151_poly-right##6 9.854
R8090 Cin_to_XOR2___NAND6#22pmos@151_poly-right##6 Cin_to_XOR2___NAND6#22pmos@151_poly-right##7 9.854
R8091 Cin_to_XOR2___NAND6#22pmos@151_poly-right##7 Cin_to_XOR2___NAND6#22pmos@151_poly-right##8 9.854
R8092 Cin_to_XOR2___NAND6#22pmos@151_poly-right##8 Cin_to_XOR2___NAND6#22pmos@151_poly-right##9 9.854
R8093 Cin_to_XOR2___NAND6#22pmos@151_poly-right##9 Cin_to_XOR2___NAND6#22pmos@151_poly-right##10 9.854
R8094 Cin_to_XOR2___NAND6#22pmos@151_poly-right##10 Cin_to_XOR2___NAND6#22pmos@151_poly-right##11 9.854
R8095 Cin_to_XOR2___NAND6#22pmos@151_poly-right##11 Cin_to_XOR2___NAND6#22pmos@151_poly-right##12 9.854
R8096 Cin_to_XOR2___NAND6#22pmos@151_poly-right##12 Cin_to_XOR2___NAND6#22pmos@151_poly-right##13 9.854
R8097 Cin_to_XOR2___NAND6#22pmos@151_poly-right##13 Cin_to_XOR2___NAND6#22pmos@151_poly-right##14 9.854
R8098 Cin_to_XOR2___NAND6#22pmos@151_poly-right##14 Cin_to_XOR2___NAND6#22pmos@151_poly-right##15 9.854
R8099 Cin_to_XOR2___NAND6#22pmos@151_poly-right##15 Cin_to_XOR2___NAND6#22pmos@151_poly-right##16 9.854
R8100 Cin_to_XOR2___NAND6#22pmos@151_poly-right##16 Cin_to_XOR2___NAND6#22pmos@151_poly-right##17 9.854
R8101 Cin_to_XOR2___NAND6#22pmos@151_poly-right##17 Cin_to_XOR2___NAND6#22pmos@151_poly-right##18 9.854
R8102 Cin_to_XOR2___NAND6#22pmos@151_poly-right##18 Cin_to_XOR2___NAND6#22pmos@151_poly-right##19 9.854
R8103 Cin_to_XOR2___NAND6#22pmos@151_poly-right##19 Cin_to_XOR2___NAND6#22pmos@151_poly-right##20 9.854
R8104 Cin_to_XOR2___NAND6#22pmos@151_poly-right##20 Cin_to_XOR2___NAND6#22pmos@151_poly-right##21 9.854
R8105 Cin_to_XOR2___NAND6#22pmos@151_poly-right##21 Cin_to_XOR2___NAND6#22pmos@151_poly-right##22 9.854
R8106 Cin_to_XOR2___NAND6#22pmos@151_poly-right##22 Cin_to_XOR2___NAND6#22pmos@151_poly-right##23 9.854
R8107 Cin_to_XOR2___NAND6#22pmos@151_poly-right##23 Cin_to_XOR2___NAND6#22pmos@151_poly-right##24 9.854
R8108 Cin_to_XOR2___NAND6#22pmos@151_poly-right##24 Cin_to_XOR2___NAND6#22pmos@151_poly-right##25 9.854
R8109 Cin_to_XOR2___NAND6#22pmos@151_poly-right##25 Cin_to_XOR2___NAND6#22pmos@151_poly-right##26 9.854
R8110 Cin_to_XOR2___NAND6#22pmos@151_poly-right##26 Cin_to_XOR2___NAND6#22pmos@151_poly-right##27 9.854
R8111 Cin_to_XOR2___NAND6#22pmos@151_poly-right##27 Cin_to_XOR2___NAND6#22pmos@151_poly-right##28 9.854
R8112 Cin_to_XOR2___NAND6#22pmos@151_poly-right##28 Cin_to_XOR2___NAND6#22pmos@151_poly-right##29 9.854
R8113 Cin_to_XOR2___NAND6#22pmos@151_poly-right##29 Cin_to_XOR2___NAND6#22pmos@151_poly-right##30 9.854
R8114 Cin_to_XOR2___NAND6#22pmos@151_poly-right##30 Cin_to_XOR2___NAND6#22pmos@151_poly-right##31 9.854
R8115 Cin_to_XOR2___NAND6#22pmos@151_poly-right##31 Cin_to_XOR2___NAND6#22pmos@151_poly-right##32 9.854
R8116 Cin_to_XOR2___NAND6#22pmos@151_poly-right##32 Cin_to_XOR2___NAND6#22pmos@151_poly-right##33 9.854
R8117 Cin_to_XOR2___NAND6#22pmos@151_poly-right##33 Cin_to_XOR2___NAND6#22pmos@151_poly-right##34 9.854
R8118 Cin_to_XOR2___NAND6#22pmos@151_poly-right##34 Cin_to_XOR2___NAND6#22pmos@151_poly-right##35 9.854
R8119 Cin_to_XOR2___NAND6#22pmos@151_poly-right##35 Cin_to_XOR2___NAND6#22pmos@151_poly-right##36 9.854
R8120 Cin_to_XOR2___NAND6#22pmos@151_poly-right##36 Cin_to_XOR2___NAND6#22pmos@151_poly-right##37 9.854
R8121 Cin_to_XOR2___NAND6#22pmos@151_poly-right##37 Cin_to_XOR2___NAND6#22pmos@151_poly-right##38 9.854
R8122 Cin_to_XOR2___NAND6#22pmos@151_poly-right##38 Cin_to_XOR2___NAND6#22pmos@151_poly-right##39 9.854
R8123 Cin_to_XOR2___NAND6#22pmos@151_poly-right##39 Cin_to_XOR2___NAND6#22pmos@151_poly-right##40 9.854
R8124 Cin_to_XOR2___NAND6#22pmos@151_poly-right##40 Cin_to_XOR2___NAND6#22pmos@151_poly-right##41 9.854
R8125 Cin_to_XOR2___NAND6#22pmos@151_poly-right##41 Cin_to_XOR2___NAND6#22pmos@151_poly-right##42 9.854
R8126 Cin_to_XOR2___NAND6#22pmos@151_poly-right##42 Cin_to_XOR2___NAND6#22pmos@151_poly-right##43 9.854
R8127 Cin_to_XOR2___NAND6#22pmos@151_poly-right##43 Cin_to_XOR2___NAND6#22pmos@151_poly-right##44 9.854
R8128 Cin_to_XOR2___NAND6#22pmos@151_poly-right##44 Cin_to_XOR2___NAND6#22pmos@151_poly-right##45 9.854
R8129 Cin_to_XOR2___NAND6#22pmos@151_poly-right##45 Cin_to_XOR2___NAND6#22pmos@151_poly-right##46 9.854
R8130 Cin_to_XOR2___NAND6#22pmos@151_poly-right##46 Cin_to_XOR2___NAND6#22pmos@151_poly-right##47 9.854
R8131 Cin_to_XOR2___NAND6#22pmos@151_poly-right##47 Cin_to_XOR2___NAND6#22pmos@151_poly-right##48 9.854
R8132 Cin_to_XOR2___NAND6#22pmos@151_poly-right##48 Cin_to_XOR2___NAND6#22pmos@151_poly-right##49 9.854
R8133 Cin_to_XOR2___NAND6#22pmos@151_poly-right##49 Cin_to_XOR2___NAND6#22pmos@151_poly-right##50 9.854
R8134 Cin_to_XOR2___NAND6#22pmos@151_poly-right##50 Cin_to_XOR2___NAND6#22pmos@151_poly-right##51 9.854
R8135 Cin_to_XOR2___NAND6#22pmos@151_poly-right##51 Cin_to_XOR2___NAND6#22pmos@151_poly-right##52 9.854
R8136 Cin_to_XOR2___NAND6#22pmos@151_poly-right##52 Cin_to_XOR2___NAND6#22pmos@151_poly-right##53 9.854
R8137 Cin_to_XOR2___NAND6#22pmos@151_poly-right##53 Cin_to_XOR2___NAND6#22pmos@151_poly-right##54 9.854
R8138 Cin_to_XOR2___NAND6#22pmos@151_poly-right##54 Cin_to_XOR2___NAND6#21pin@854_polysilicon-1 9.854
R8139 net@2778 net@2778#2contact@945_metal-1-metal-2 4.797
R8140 Cin_to_XOR2___NAND6 Cin_to_XOR2___NAND6##0 8.99
R8141 Cin_to_XOR2___NAND6##0 Cin_to_XOR2___NAND6##1 8.99
R8142 Cin_to_XOR2___NAND6##1 Cin_to_XOR2___NAND6##2 8.99
R8143 Cin_to_XOR2___NAND6##2 Cin_to_XOR2___NAND6##3 8.99
R8144 Cin_to_XOR2___NAND6##3 Cin_to_XOR2___NAND6#21pin@854_polysilicon-1 8.99
R8145 XOR1_to_NAND6#20pmos@147_poly-right XOR1_to_NAND6#20pmos@147_poly-right##0 9.871
R8146 XOR1_to_NAND6#20pmos@147_poly-right##0 XOR1_to_NAND6#20pmos@147_poly-right##1 9.871
R8147 XOR1_to_NAND6#20pmos@147_poly-right##1 XOR1_to_NAND6#20pmos@147_poly-right##2 9.871
R8148 XOR1_to_NAND6#20pmos@147_poly-right##2 XOR1_to_NAND6#20pmos@147_poly-right##3 9.871
R8149 XOR1_to_NAND6#20pmos@147_poly-right##3 XOR1_to_NAND6#20pmos@147_poly-right##4 9.871
R8150 XOR1_to_NAND6#20pmos@147_poly-right##4 XOR1_to_NAND6#20pmos@147_poly-right##5 9.871
R8151 XOR1_to_NAND6#20pmos@147_poly-right##5 XOR1_to_NAND6#20pmos@147_poly-right##6 9.871
R8152 XOR1_to_NAND6#20pmos@147_poly-right##6 XOR1_to_NAND6#20pmos@147_poly-right##7 9.871
R8153 XOR1_to_NAND6#20pmos@147_poly-right##7 XOR1_to_NAND6#20pmos@147_poly-right##8 9.871
R8154 XOR1_to_NAND6#20pmos@147_poly-right##8 XOR1_to_NAND6#20pmos@147_poly-right##9 9.871
R8155 XOR1_to_NAND6#20pmos@147_poly-right##9 XOR1_to_NAND6#20pmos@147_poly-right##10 9.871
R8156 XOR1_to_NAND6#20pmos@147_poly-right##10 XOR1_to_NAND6#20pmos@147_poly-right##11 9.871
R8157 XOR1_to_NAND6#20pmos@147_poly-right##11 XOR1_to_NAND6#20pmos@147_poly-right##12 9.871
R8158 XOR1_to_NAND6#20pmos@147_poly-right##12 XOR1_to_NAND6#20pmos@147_poly-right##13 9.871
R8159 XOR1_to_NAND6#20pmos@147_poly-right##13 XOR1_to_NAND6#20pmos@147_poly-right##14 9.871
R8160 XOR1_to_NAND6#20pmos@147_poly-right##14 XOR1_to_NAND6#20pmos@147_poly-right##15 9.871
R8161 XOR1_to_NAND6#20pmos@147_poly-right##15 XOR1_to_NAND6#20pmos@147_poly-right##16 9.871
R8162 XOR1_to_NAND6#20pmos@147_poly-right##16 XOR1_to_NAND6#20pmos@147_poly-right##17 9.871
R8163 XOR1_to_NAND6#20pmos@147_poly-right##17 XOR1_to_NAND6#20pmos@147_poly-right##18 9.871
R8164 XOR1_to_NAND6#20pmos@147_poly-right##18 XOR1_to_NAND6#20pmos@147_poly-right##19 9.871
R8165 XOR1_to_NAND6#20pmos@147_poly-right##19 XOR1_to_NAND6#20pmos@147_poly-right##20 9.871
R8166 XOR1_to_NAND6#20pmos@147_poly-right##20 XOR1_to_NAND6#20pmos@147_poly-right##21 9.871
R8167 XOR1_to_NAND6#20pmos@147_poly-right##21 XOR1_to_NAND6#20pmos@147_poly-right##22 9.871
R8168 XOR1_to_NAND6#20pmos@147_poly-right##22 XOR1_to_NAND6#20pmos@147_poly-right##23 9.871
R8169 XOR1_to_NAND6#20pmos@147_poly-right##23 XOR1_to_NAND6#20pmos@147_poly-right##24 9.871
R8170 XOR1_to_NAND6#20pmos@147_poly-right##24 XOR1_to_NAND6#20pmos@147_poly-right##25 9.871
R8171 XOR1_to_NAND6#20pmos@147_poly-right##25 XOR1_to_NAND6#20pmos@147_poly-right##26 9.871
R8172 XOR1_to_NAND6#20pmos@147_poly-right##26 XOR1_to_NAND6#20pmos@147_poly-right##27 9.871
R8173 XOR1_to_NAND6#20pmos@147_poly-right##27 XOR1_to_NAND6#20pmos@147_poly-right##28 9.871
R8174 XOR1_to_NAND6#20pmos@147_poly-right##28 XOR1_to_NAND6#20pmos@147_poly-right##29 9.871
R8175 XOR1_to_NAND6#20pmos@147_poly-right##29 XOR1_to_NAND6#20pmos@147_poly-right##30 9.871
R8176 XOR1_to_NAND6#20pmos@147_poly-right##30 XOR1_to_NAND6#20pmos@147_poly-right##31 9.871
R8177 XOR1_to_NAND6#20pmos@147_poly-right##31 XOR1_to_NAND6#20pmos@147_poly-right##32 9.871
R8178 XOR1_to_NAND6#20pmos@147_poly-right##32 XOR1_to_NAND6#20pmos@147_poly-right##33 9.871
R8179 XOR1_to_NAND6#20pmos@147_poly-right##33 XOR1_to_NAND6#20pmos@147_poly-right##34 9.871
R8180 XOR1_to_NAND6#20pmos@147_poly-right##34 XOR1_to_NAND6#20pmos@147_poly-right##35 9.871
R8181 XOR1_to_NAND6#20pmos@147_poly-right##35 XOR1_to_NAND6#20pmos@147_poly-right##36 9.871
R8182 XOR1_to_NAND6#20pmos@147_poly-right##36 XOR1_to_NAND6#20pmos@147_poly-right##37 9.871
R8183 XOR1_to_NAND6#20pmos@147_poly-right##37 XOR1_to_NAND6#20pmos@147_poly-right##38 9.871
R8184 XOR1_to_NAND6#20pmos@147_poly-right##38 XOR1_to_NAND6#20pmos@147_poly-right##39 9.871
R8185 XOR1_to_NAND6#20pmos@147_poly-right##39 XOR1_to_NAND6#20pmos@147_poly-right##40 9.871
R8186 XOR1_to_NAND6#20pmos@147_poly-right##40 XOR1_to_NAND6#20pmos@147_poly-right##41 9.871
R8187 XOR1_to_NAND6#20pmos@147_poly-right##41 XOR1_to_NAND6#20pmos@147_poly-right##42 9.871
R8188 XOR1_to_NAND6#20pmos@147_poly-right##42 XOR1_to_NAND6#20pmos@147_poly-right##43 9.871
R8189 XOR1_to_NAND6#20pmos@147_poly-right##43 XOR1_to_NAND6#20pmos@147_poly-right##44 9.871
R8190 XOR1_to_NAND6#20pmos@147_poly-right##44 XOR1_to_NAND6#20pmos@147_poly-right##45 9.871
R8191 XOR1_to_NAND6#20pmos@147_poly-right##45 XOR1_to_NAND6#20pmos@147_poly-right##46 9.871
R8192 XOR1_to_NAND6#20pmos@147_poly-right##46 XOR1_to_NAND6#20pmos@147_poly-right##47 9.871
R8193 XOR1_to_NAND6#20pmos@147_poly-right##47 XOR1_to_NAND6#20pmos@147_poly-right##48 9.871
R8194 XOR1_to_NAND6#20pmos@147_poly-right##48 XOR1_to_NAND6#20pmos@147_poly-right##49 9.871
R8195 XOR1_to_NAND6#20pmos@147_poly-right##49 XOR1_to_NAND6#20pmos@147_poly-right##50 9.871
R8196 XOR1_to_NAND6#20pmos@147_poly-right##50 XOR1_to_NAND6#20pmos@147_poly-right##51 9.871
R8197 XOR1_to_NAND6#20pmos@147_poly-right##51 XOR1_to_NAND6#20pmos@147_poly-right##52 9.871
R8198 XOR1_to_NAND6#20pmos@147_poly-right##52 XOR1_to_NAND6#20pmos@147_poly-right##53 9.871
R8199 XOR1_to_NAND6#20pmos@147_poly-right##53 XOR1_to_NAND6#20pmos@147_poly-right##54 9.871
R8200 XOR1_to_NAND6#20pmos@147_poly-right##54 XOR1_to_NAND6#20pmos@147_poly-right##55 9.871
R8201 XOR1_to_NAND6#20pmos@147_poly-right##55 XOR1_to_NAND6#21nmos@147_poly-right 9.871
R8202 net@2789#5pmos@148_poly-right net@2789#5pmos@148_poly-right##0 9.871
R8203 net@2789#5pmos@148_poly-right##0 net@2789#5pmos@148_poly-right##1 9.871
R8204 net@2789#5pmos@148_poly-right##1 net@2789#5pmos@148_poly-right##2 9.871
R8205 net@2789#5pmos@148_poly-right##2 net@2789#5pmos@148_poly-right##3 9.871
R8206 net@2789#5pmos@148_poly-right##3 net@2789#5pmos@148_poly-right##4 9.871
R8207 net@2789#5pmos@148_poly-right##4 net@2789#5pmos@148_poly-right##5 9.871
R8208 net@2789#5pmos@148_poly-right##5 net@2789#5pmos@148_poly-right##6 9.871
R8209 net@2789#5pmos@148_poly-right##6 net@2789#5pmos@148_poly-right##7 9.871
R8210 net@2789#5pmos@148_poly-right##7 net@2789#5pmos@148_poly-right##8 9.871
R8211 net@2789#5pmos@148_poly-right##8 net@2789#5pmos@148_poly-right##9 9.871
R8212 net@2789#5pmos@148_poly-right##9 net@2789#5pmos@148_poly-right##10 9.871
R8213 net@2789#5pmos@148_poly-right##10 net@2789#5pmos@148_poly-right##11 9.871
R8214 net@2789#5pmos@148_poly-right##11 net@2789#5pmos@148_poly-right##12 9.871
R8215 net@2789#5pmos@148_poly-right##12 net@2789#5pmos@148_poly-right##13 9.871
R8216 net@2789#5pmos@148_poly-right##13 net@2789#5pmos@148_poly-right##14 9.871
R8217 net@2789#5pmos@148_poly-right##14 net@2789#5pmos@148_poly-right##15 9.871
R8218 net@2789#5pmos@148_poly-right##15 net@2789#5pmos@148_poly-right##16 9.871
R8219 net@2789#5pmos@148_poly-right##16 net@2789#5pmos@148_poly-right##17 9.871
R8220 net@2789#5pmos@148_poly-right##17 net@2789#5pmos@148_poly-right##18 9.871
R8221 net@2789#5pmos@148_poly-right##18 net@2789#5pmos@148_poly-right##19 9.871
R8222 net@2789#5pmos@148_poly-right##19 net@2789#5pmos@148_poly-right##20 9.871
R8223 net@2789#5pmos@148_poly-right##20 net@2789#5pmos@148_poly-right##21 9.871
R8224 net@2789#5pmos@148_poly-right##21 net@2789#5pmos@148_poly-right##22 9.871
R8225 net@2789#5pmos@148_poly-right##22 net@2789#5pmos@148_poly-right##23 9.871
R8226 net@2789#5pmos@148_poly-right##23 net@2789#5pmos@148_poly-right##24 9.871
R8227 net@2789#5pmos@148_poly-right##24 net@2789#5pmos@148_poly-right##25 9.871
R8228 net@2789#5pmos@148_poly-right##25 net@2789#5pmos@148_poly-right##26 9.871
R8229 net@2789#5pmos@148_poly-right##26 net@2789#5pmos@148_poly-right##27 9.871
R8230 net@2789#5pmos@148_poly-right##27 net@2789#5pmos@148_poly-right##28 9.871
R8231 net@2789#5pmos@148_poly-right##28 net@2789#5pmos@148_poly-right##29 9.871
R8232 net@2789#5pmos@148_poly-right##29 net@2789#5pmos@148_poly-right##30 9.871
R8233 net@2789#5pmos@148_poly-right##30 net@2789#5pmos@148_poly-right##31 9.871
R8234 net@2789#5pmos@148_poly-right##31 net@2789#5pmos@148_poly-right##32 9.871
R8235 net@2789#5pmos@148_poly-right##32 net@2789#5pmos@148_poly-right##33 9.871
R8236 net@2789#5pmos@148_poly-right##33 net@2789#5pmos@148_poly-right##34 9.871
R8237 net@2789#5pmos@148_poly-right##34 net@2789#5pmos@148_poly-right##35 9.871
R8238 net@2789#5pmos@148_poly-right##35 net@2789#5pmos@148_poly-right##36 9.871
R8239 net@2789#5pmos@148_poly-right##36 net@2789#5pmos@148_poly-right##37 9.871
R8240 net@2789#5pmos@148_poly-right##37 net@2789#5pmos@148_poly-right##38 9.871
R8241 net@2789#5pmos@148_poly-right##38 net@2789#5pmos@148_poly-right##39 9.871
R8242 net@2789#5pmos@148_poly-right##39 net@2789#5pmos@148_poly-right##40 9.871
R8243 net@2789#5pmos@148_poly-right##40 net@2789#5pmos@148_poly-right##41 9.871
R8244 net@2789#5pmos@148_poly-right##41 net@2789#5pmos@148_poly-right##42 9.871
R8245 net@2789#5pmos@148_poly-right##42 net@2789#5pmos@148_poly-right##43 9.871
R8246 net@2789#5pmos@148_poly-right##43 net@2789#5pmos@148_poly-right##44 9.871
R8247 net@2789#5pmos@148_poly-right##44 net@2789#5pmos@148_poly-right##45 9.871
R8248 net@2789#5pmos@148_poly-right##45 net@2789#5pmos@148_poly-right##46 9.871
R8249 net@2789#5pmos@148_poly-right##46 net@2789#5pmos@148_poly-right##47 9.871
R8250 net@2789#5pmos@148_poly-right##47 net@2789#5pmos@148_poly-right##48 9.871
R8251 net@2789#5pmos@148_poly-right##48 net@2789#5pmos@148_poly-right##49 9.871
R8252 net@2789#5pmos@148_poly-right##49 net@2789#5pmos@148_poly-right##50 9.871
R8253 net@2789#5pmos@148_poly-right##50 net@2789#5pmos@148_poly-right##51 9.871
R8254 net@2789#5pmos@148_poly-right##51 net@2789#5pmos@148_poly-right##52 9.871
R8255 net@2789#5pmos@148_poly-right##52 net@2789#5pmos@148_poly-right##53 9.871
R8256 net@2789#5pmos@148_poly-right##53 net@2789#5pmos@148_poly-right##54 9.871
R8257 net@2789#5pmos@148_poly-right##54 net@2789#5pmos@148_poly-right##55 9.871
R8258 net@2789#5pmos@148_poly-right##55 net@2789#6nmos@148_poly-right 9.871
R8259 Cin_to_XOR2___NAND6#23pmos@149_poly-right Cin_to_XOR2___NAND6#23pmos@149_poly-right##0 9.871
R8260 Cin_to_XOR2___NAND6#23pmos@149_poly-right##0 Cin_to_XOR2___NAND6#23pmos@149_poly-right##1 9.871
R8261 Cin_to_XOR2___NAND6#23pmos@149_poly-right##1 Cin_to_XOR2___NAND6#23pmos@149_poly-right##2 9.871
R8262 Cin_to_XOR2___NAND6#23pmos@149_poly-right##2 Cin_to_XOR2___NAND6#23pmos@149_poly-right##3 9.871
R8263 Cin_to_XOR2___NAND6#23pmos@149_poly-right##3 Cin_to_XOR2___NAND6#23pmos@149_poly-right##4 9.871
R8264 Cin_to_XOR2___NAND6#23pmos@149_poly-right##4 Cin_to_XOR2___NAND6#23pmos@149_poly-right##5 9.871
R8265 Cin_to_XOR2___NAND6#23pmos@149_poly-right##5 Cin_to_XOR2___NAND6#23pmos@149_poly-right##6 9.871
R8266 Cin_to_XOR2___NAND6#23pmos@149_poly-right##6 Cin_to_XOR2___NAND6#23pmos@149_poly-right##7 9.871
R8267 Cin_to_XOR2___NAND6#23pmos@149_poly-right##7 Cin_to_XOR2___NAND6#23pmos@149_poly-right##8 9.871
R8268 Cin_to_XOR2___NAND6#23pmos@149_poly-right##8 Cin_to_XOR2___NAND6#23pmos@149_poly-right##9 9.871
R8269 Cin_to_XOR2___NAND6#23pmos@149_poly-right##9 Cin_to_XOR2___NAND6#23pmos@149_poly-right##10 9.871
R8270 Cin_to_XOR2___NAND6#23pmos@149_poly-right##10 Cin_to_XOR2___NAND6#23pmos@149_poly-right##11 9.871
R8271 Cin_to_XOR2___NAND6#23pmos@149_poly-right##11 Cin_to_XOR2___NAND6#23pmos@149_poly-right##12 9.871
R8272 Cin_to_XOR2___NAND6#23pmos@149_poly-right##12 Cin_to_XOR2___NAND6#23pmos@149_poly-right##13 9.871
R8273 Cin_to_XOR2___NAND6#23pmos@149_poly-right##13 Cin_to_XOR2___NAND6#23pmos@149_poly-right##14 9.871
R8274 Cin_to_XOR2___NAND6#23pmos@149_poly-right##14 Cin_to_XOR2___NAND6#23pmos@149_poly-right##15 9.871
R8275 Cin_to_XOR2___NAND6#23pmos@149_poly-right##15 Cin_to_XOR2___NAND6#23pmos@149_poly-right##16 9.871
R8276 Cin_to_XOR2___NAND6#23pmos@149_poly-right##16 Cin_to_XOR2___NAND6#23pmos@149_poly-right##17 9.871
R8277 Cin_to_XOR2___NAND6#23pmos@149_poly-right##17 Cin_to_XOR2___NAND6#23pmos@149_poly-right##18 9.871
R8278 Cin_to_XOR2___NAND6#23pmos@149_poly-right##18 Cin_to_XOR2___NAND6#23pmos@149_poly-right##19 9.871
R8279 Cin_to_XOR2___NAND6#23pmos@149_poly-right##19 Cin_to_XOR2___NAND6#23pmos@149_poly-right##20 9.871
R8280 Cin_to_XOR2___NAND6#23pmos@149_poly-right##20 Cin_to_XOR2___NAND6#23pmos@149_poly-right##21 9.871
R8281 Cin_to_XOR2___NAND6#23pmos@149_poly-right##21 Cin_to_XOR2___NAND6#23pmos@149_poly-right##22 9.871
R8282 Cin_to_XOR2___NAND6#23pmos@149_poly-right##22 Cin_to_XOR2___NAND6#23pmos@149_poly-right##23 9.871
R8283 Cin_to_XOR2___NAND6#23pmos@149_poly-right##23 Cin_to_XOR2___NAND6#23pmos@149_poly-right##24 9.871
R8284 Cin_to_XOR2___NAND6#23pmos@149_poly-right##24 Cin_to_XOR2___NAND6#23pmos@149_poly-right##25 9.871
R8285 Cin_to_XOR2___NAND6#23pmos@149_poly-right##25 Cin_to_XOR2___NAND6#23pmos@149_poly-right##26 9.871
R8286 Cin_to_XOR2___NAND6#23pmos@149_poly-right##26 Cin_to_XOR2___NAND6#23pmos@149_poly-right##27 9.871
R8287 Cin_to_XOR2___NAND6#23pmos@149_poly-right##27 Cin_to_XOR2___NAND6#23pmos@149_poly-right##28 9.871
R8288 Cin_to_XOR2___NAND6#23pmos@149_poly-right##28 Cin_to_XOR2___NAND6#23pmos@149_poly-right##29 9.871
R8289 Cin_to_XOR2___NAND6#23pmos@149_poly-right##29 Cin_to_XOR2___NAND6#23pmos@149_poly-right##30 9.871
R8290 Cin_to_XOR2___NAND6#23pmos@149_poly-right##30 Cin_to_XOR2___NAND6#23pmos@149_poly-right##31 9.871
R8291 Cin_to_XOR2___NAND6#23pmos@149_poly-right##31 Cin_to_XOR2___NAND6#23pmos@149_poly-right##32 9.871
R8292 Cin_to_XOR2___NAND6#23pmos@149_poly-right##32 Cin_to_XOR2___NAND6#23pmos@149_poly-right##33 9.871
R8293 Cin_to_XOR2___NAND6#23pmos@149_poly-right##33 Cin_to_XOR2___NAND6#23pmos@149_poly-right##34 9.871
R8294 Cin_to_XOR2___NAND6#23pmos@149_poly-right##34 Cin_to_XOR2___NAND6#23pmos@149_poly-right##35 9.871
R8295 Cin_to_XOR2___NAND6#23pmos@149_poly-right##35 Cin_to_XOR2___NAND6#23pmos@149_poly-right##36 9.871
R8296 Cin_to_XOR2___NAND6#23pmos@149_poly-right##36 Cin_to_XOR2___NAND6#23pmos@149_poly-right##37 9.871
R8297 Cin_to_XOR2___NAND6#23pmos@149_poly-right##37 Cin_to_XOR2___NAND6#23pmos@149_poly-right##38 9.871
R8298 Cin_to_XOR2___NAND6#23pmos@149_poly-right##38 Cin_to_XOR2___NAND6#23pmos@149_poly-right##39 9.871
R8299 Cin_to_XOR2___NAND6#23pmos@149_poly-right##39 Cin_to_XOR2___NAND6#23pmos@149_poly-right##40 9.871
R8300 Cin_to_XOR2___NAND6#23pmos@149_poly-right##40 Cin_to_XOR2___NAND6#23pmos@149_poly-right##41 9.871
R8301 Cin_to_XOR2___NAND6#23pmos@149_poly-right##41 Cin_to_XOR2___NAND6#23pmos@149_poly-right##42 9.871
R8302 Cin_to_XOR2___NAND6#23pmos@149_poly-right##42 Cin_to_XOR2___NAND6#23pmos@149_poly-right##43 9.871
R8303 Cin_to_XOR2___NAND6#23pmos@149_poly-right##43 Cin_to_XOR2___NAND6#23pmos@149_poly-right##44 9.871
R8304 Cin_to_XOR2___NAND6#23pmos@149_poly-right##44 Cin_to_XOR2___NAND6#23pmos@149_poly-right##45 9.871
R8305 Cin_to_XOR2___NAND6#23pmos@149_poly-right##45 Cin_to_XOR2___NAND6#23pmos@149_poly-right##46 9.871
R8306 Cin_to_XOR2___NAND6#23pmos@149_poly-right##46 Cin_to_XOR2___NAND6#23pmos@149_poly-right##47 9.871
R8307 Cin_to_XOR2___NAND6#23pmos@149_poly-right##47 Cin_to_XOR2___NAND6#23pmos@149_poly-right##48 9.871
R8308 Cin_to_XOR2___NAND6#23pmos@149_poly-right##48 Cin_to_XOR2___NAND6#23pmos@149_poly-right##49 9.871
R8309 Cin_to_XOR2___NAND6#23pmos@149_poly-right##49 Cin_to_XOR2___NAND6#23pmos@149_poly-right##50 9.871
R8310 Cin_to_XOR2___NAND6#23pmos@149_poly-right##50 Cin_to_XOR2___NAND6#23pmos@149_poly-right##51 9.871
R8311 Cin_to_XOR2___NAND6#23pmos@149_poly-right##51 Cin_to_XOR2___NAND6#23pmos@149_poly-right##52 9.871
R8312 Cin_to_XOR2___NAND6#23pmos@149_poly-right##52 Cin_to_XOR2___NAND6#23pmos@149_poly-right##53 9.871
R8313 Cin_to_XOR2___NAND6#23pmos@149_poly-right##53 Cin_to_XOR2___NAND6#23pmos@149_poly-right##54 9.871
R8314 Cin_to_XOR2___NAND6#23pmos@149_poly-right##54 Cin_to_XOR2___NAND6#23pmos@149_poly-right##55 9.871
R8315 Cin_to_XOR2___NAND6#23pmos@149_poly-right##55 Cin_to_XOR2___NAND6#24nmos@149_poly-right 9.871
R8316 net@2778#5pmos@150_poly-right net@2778#5pmos@150_poly-right##0 9.871
R8317 net@2778#5pmos@150_poly-right##0 net@2778#5pmos@150_poly-right##1 9.871
R8318 net@2778#5pmos@150_poly-right##1 net@2778#5pmos@150_poly-right##2 9.871
R8319 net@2778#5pmos@150_poly-right##2 net@2778#5pmos@150_poly-right##3 9.871
R8320 net@2778#5pmos@150_poly-right##3 net@2778#5pmos@150_poly-right##4 9.871
R8321 net@2778#5pmos@150_poly-right##4 net@2778#5pmos@150_poly-right##5 9.871
R8322 net@2778#5pmos@150_poly-right##5 net@2778#5pmos@150_poly-right##6 9.871
R8323 net@2778#5pmos@150_poly-right##6 net@2778#5pmos@150_poly-right##7 9.871
R8324 net@2778#5pmos@150_poly-right##7 net@2778#5pmos@150_poly-right##8 9.871
R8325 net@2778#5pmos@150_poly-right##8 net@2778#5pmos@150_poly-right##9 9.871
R8326 net@2778#5pmos@150_poly-right##9 net@2778#5pmos@150_poly-right##10 9.871
R8327 net@2778#5pmos@150_poly-right##10 net@2778#5pmos@150_poly-right##11 9.871
R8328 net@2778#5pmos@150_poly-right##11 net@2778#5pmos@150_poly-right##12 9.871
R8329 net@2778#5pmos@150_poly-right##12 net@2778#5pmos@150_poly-right##13 9.871
R8330 net@2778#5pmos@150_poly-right##13 net@2778#5pmos@150_poly-right##14 9.871
R8331 net@2778#5pmos@150_poly-right##14 net@2778#5pmos@150_poly-right##15 9.871
R8332 net@2778#5pmos@150_poly-right##15 net@2778#5pmos@150_poly-right##16 9.871
R8333 net@2778#5pmos@150_poly-right##16 net@2778#5pmos@150_poly-right##17 9.871
R8334 net@2778#5pmos@150_poly-right##17 net@2778#5pmos@150_poly-right##18 9.871
R8335 net@2778#5pmos@150_poly-right##18 net@2778#5pmos@150_poly-right##19 9.871
R8336 net@2778#5pmos@150_poly-right##19 net@2778#5pmos@150_poly-right##20 9.871
R8337 net@2778#5pmos@150_poly-right##20 net@2778#5pmos@150_poly-right##21 9.871
R8338 net@2778#5pmos@150_poly-right##21 net@2778#5pmos@150_poly-right##22 9.871
R8339 net@2778#5pmos@150_poly-right##22 net@2778#5pmos@150_poly-right##23 9.871
R8340 net@2778#5pmos@150_poly-right##23 net@2778#5pmos@150_poly-right##24 9.871
R8341 net@2778#5pmos@150_poly-right##24 net@2778#5pmos@150_poly-right##25 9.871
R8342 net@2778#5pmos@150_poly-right##25 net@2778#5pmos@150_poly-right##26 9.871
R8343 net@2778#5pmos@150_poly-right##26 net@2778#5pmos@150_poly-right##27 9.871
R8344 net@2778#5pmos@150_poly-right##27 net@2778#5pmos@150_poly-right##28 9.871
R8345 net@2778#5pmos@150_poly-right##28 net@2778#5pmos@150_poly-right##29 9.871
R8346 net@2778#5pmos@150_poly-right##29 net@2778#5pmos@150_poly-right##30 9.871
R8347 net@2778#5pmos@150_poly-right##30 net@2778#5pmos@150_poly-right##31 9.871
R8348 net@2778#5pmos@150_poly-right##31 net@2778#5pmos@150_poly-right##32 9.871
R8349 net@2778#5pmos@150_poly-right##32 net@2778#5pmos@150_poly-right##33 9.871
R8350 net@2778#5pmos@150_poly-right##33 net@2778#5pmos@150_poly-right##34 9.871
R8351 net@2778#5pmos@150_poly-right##34 net@2778#5pmos@150_poly-right##35 9.871
R8352 net@2778#5pmos@150_poly-right##35 net@2778#5pmos@150_poly-right##36 9.871
R8353 net@2778#5pmos@150_poly-right##36 net@2778#5pmos@150_poly-right##37 9.871
R8354 net@2778#5pmos@150_poly-right##37 net@2778#5pmos@150_poly-right##38 9.871
R8355 net@2778#5pmos@150_poly-right##38 net@2778#5pmos@150_poly-right##39 9.871
R8356 net@2778#5pmos@150_poly-right##39 net@2778#5pmos@150_poly-right##40 9.871
R8357 net@2778#5pmos@150_poly-right##40 net@2778#5pmos@150_poly-right##41 9.871
R8358 net@2778#5pmos@150_poly-right##41 net@2778#5pmos@150_poly-right##42 9.871
R8359 net@2778#5pmos@150_poly-right##42 net@2778#5pmos@150_poly-right##43 9.871
R8360 net@2778#5pmos@150_poly-right##43 net@2778#5pmos@150_poly-right##44 9.871
R8361 net@2778#5pmos@150_poly-right##44 net@2778#5pmos@150_poly-right##45 9.871
R8362 net@2778#5pmos@150_poly-right##45 net@2778#5pmos@150_poly-right##46 9.871
R8363 net@2778#5pmos@150_poly-right##46 net@2778#5pmos@150_poly-right##47 9.871
R8364 net@2778#5pmos@150_poly-right##47 net@2778#5pmos@150_poly-right##48 9.871
R8365 net@2778#5pmos@150_poly-right##48 net@2778#5pmos@150_poly-right##49 9.871
R8366 net@2778#5pmos@150_poly-right##49 net@2778#5pmos@150_poly-right##50 9.871
R8367 net@2778#5pmos@150_poly-right##50 net@2778#5pmos@150_poly-right##51 9.871
R8368 net@2778#5pmos@150_poly-right##51 net@2778#5pmos@150_poly-right##52 9.871
R8369 net@2778#5pmos@150_poly-right##52 net@2778#5pmos@150_poly-right##53 9.871
R8370 net@2778#5pmos@150_poly-right##53 net@2778#5pmos@150_poly-right##54 9.871
R8371 net@2778#5pmos@150_poly-right##54 net@2778#5pmos@150_poly-right##55 9.871
R8372 net@2778#5pmos@150_poly-right##55 net@2778#6nmos@150_poly-right 9.871
R8373 net@2767#2contact@970_metal-1-polysilicon-1 net@2767 4.654
R8374 net@2767#5pmos@153_poly-right net@2767#5pmos@153_poly-right##0 9.931
R8375 net@2767#5pmos@153_poly-right##0 net@2767#5pmos@153_poly-right##1 9.931
R8376 net@2767#5pmos@153_poly-right##1 net@2767#5pmos@153_poly-right##2 9.931
R8377 net@2767#5pmos@153_poly-right##2 net@2767#5pmos@153_poly-right##3 9.931
R8378 net@2767#5pmos@153_poly-right##3 net@2767#5pmos@153_poly-right##4 9.931
R8379 net@2767#5pmos@153_poly-right##4 net@2767#5pmos@153_poly-right##5 9.931
R8380 net@2767#5pmos@153_poly-right##5 net@2767#5pmos@153_poly-right##6 9.931
R8381 net@2767#5pmos@153_poly-right##6 net@2767#5pmos@153_poly-right##7 9.931
R8382 net@2767#5pmos@153_poly-right##7 net@2767#5pmos@153_poly-right##8 9.931
R8383 net@2767#5pmos@153_poly-right##8 net@2767#5pmos@153_poly-right##9 9.931
R8384 net@2767#5pmos@153_poly-right##9 net@2767#5pmos@153_poly-right##10 9.931
R8385 net@2767#5pmos@153_poly-right##10 net@2767#5pmos@153_poly-right##11 9.931
R8386 net@2767#5pmos@153_poly-right##11 net@2767#5pmos@153_poly-right##12 9.931
R8387 net@2767#5pmos@153_poly-right##12 net@2767#5pmos@153_poly-right##13 9.931
R8388 net@2767#5pmos@153_poly-right##13 net@2767#5pmos@153_poly-right##14 9.931
R8389 net@2767#5pmos@153_poly-right##14 net@2767#5pmos@153_poly-right##15 9.931
R8390 net@2767#5pmos@153_poly-right##15 net@2767#5pmos@153_poly-right##16 9.931
R8391 net@2767#5pmos@153_poly-right##16 net@2767#5pmos@153_poly-right##17 9.931
R8392 net@2767#5pmos@153_poly-right##17 net@2767#5pmos@153_poly-right##18 9.931
R8393 net@2767#5pmos@153_poly-right##18 net@2767#5pmos@153_poly-right##19 9.931
R8394 net@2767#5pmos@153_poly-right##19 net@2767#5pmos@153_poly-right##20 9.931
R8395 net@2767#5pmos@153_poly-right##20 net@2767#5pmos@153_poly-right##21 9.931
R8396 net@2767#5pmos@153_poly-right##21 net@2767#5pmos@153_poly-right##22 9.931
R8397 net@2767#5pmos@153_poly-right##22 net@2767#5pmos@153_poly-right##23 9.931
R8398 net@2767#5pmos@153_poly-right##23 net@2767#5pmos@153_poly-right##24 9.931
R8399 net@2767#5pmos@153_poly-right##24 net@2767#5pmos@153_poly-right##25 9.931
R8400 net@2767#5pmos@153_poly-right##25 net@2767#5pmos@153_poly-right##26 9.931
R8401 net@2767#5pmos@153_poly-right##26 net@2767#5pmos@153_poly-right##27 9.931
R8402 net@2767#5pmos@153_poly-right##27 net@2767#5pmos@153_poly-right##28 9.931
R8403 net@2767#5pmos@153_poly-right##28 net@2767#5pmos@153_poly-right##29 9.931
R8404 net@2767#5pmos@153_poly-right##29 net@2767#5pmos@153_poly-right##30 9.931
R8405 net@2767#5pmos@153_poly-right##30 net@2767#5pmos@153_poly-right##31 9.931
R8406 net@2767#5pmos@153_poly-right##31 net@2767#5pmos@153_poly-right##32 9.931
R8407 net@2767#5pmos@153_poly-right##32 net@2767#5pmos@153_poly-right##33 9.931
R8408 net@2767#5pmos@153_poly-right##33 net@2767#5pmos@153_poly-right##34 9.931
R8409 net@2767#5pmos@153_poly-right##34 net@2767#5pmos@153_poly-right##35 9.931
R8410 net@2767#5pmos@153_poly-right##35 net@2767#5pmos@153_poly-right##36 9.931
R8411 net@2767#5pmos@153_poly-right##36 net@2767#5pmos@153_poly-right##37 9.931
R8412 net@2767#5pmos@153_poly-right##37 net@2767#5pmos@153_poly-right##38 9.931
R8413 net@2767#5pmos@153_poly-right##38 net@2767#5pmos@153_poly-right##39 9.931
R8414 net@2767#5pmos@153_poly-right##39 net@2767#5pmos@153_poly-right##40 9.931
R8415 net@2767#5pmos@153_poly-right##40 net@2767#5pmos@153_poly-right##41 9.931
R8416 net@2767#5pmos@153_poly-right##41 net@2767#5pmos@153_poly-right##42 9.931
R8417 net@2767#5pmos@153_poly-right##42 net@2767#5pmos@153_poly-right##43 9.931
R8418 net@2767#5pmos@153_poly-right##43 net@2767#5pmos@153_poly-right##44 9.931
R8419 net@2767#5pmos@153_poly-right##44 net@2767#5pmos@153_poly-right##45 9.931
R8420 net@2767#5pmos@153_poly-right##45 net@2767#5pmos@153_poly-right##46 9.931
R8421 net@2767#5pmos@153_poly-right##46 net@2767#5pmos@153_poly-right##47 9.931
R8422 net@2767#5pmos@153_poly-right##47 net@2767#5pmos@153_poly-right##48 9.931
R8423 net@2767#5pmos@153_poly-right##48 net@2767#5pmos@153_poly-right##49 9.931
R8424 net@2767#5pmos@153_poly-right##49 net@2767#5pmos@153_poly-right##50 9.931
R8425 net@2767#5pmos@153_poly-right##50 net@2767#5pmos@153_poly-right##51 9.931
R8426 net@2767#5pmos@153_poly-right##51 net@2767#5pmos@153_poly-right##52 9.931
R8427 net@2767#5pmos@153_poly-right##52 net@2767#6pin@856_polysilicon-1 9.931
R8428 net@2795#3contact@969_metal-1-p-act net@2795 4.823
R8429 XOR1_to_NAND6#8pin@868_polysilicon-1 XOR1_to_NAND6#8pin@868_polysilicon-1##0 9.854
R8430 XOR1_to_NAND6#8pin@868_polysilicon-1##0 XOR1_to_NAND6#8pin@868_polysilicon-1##1 9.854
R8431 XOR1_to_NAND6#8pin@868_polysilicon-1##1 XOR1_to_NAND6#8pin@868_polysilicon-1##2 9.854
R8432 XOR1_to_NAND6#8pin@868_polysilicon-1##2 XOR1_to_NAND6#8pin@868_polysilicon-1##3 9.854
R8433 XOR1_to_NAND6#8pin@868_polysilicon-1##3 XOR1_to_NAND6#8pin@868_polysilicon-1##4 9.854
R8434 XOR1_to_NAND6#8pin@868_polysilicon-1##4 XOR1_to_NAND6#8pin@868_polysilicon-1##5 9.854
R8435 XOR1_to_NAND6#8pin@868_polysilicon-1##5 XOR1_to_NAND6#8pin@868_polysilicon-1##6 9.854
R8436 XOR1_to_NAND6#8pin@868_polysilicon-1##6 XOR1_to_NAND6#8pin@868_polysilicon-1##7 9.854
R8437 XOR1_to_NAND6#8pin@868_polysilicon-1##7 XOR1_to_NAND6#8pin@868_polysilicon-1##8 9.854
R8438 XOR1_to_NAND6#8pin@868_polysilicon-1##8 XOR1_to_NAND6#8pin@868_polysilicon-1##9 9.854
R8439 XOR1_to_NAND6#8pin@868_polysilicon-1##9 XOR1_to_NAND6#8pin@868_polysilicon-1##10 9.854
R8440 XOR1_to_NAND6#8pin@868_polysilicon-1##10 XOR1_to_NAND6#8pin@868_polysilicon-1##11 9.854
R8441 XOR1_to_NAND6#8pin@868_polysilicon-1##11 XOR1_to_NAND6#8pin@868_polysilicon-1##12 9.854
R8442 XOR1_to_NAND6#8pin@868_polysilicon-1##12 XOR1_to_NAND6#8pin@868_polysilicon-1##13 9.854
R8443 XOR1_to_NAND6#8pin@868_polysilicon-1##13 XOR1_to_NAND6#8pin@868_polysilicon-1##14 9.854
R8444 XOR1_to_NAND6#8pin@868_polysilicon-1##14 XOR1_to_NAND6#8pin@868_polysilicon-1##15 9.854
R8445 XOR1_to_NAND6#8pin@868_polysilicon-1##15 XOR1_to_NAND6#8pin@868_polysilicon-1##16 9.854
R8446 XOR1_to_NAND6#8pin@868_polysilicon-1##16 XOR1_to_NAND6#8pin@868_polysilicon-1##17 9.854
R8447 XOR1_to_NAND6#8pin@868_polysilicon-1##17 XOR1_to_NAND6#8pin@868_polysilicon-1##18 9.854
R8448 XOR1_to_NAND6#8pin@868_polysilicon-1##18 XOR1_to_NAND6#8pin@868_polysilicon-1##19 9.854
R8449 XOR1_to_NAND6#8pin@868_polysilicon-1##19 XOR1_to_NAND6#8pin@868_polysilicon-1##20 9.854
R8450 XOR1_to_NAND6#8pin@868_polysilicon-1##20 XOR1_to_NAND6#8pin@868_polysilicon-1##21 9.854
R8451 XOR1_to_NAND6#8pin@868_polysilicon-1##21 XOR1_to_NAND6#8pin@868_polysilicon-1##22 9.854
R8452 XOR1_to_NAND6#8pin@868_polysilicon-1##22 XOR1_to_NAND6#8pin@868_polysilicon-1##23 9.854
R8453 XOR1_to_NAND6#8pin@868_polysilicon-1##23 XOR1_to_NAND6#8pin@868_polysilicon-1##24 9.854
R8454 XOR1_to_NAND6#8pin@868_polysilicon-1##24 XOR1_to_NAND6#8pin@868_polysilicon-1##25 9.854
R8455 XOR1_to_NAND6#8pin@868_polysilicon-1##25 XOR1_to_NAND6#8pin@868_polysilicon-1##26 9.854
R8456 XOR1_to_NAND6#8pin@868_polysilicon-1##26 XOR1_to_NAND6#8pin@868_polysilicon-1##27 9.854
R8457 XOR1_to_NAND6#8pin@868_polysilicon-1##27 XOR1_to_NAND6#8pin@868_polysilicon-1##28 9.854
R8458 XOR1_to_NAND6#8pin@868_polysilicon-1##28 XOR1_to_NAND6#8pin@868_polysilicon-1##29 9.854
R8459 XOR1_to_NAND6#8pin@868_polysilicon-1##29 XOR1_to_NAND6#8pin@868_polysilicon-1##30 9.854
R8460 XOR1_to_NAND6#8pin@868_polysilicon-1##30 XOR1_to_NAND6#8pin@868_polysilicon-1##31 9.854
R8461 XOR1_to_NAND6#8pin@868_polysilicon-1##31 XOR1_to_NAND6#8pin@868_polysilicon-1##32 9.854
R8462 XOR1_to_NAND6#8pin@868_polysilicon-1##32 XOR1_to_NAND6#8pin@868_polysilicon-1##33 9.854
R8463 XOR1_to_NAND6#8pin@868_polysilicon-1##33 XOR1_to_NAND6#8pin@868_polysilicon-1##34 9.854
R8464 XOR1_to_NAND6#8pin@868_polysilicon-1##34 XOR1_to_NAND6#8pin@868_polysilicon-1##35 9.854
R8465 XOR1_to_NAND6#8pin@868_polysilicon-1##35 XOR1_to_NAND6#8pin@868_polysilicon-1##36 9.854
R8466 XOR1_to_NAND6#8pin@868_polysilicon-1##36 XOR1_to_NAND6#8pin@868_polysilicon-1##37 9.854
R8467 XOR1_to_NAND6#8pin@868_polysilicon-1##37 XOR1_to_NAND6#8pin@868_polysilicon-1##38 9.854
R8468 XOR1_to_NAND6#8pin@868_polysilicon-1##38 XOR1_to_NAND6#8pin@868_polysilicon-1##39 9.854
R8469 XOR1_to_NAND6#8pin@868_polysilicon-1##39 XOR1_to_NAND6#8pin@868_polysilicon-1##40 9.854
R8470 XOR1_to_NAND6#8pin@868_polysilicon-1##40 XOR1_to_NAND6#8pin@868_polysilicon-1##41 9.854
R8471 XOR1_to_NAND6#8pin@868_polysilicon-1##41 XOR1_to_NAND6#8pin@868_polysilicon-1##42 9.854
R8472 XOR1_to_NAND6#8pin@868_polysilicon-1##42 XOR1_to_NAND6#8pin@868_polysilicon-1##43 9.854
R8473 XOR1_to_NAND6#8pin@868_polysilicon-1##43 XOR1_to_NAND6#8pin@868_polysilicon-1##44 9.854
R8474 XOR1_to_NAND6#8pin@868_polysilicon-1##44 XOR1_to_NAND6#8pin@868_polysilicon-1##45 9.854
R8475 XOR1_to_NAND6#8pin@868_polysilicon-1##45 XOR1_to_NAND6#8pin@868_polysilicon-1##46 9.854
R8476 XOR1_to_NAND6#8pin@868_polysilicon-1##46 XOR1_to_NAND6#8pin@868_polysilicon-1##47 9.854
R8477 XOR1_to_NAND6#8pin@868_polysilicon-1##47 XOR1_to_NAND6#8pin@868_polysilicon-1##48 9.854
R8478 XOR1_to_NAND6#8pin@868_polysilicon-1##48 XOR1_to_NAND6#8pin@868_polysilicon-1##49 9.854
R8479 XOR1_to_NAND6#8pin@868_polysilicon-1##49 XOR1_to_NAND6#8pin@868_polysilicon-1##50 9.854
R8480 XOR1_to_NAND6#8pin@868_polysilicon-1##50 XOR1_to_NAND6#8pin@868_polysilicon-1##51 9.854
R8481 XOR1_to_NAND6#8pin@868_polysilicon-1##51 XOR1_to_NAND6#8pin@868_polysilicon-1##52 9.854
R8482 XOR1_to_NAND6#8pin@868_polysilicon-1##52 XOR1_to_NAND6#8pin@868_polysilicon-1##53 9.854
R8483 XOR1_to_NAND6#8pin@868_polysilicon-1##53 XOR1_to_NAND6#8pin@868_polysilicon-1##54 9.854
R8484 XOR1_to_NAND6#8pin@868_polysilicon-1##54 XOR1_to_NAND6#22nmos@154_poly-right 9.854
R8485 Cin_to_XOR2___NAND6#25pmos@155_poly-right Cin_to_XOR2___NAND6#25pmos@155_poly-right##0 9.877
R8486 Cin_to_XOR2___NAND6#25pmos@155_poly-right##0 Cin_to_XOR2___NAND6#25pmos@155_poly-right##1 9.877
R8487 Cin_to_XOR2___NAND6#25pmos@155_poly-right##1 Cin_to_XOR2___NAND6#25pmos@155_poly-right##2 9.877
R8488 Cin_to_XOR2___NAND6#25pmos@155_poly-right##2 Cin_to_XOR2___NAND6#25pmos@155_poly-right##3 9.877
R8489 Cin_to_XOR2___NAND6#25pmos@155_poly-right##3 Cin_to_XOR2___NAND6#25pmos@155_poly-right##4 9.877
R8490 Cin_to_XOR2___NAND6#25pmos@155_poly-right##4 Cin_to_XOR2___NAND6#25pmos@155_poly-right##5 9.877
R8491 Cin_to_XOR2___NAND6#25pmos@155_poly-right##5 Cin_to_XOR2___NAND6#25pmos@155_poly-right##6 9.877
R8492 Cin_to_XOR2___NAND6#25pmos@155_poly-right##6 Cin_to_XOR2___NAND6#25pmos@155_poly-right##7 9.877
R8493 Cin_to_XOR2___NAND6#25pmos@155_poly-right##7 Cin_to_XOR2___NAND6#25pmos@155_poly-right##8 9.877
R8494 Cin_to_XOR2___NAND6#25pmos@155_poly-right##8 Cin_to_XOR2___NAND6#25pmos@155_poly-right##9 9.877
R8495 Cin_to_XOR2___NAND6#25pmos@155_poly-right##9 Cin_to_XOR2___NAND6#25pmos@155_poly-right##10 9.877
R8496 Cin_to_XOR2___NAND6#25pmos@155_poly-right##10 Cin_to_XOR2___NAND6#25pmos@155_poly-right##11 9.877
R8497 Cin_to_XOR2___NAND6#25pmos@155_poly-right##11 Cin_to_XOR2___NAND6#25pmos@155_poly-right##12 9.877
R8498 Cin_to_XOR2___NAND6#25pmos@155_poly-right##12 Cin_to_XOR2___NAND6#25pmos@155_poly-right##13 9.877
R8499 Cin_to_XOR2___NAND6#25pmos@155_poly-right##13 Cin_to_XOR2___NAND6#25pmos@155_poly-right##14 9.877
R8500 Cin_to_XOR2___NAND6#25pmos@155_poly-right##14 Cin_to_XOR2___NAND6#25pmos@155_poly-right##15 9.877
R8501 Cin_to_XOR2___NAND6#25pmos@155_poly-right##15 Cin_to_XOR2___NAND6#25pmos@155_poly-right##16 9.877
R8502 Cin_to_XOR2___NAND6#25pmos@155_poly-right##16 Cin_to_XOR2___NAND6#25pmos@155_poly-right##17 9.877
R8503 Cin_to_XOR2___NAND6#25pmos@155_poly-right##17 Cin_to_XOR2___NAND6#25pmos@155_poly-right##18 9.877
R8504 Cin_to_XOR2___NAND6#25pmos@155_poly-right##18 Cin_to_XOR2___NAND6#25pmos@155_poly-right##19 9.877
R8505 Cin_to_XOR2___NAND6#25pmos@155_poly-right##19 Cin_to_XOR2___NAND6#25pmos@155_poly-right##20 9.877
R8506 Cin_to_XOR2___NAND6#25pmos@155_poly-right##20 Cin_to_XOR2___NAND6#25pmos@155_poly-right##21 9.877
R8507 Cin_to_XOR2___NAND6#25pmos@155_poly-right##21 Cin_to_XOR2___NAND6#25pmos@155_poly-right##22 9.877
R8508 Cin_to_XOR2___NAND6#25pmos@155_poly-right##22 Cin_to_XOR2___NAND6#25pmos@155_poly-right##23 9.877
R8509 Cin_to_XOR2___NAND6#25pmos@155_poly-right##23 Cin_to_XOR2___NAND6#25pmos@155_poly-right##24 9.877
R8510 Cin_to_XOR2___NAND6#25pmos@155_poly-right##24 Cin_to_XOR2___NAND6#25pmos@155_poly-right##25 9.877
R8511 Cin_to_XOR2___NAND6#25pmos@155_poly-right##25 Cin_to_XOR2___NAND6#25pmos@155_poly-right##26 9.877
R8512 Cin_to_XOR2___NAND6#25pmos@155_poly-right##26 Cin_to_XOR2___NAND6#25pmos@155_poly-right##27 9.877
R8513 Cin_to_XOR2___NAND6#25pmos@155_poly-right##27 Cin_to_XOR2___NAND6#25pmos@155_poly-right##28 9.877
R8514 Cin_to_XOR2___NAND6#25pmos@155_poly-right##28 Cin_to_XOR2___NAND6#25pmos@155_poly-right##29 9.877
R8515 Cin_to_XOR2___NAND6#25pmos@155_poly-right##29 Cin_to_XOR2___NAND6#25pmos@155_poly-right##30 9.877
R8516 Cin_to_XOR2___NAND6#25pmos@155_poly-right##30 Cin_to_XOR2___NAND6#25pmos@155_poly-right##31 9.877
R8517 Cin_to_XOR2___NAND6#25pmos@155_poly-right##31 Cin_to_XOR2___NAND6#25pmos@155_poly-right##32 9.877
R8518 Cin_to_XOR2___NAND6#25pmos@155_poly-right##32 Cin_to_XOR2___NAND6#25pmos@155_poly-right##33 9.877
R8519 Cin_to_XOR2___NAND6#25pmos@155_poly-right##33 Cin_to_XOR2___NAND6#25pmos@155_poly-right##34 9.877
R8520 Cin_to_XOR2___NAND6#25pmos@155_poly-right##34 Cin_to_XOR2___NAND6#25pmos@155_poly-right##35 9.877
R8521 Cin_to_XOR2___NAND6#25pmos@155_poly-right##35 Cin_to_XOR2___NAND6#25pmos@155_poly-right##36 9.877
R8522 Cin_to_XOR2___NAND6#25pmos@155_poly-right##36 Cin_to_XOR2___NAND6#25pmos@155_poly-right##37 9.877
R8523 Cin_to_XOR2___NAND6#25pmos@155_poly-right##37 Cin_to_XOR2___NAND6#25pmos@155_poly-right##38 9.877
R8524 Cin_to_XOR2___NAND6#25pmos@155_poly-right##38 Cin_to_XOR2___NAND6#25pmos@155_poly-right##39 9.877
R8525 Cin_to_XOR2___NAND6#25pmos@155_poly-right##39 Cin_to_XOR2___NAND6#25pmos@155_poly-right##40 9.877
R8526 Cin_to_XOR2___NAND6#25pmos@155_poly-right##40 Cin_to_XOR2___NAND6#25pmos@155_poly-right##41 9.877
R8527 Cin_to_XOR2___NAND6#25pmos@155_poly-right##41 Cin_to_XOR2___NAND6#25pmos@155_poly-right##42 9.877
R8528 Cin_to_XOR2___NAND6#25pmos@155_poly-right##42 Cin_to_XOR2___NAND6#25pmos@155_poly-right##43 9.877
R8529 Cin_to_XOR2___NAND6#25pmos@155_poly-right##43 Cin_to_XOR2___NAND6#25pmos@155_poly-right##44 9.877
R8530 Cin_to_XOR2___NAND6#25pmos@155_poly-right##44 Cin_to_XOR2___NAND6#25pmos@155_poly-right##45 9.877
R8531 Cin_to_XOR2___NAND6#25pmos@155_poly-right##45 Cin_to_XOR2___NAND6#25pmos@155_poly-right##46 9.877
R8532 Cin_to_XOR2___NAND6#25pmos@155_poly-right##46 Cin_to_XOR2___NAND6#25pmos@155_poly-right##47 9.877
R8533 Cin_to_XOR2___NAND6#25pmos@155_poly-right##47 Cin_to_XOR2___NAND6#25pmos@155_poly-right##48 9.877
R8534 Cin_to_XOR2___NAND6#25pmos@155_poly-right##48 Cin_to_XOR2___NAND6#25pmos@155_poly-right##49 9.877
R8535 Cin_to_XOR2___NAND6#25pmos@155_poly-right##49 Cin_to_XOR2___NAND6#12pin@872_polysilicon-1 9.877
R8536 NAND1_to_NAND8 NAND1_to_NAND8#12contact@979_metal-1-n-act 4.823
R8537 A5#4pin@875_polysilicon-1 A5#4pin@875_polysilicon-1##0 9.938
R8538 A5#4pin@875_polysilicon-1##0 A5#4pin@875_polysilicon-1##1 9.938
R8539 A5#4pin@875_polysilicon-1##1 A5#4pin@875_polysilicon-1##2 9.938
R8540 A5#4pin@875_polysilicon-1##2 A5#4pin@875_polysilicon-1##3 9.938
R8541 A5#4pin@875_polysilicon-1##3 A5#4pin@875_polysilicon-1##4 9.938
R8542 A5#4pin@875_polysilicon-1##4 A5#4pin@875_polysilicon-1##5 9.938
R8543 A5#4pin@875_polysilicon-1##5 A5#4pin@875_polysilicon-1##6 9.938
R8544 A5#4pin@875_polysilicon-1##6 A5#4pin@875_polysilicon-1##7 9.938
R8545 A5#4pin@875_polysilicon-1##7 A5#4pin@875_polysilicon-1##8 9.938
R8546 A5#4pin@875_polysilicon-1##8 A5#4pin@875_polysilicon-1##9 9.938
R8547 A5#4pin@875_polysilicon-1##9 A5#4pin@875_polysilicon-1##10 9.938
R8548 A5#4pin@875_polysilicon-1##10 A5#4pin@875_polysilicon-1##11 9.938
R8549 A5#4pin@875_polysilicon-1##11 A5#4pin@875_polysilicon-1##12 9.938
R8550 A5#4pin@875_polysilicon-1##12 A5#4pin@875_polysilicon-1##13 9.938
R8551 A5#4pin@875_polysilicon-1##13 A5#4pin@875_polysilicon-1##14 9.938
R8552 A5#4pin@875_polysilicon-1##14 A5#4pin@875_polysilicon-1##15 9.938
R8553 A5#4pin@875_polysilicon-1##15 A5#4pin@875_polysilicon-1##16 9.938
R8554 A5#4pin@875_polysilicon-1##16 A5#4pin@875_polysilicon-1##17 9.938
R8555 A5#4pin@875_polysilicon-1##17 A5#4pin@875_polysilicon-1##18 9.938
R8556 A5#4pin@875_polysilicon-1##18 A5#4pin@875_polysilicon-1##19 9.938
R8557 A5#4pin@875_polysilicon-1##19 A5#4pin@875_polysilicon-1##20 9.938
R8558 A5#4pin@875_polysilicon-1##20 A5#4pin@875_polysilicon-1##21 9.938
R8559 A5#4pin@875_polysilicon-1##21 A5#4pin@875_polysilicon-1##22 9.938
R8560 A5#4pin@875_polysilicon-1##22 A5#4pin@875_polysilicon-1##23 9.938
R8561 A5#4pin@875_polysilicon-1##23 A5#4pin@875_polysilicon-1##24 9.938
R8562 A5#4pin@875_polysilicon-1##24 A5#4pin@875_polysilicon-1##25 9.938
R8563 A5#4pin@875_polysilicon-1##25 A5#4pin@875_polysilicon-1##26 9.938
R8564 A5#4pin@875_polysilicon-1##26 A5#4pin@875_polysilicon-1##27 9.938
R8565 A5#4pin@875_polysilicon-1##27 A5#4pin@875_polysilicon-1##28 9.938
R8566 A5#4pin@875_polysilicon-1##28 A5#4pin@875_polysilicon-1##29 9.938
R8567 A5#4pin@875_polysilicon-1##29 A5#4pin@875_polysilicon-1##30 9.938
R8568 A5#4pin@875_polysilicon-1##30 A5#4pin@875_polysilicon-1##31 9.938
R8569 A5#4pin@875_polysilicon-1##31 A5#4pin@875_polysilicon-1##32 9.938
R8570 A5#4pin@875_polysilicon-1##32 A5#4pin@875_polysilicon-1##33 9.938
R8571 A5#4pin@875_polysilicon-1##33 A5#4pin@875_polysilicon-1##34 9.938
R8572 A5#4pin@875_polysilicon-1##34 A5#4pin@875_polysilicon-1##35 9.938
R8573 A5#4pin@875_polysilicon-1##35 A5#4pin@875_polysilicon-1##36 9.938
R8574 A5#4pin@875_polysilicon-1##36 A5#4pin@875_polysilicon-1##37 9.938
R8575 A5#4pin@875_polysilicon-1##37 A5#4pin@875_polysilicon-1##38 9.938
R8576 A5#4pin@875_polysilicon-1##38 A5#4pin@875_polysilicon-1##39 9.938
R8577 A5#4pin@875_polysilicon-1##39 A5#4pin@875_polysilicon-1##40 9.938
R8578 A5#4pin@875_polysilicon-1##40 A5#4pin@875_polysilicon-1##41 9.938
R8579 A5#4pin@875_polysilicon-1##41 A5#4pin@875_polysilicon-1##42 9.938
R8580 A5#4pin@875_polysilicon-1##42 A5#4pin@875_polysilicon-1##43 9.938
R8581 A5#4pin@875_polysilicon-1##43 A5#4pin@875_polysilicon-1##44 9.938
R8582 A5#4pin@875_polysilicon-1##44 A5#4pin@875_polysilicon-1##45 9.938
R8583 A5#4pin@875_polysilicon-1##45 A5#4pin@875_polysilicon-1##46 9.938
R8584 A5#4pin@875_polysilicon-1##46 A5#4pin@875_polysilicon-1##47 9.938
R8585 A5#4pin@875_polysilicon-1##47 A5#4pin@875_polysilicon-1##48 9.938
R8586 A5#4pin@875_polysilicon-1##48 A5#4pin@875_polysilicon-1##49 9.938
R8587 A5#4pin@875_polysilicon-1##49 A5#17nmos@156_poly-right 9.938
R8588 B5#19pmos@157_poly-right B5#19pmos@157_poly-right##0 9.869
R8589 B5#19pmos@157_poly-right##0 B5#19pmos@157_poly-right##1 9.869
R8590 B5#19pmos@157_poly-right##1 B5#19pmos@157_poly-right##2 9.869
R8591 B5#19pmos@157_poly-right##2 B5#19pmos@157_poly-right##3 9.869
R8592 B5#19pmos@157_poly-right##3 B5#19pmos@157_poly-right##4 9.869
R8593 B5#19pmos@157_poly-right##4 B5#19pmos@157_poly-right##5 9.869
R8594 B5#19pmos@157_poly-right##5 B5#19pmos@157_poly-right##6 9.869
R8595 B5#19pmos@157_poly-right##6 B5#19pmos@157_poly-right##7 9.869
R8596 B5#19pmos@157_poly-right##7 B5#19pmos@157_poly-right##8 9.869
R8597 B5#19pmos@157_poly-right##8 B5#19pmos@157_poly-right##9 9.869
R8598 B5#19pmos@157_poly-right##9 B5#19pmos@157_poly-right##10 9.869
R8599 B5#19pmos@157_poly-right##10 B5#19pmos@157_poly-right##11 9.869
R8600 B5#19pmos@157_poly-right##11 B5#19pmos@157_poly-right##12 9.869
R8601 B5#19pmos@157_poly-right##12 B5#19pmos@157_poly-right##13 9.869
R8602 B5#19pmos@157_poly-right##13 B5#19pmos@157_poly-right##14 9.869
R8603 B5#19pmos@157_poly-right##14 B5#19pmos@157_poly-right##15 9.869
R8604 B5#19pmos@157_poly-right##15 B5#19pmos@157_poly-right##16 9.869
R8605 B5#19pmos@157_poly-right##16 B5#19pmos@157_poly-right##17 9.869
R8606 B5#19pmos@157_poly-right##17 B5#19pmos@157_poly-right##18 9.869
R8607 B5#19pmos@157_poly-right##18 B5#19pmos@157_poly-right##19 9.869
R8608 B5#19pmos@157_poly-right##19 B5#19pmos@157_poly-right##20 9.869
R8609 B5#19pmos@157_poly-right##20 B5#19pmos@157_poly-right##21 9.869
R8610 B5#19pmos@157_poly-right##21 B5#19pmos@157_poly-right##22 9.869
R8611 B5#19pmos@157_poly-right##22 B5#19pmos@157_poly-right##23 9.869
R8612 B5#19pmos@157_poly-right##23 B5#19pmos@157_poly-right##24 9.869
R8613 B5#19pmos@157_poly-right##24 B5#19pmos@157_poly-right##25 9.869
R8614 B5#19pmos@157_poly-right##25 B5#19pmos@157_poly-right##26 9.869
R8615 B5#19pmos@157_poly-right##26 B5#19pmos@157_poly-right##27 9.869
R8616 B5#19pmos@157_poly-right##27 B5#19pmos@157_poly-right##28 9.869
R8617 B5#19pmos@157_poly-right##28 B5#19pmos@157_poly-right##29 9.869
R8618 B5#19pmos@157_poly-right##29 B5#19pmos@157_poly-right##30 9.869
R8619 B5#19pmos@157_poly-right##30 B5#19pmos@157_poly-right##31 9.869
R8620 B5#19pmos@157_poly-right##31 B5#19pmos@157_poly-right##32 9.869
R8621 B5#19pmos@157_poly-right##32 B5#19pmos@157_poly-right##33 9.869
R8622 B5#19pmos@157_poly-right##33 B5#19pmos@157_poly-right##34 9.869
R8623 B5#19pmos@157_poly-right##34 B5#19pmos@157_poly-right##35 9.869
R8624 B5#19pmos@157_poly-right##35 B5#19pmos@157_poly-right##36 9.869
R8625 B5#19pmos@157_poly-right##36 B5#19pmos@157_poly-right##37 9.869
R8626 B5#19pmos@157_poly-right##37 B5#19pmos@157_poly-right##38 9.869
R8627 B5#19pmos@157_poly-right##38 B5#19pmos@157_poly-right##39 9.869
R8628 B5#19pmos@157_poly-right##39 B5#19pmos@157_poly-right##40 9.869
R8629 B5#19pmos@157_poly-right##40 B5#19pmos@157_poly-right##41 9.869
R8630 B5#19pmos@157_poly-right##41 B5#19pmos@157_poly-right##42 9.869
R8631 B5#19pmos@157_poly-right##42 B5#19pmos@157_poly-right##43 9.869
R8632 B5#19pmos@157_poly-right##43 B5#19pmos@157_poly-right##44 9.869
R8633 B5#19pmos@157_poly-right##44 B5#19pmos@157_poly-right##45 9.869
R8634 B5#19pmos@157_poly-right##45 B5#19pmos@157_poly-right##46 9.869
R8635 B5#19pmos@157_poly-right##46 B5#19pmos@157_poly-right##47 9.869
R8636 B5#19pmos@157_poly-right##47 B5#9pin@879_polysilicon-1 9.869
R8637 NAND2_to_Nand8#9pin@881_polysilicon-1 NAND2_to_Nand8#9pin@881_polysilicon-1##0 9.938
R8638 NAND2_to_Nand8#9pin@881_polysilicon-1##0 NAND2_to_Nand8#9pin@881_polysilicon-1##1 9.938
R8639 NAND2_to_Nand8#9pin@881_polysilicon-1##1 NAND2_to_Nand8#9pin@881_polysilicon-1##2 9.938
R8640 NAND2_to_Nand8#9pin@881_polysilicon-1##2 NAND2_to_Nand8#9pin@881_polysilicon-1##3 9.938
R8641 NAND2_to_Nand8#9pin@881_polysilicon-1##3 NAND2_to_Nand8#9pin@881_polysilicon-1##4 9.938
R8642 NAND2_to_Nand8#9pin@881_polysilicon-1##4 NAND2_to_Nand8#9pin@881_polysilicon-1##5 9.938
R8643 NAND2_to_Nand8#9pin@881_polysilicon-1##5 NAND2_to_Nand8#9pin@881_polysilicon-1##6 9.938
R8644 NAND2_to_Nand8#9pin@881_polysilicon-1##6 NAND2_to_Nand8#9pin@881_polysilicon-1##7 9.938
R8645 NAND2_to_Nand8#9pin@881_polysilicon-1##7 NAND2_to_Nand8#9pin@881_polysilicon-1##8 9.938
R8646 NAND2_to_Nand8#9pin@881_polysilicon-1##8 NAND2_to_Nand8#9pin@881_polysilicon-1##9 9.938
R8647 NAND2_to_Nand8#9pin@881_polysilicon-1##9 NAND2_to_Nand8#9pin@881_polysilicon-1##10 9.938
R8648 NAND2_to_Nand8#9pin@881_polysilicon-1##10 NAND2_to_Nand8#9pin@881_polysilicon-1##11 9.938
R8649 NAND2_to_Nand8#9pin@881_polysilicon-1##11 NAND2_to_Nand8#9pin@881_polysilicon-1##12 9.938
R8650 NAND2_to_Nand8#9pin@881_polysilicon-1##12 NAND2_to_Nand8#9pin@881_polysilicon-1##13 9.938
R8651 NAND2_to_Nand8#9pin@881_polysilicon-1##13 NAND2_to_Nand8#9pin@881_polysilicon-1##14 9.938
R8652 NAND2_to_Nand8#9pin@881_polysilicon-1##14 NAND2_to_Nand8#9pin@881_polysilicon-1##15 9.938
R8653 NAND2_to_Nand8#9pin@881_polysilicon-1##15 NAND2_to_Nand8#9pin@881_polysilicon-1##16 9.938
R8654 NAND2_to_Nand8#9pin@881_polysilicon-1##16 NAND2_to_Nand8#9pin@881_polysilicon-1##17 9.938
R8655 NAND2_to_Nand8#9pin@881_polysilicon-1##17 NAND2_to_Nand8#9pin@881_polysilicon-1##18 9.938
R8656 NAND2_to_Nand8#9pin@881_polysilicon-1##18 NAND2_to_Nand8#9pin@881_polysilicon-1##19 9.938
R8657 NAND2_to_Nand8#9pin@881_polysilicon-1##19 NAND2_to_Nand8#9pin@881_polysilicon-1##20 9.938
R8658 NAND2_to_Nand8#9pin@881_polysilicon-1##20 NAND2_to_Nand8#9pin@881_polysilicon-1##21 9.938
R8659 NAND2_to_Nand8#9pin@881_polysilicon-1##21 NAND2_to_Nand8#9pin@881_polysilicon-1##22 9.938
R8660 NAND2_to_Nand8#9pin@881_polysilicon-1##22 NAND2_to_Nand8#9pin@881_polysilicon-1##23 9.938
R8661 NAND2_to_Nand8#9pin@881_polysilicon-1##23 NAND2_to_Nand8#9pin@881_polysilicon-1##24 9.938
R8662 NAND2_to_Nand8#9pin@881_polysilicon-1##24 NAND2_to_Nand8#9pin@881_polysilicon-1##25 9.938
R8663 NAND2_to_Nand8#9pin@881_polysilicon-1##25 NAND2_to_Nand8#9pin@881_polysilicon-1##26 9.938
R8664 NAND2_to_Nand8#9pin@881_polysilicon-1##26 NAND2_to_Nand8#9pin@881_polysilicon-1##27 9.938
R8665 NAND2_to_Nand8#9pin@881_polysilicon-1##27 NAND2_to_Nand8#9pin@881_polysilicon-1##28 9.938
R8666 NAND2_to_Nand8#9pin@881_polysilicon-1##28 NAND2_to_Nand8#9pin@881_polysilicon-1##29 9.938
R8667 NAND2_to_Nand8#9pin@881_polysilicon-1##29 NAND2_to_Nand8#9pin@881_polysilicon-1##30 9.938
R8668 NAND2_to_Nand8#9pin@881_polysilicon-1##30 NAND2_to_Nand8#9pin@881_polysilicon-1##31 9.938
R8669 NAND2_to_Nand8#9pin@881_polysilicon-1##31 NAND2_to_Nand8#9pin@881_polysilicon-1##32 9.938
R8670 NAND2_to_Nand8#9pin@881_polysilicon-1##32 NAND2_to_Nand8#9pin@881_polysilicon-1##33 9.938
R8671 NAND2_to_Nand8#9pin@881_polysilicon-1##33 NAND2_to_Nand8#9pin@881_polysilicon-1##34 9.938
R8672 NAND2_to_Nand8#9pin@881_polysilicon-1##34 NAND2_to_Nand8#9pin@881_polysilicon-1##35 9.938
R8673 NAND2_to_Nand8#9pin@881_polysilicon-1##35 NAND2_to_Nand8#9pin@881_polysilicon-1##36 9.938
R8674 NAND2_to_Nand8#9pin@881_polysilicon-1##36 NAND2_to_Nand8#9pin@881_polysilicon-1##37 9.938
R8675 NAND2_to_Nand8#9pin@881_polysilicon-1##37 NAND2_to_Nand8#9pin@881_polysilicon-1##38 9.938
R8676 NAND2_to_Nand8#9pin@881_polysilicon-1##38 NAND2_to_Nand8#9pin@881_polysilicon-1##39 9.938
R8677 NAND2_to_Nand8#9pin@881_polysilicon-1##39 NAND2_to_Nand8#9pin@881_polysilicon-1##40 9.938
R8678 NAND2_to_Nand8#9pin@881_polysilicon-1##40 NAND2_to_Nand8#9pin@881_polysilicon-1##41 9.938
R8679 NAND2_to_Nand8#9pin@881_polysilicon-1##41 NAND2_to_Nand8#9pin@881_polysilicon-1##42 9.938
R8680 NAND2_to_Nand8#9pin@881_polysilicon-1##42 NAND2_to_Nand8#9pin@881_polysilicon-1##43 9.938
R8681 NAND2_to_Nand8#9pin@881_polysilicon-1##43 NAND2_to_Nand8#9pin@881_polysilicon-1##44 9.938
R8682 NAND2_to_Nand8#9pin@881_polysilicon-1##44 NAND2_to_Nand8#9pin@881_polysilicon-1##45 9.938
R8683 NAND2_to_Nand8#9pin@881_polysilicon-1##45 NAND2_to_Nand8#9pin@881_polysilicon-1##46 9.938
R8684 NAND2_to_Nand8#9pin@881_polysilicon-1##46 NAND2_to_Nand8#9pin@881_polysilicon-1##47 9.938
R8685 NAND2_to_Nand8#9pin@881_polysilicon-1##47 NAND2_to_Nand8#9pin@881_polysilicon-1##48 9.938
R8686 NAND2_to_Nand8#9pin@881_polysilicon-1##48 NAND2_to_Nand8#9pin@881_polysilicon-1##49 9.938
R8687 NAND2_to_Nand8#9pin@881_polysilicon-1##49 NAND2_to_Nand8#11nmos@158_poly-right 9.938
R8688 NAND1_to_NAND8#13nmos@159_poly-right NAND1_to_NAND8#13nmos@159_poly-right##0 9.898
R8689 NAND1_to_NAND8#13nmos@159_poly-right##0 NAND1_to_NAND8#13nmos@159_poly-right##1 9.898
R8690 NAND1_to_NAND8#13nmos@159_poly-right##1 NAND1_to_NAND8#13nmos@159_poly-right##2 9.898
R8691 NAND1_to_NAND8#13nmos@159_poly-right##2 NAND1_to_NAND8#13nmos@159_poly-right##3 9.898
R8692 NAND1_to_NAND8#13nmos@159_poly-right##3 NAND1_to_NAND8#13nmos@159_poly-right##4 9.898
R8693 NAND1_to_NAND8#13nmos@159_poly-right##4 NAND1_to_NAND8#13nmos@159_poly-right##5 9.898
R8694 NAND1_to_NAND8#13nmos@159_poly-right##5 NAND1_to_NAND8#13nmos@159_poly-right##6 9.898
R8695 NAND1_to_NAND8#13nmos@159_poly-right##6 NAND1_to_NAND8#13nmos@159_poly-right##7 9.898
R8696 NAND1_to_NAND8#13nmos@159_poly-right##7 NAND1_to_NAND8#13nmos@159_poly-right##8 9.898
R8697 NAND1_to_NAND8#13nmos@159_poly-right##8 NAND1_to_NAND8#13nmos@159_poly-right##9 9.898
R8698 NAND1_to_NAND8#13nmos@159_poly-right##9 NAND1_to_NAND8#13nmos@159_poly-right##10 9.898
R8699 NAND1_to_NAND8#13nmos@159_poly-right##10 NAND1_to_NAND8#13nmos@159_poly-right##11 9.898
R8700 NAND1_to_NAND8#13nmos@159_poly-right##11 NAND1_to_NAND8#13nmos@159_poly-right##12 9.898
R8701 NAND1_to_NAND8#13nmos@159_poly-right##12 NAND1_to_NAND8#13nmos@159_poly-right##13 9.898
R8702 NAND1_to_NAND8#13nmos@159_poly-right##13 NAND1_to_NAND8#13nmos@159_poly-right##14 9.898
R8703 NAND1_to_NAND8#13nmos@159_poly-right##14 NAND1_to_NAND8#13nmos@159_poly-right##15 9.898
R8704 NAND1_to_NAND8#13nmos@159_poly-right##15 NAND1_to_NAND8#13nmos@159_poly-right##16 9.898
R8705 NAND1_to_NAND8#13nmos@159_poly-right##16 NAND1_to_NAND8#13nmos@159_poly-right##17 9.898
R8706 NAND1_to_NAND8#13nmos@159_poly-right##17 NAND1_to_NAND8#13nmos@159_poly-right##18 9.898
R8707 NAND1_to_NAND8#13nmos@159_poly-right##18 NAND1_to_NAND8#13nmos@159_poly-right##19 9.898
R8708 NAND1_to_NAND8#13nmos@159_poly-right##19 NAND1_to_NAND8#13nmos@159_poly-right##20 9.898
R8709 NAND1_to_NAND8#13nmos@159_poly-right##20 NAND1_to_NAND8#13nmos@159_poly-right##21 9.898
R8710 NAND1_to_NAND8#13nmos@159_poly-right##21 NAND1_to_NAND8#13nmos@159_poly-right##22 9.898
R8711 NAND1_to_NAND8#13nmos@159_poly-right##22 NAND1_to_NAND8#13nmos@159_poly-right##23 9.898
R8712 NAND1_to_NAND8#13nmos@159_poly-right##23 NAND1_to_NAND8#13nmos@159_poly-right##24 9.898
R8713 NAND1_to_NAND8#13nmos@159_poly-right##24 NAND1_to_NAND8#13nmos@159_poly-right##25 9.898
R8714 NAND1_to_NAND8#13nmos@159_poly-right##25 NAND1_to_NAND8#13nmos@159_poly-right##26 9.898
R8715 NAND1_to_NAND8#13nmos@159_poly-right##26 NAND1_to_NAND8#13nmos@159_poly-right##27 9.898
R8716 NAND1_to_NAND8#13nmos@159_poly-right##27 NAND1_to_NAND8#13nmos@159_poly-right##28 9.898
R8717 NAND1_to_NAND8#13nmos@159_poly-right##28 NAND1_to_NAND8#13nmos@159_poly-right##29 9.898
R8718 NAND1_to_NAND8#13nmos@159_poly-right##29 NAND1_to_NAND8#13nmos@159_poly-right##30 9.898
R8719 NAND1_to_NAND8#13nmos@159_poly-right##30 NAND1_to_NAND8#13nmos@159_poly-right##31 9.898
R8720 NAND1_to_NAND8#13nmos@159_poly-right##31 NAND1_to_NAND8#13nmos@159_poly-right##32 9.898
R8721 NAND1_to_NAND8#13nmos@159_poly-right##32 NAND1_to_NAND8#13nmos@159_poly-right##33 9.898
R8722 NAND1_to_NAND8#13nmos@159_poly-right##33 NAND1_to_NAND8#13nmos@159_poly-right##34 9.898
R8723 NAND1_to_NAND8#13nmos@159_poly-right##34 NAND1_to_NAND8#13nmos@159_poly-right##35 9.898
R8724 NAND1_to_NAND8#13nmos@159_poly-right##35 NAND1_to_NAND8#13nmos@159_poly-right##36 9.898
R8725 NAND1_to_NAND8#13nmos@159_poly-right##36 NAND1_to_NAND8#13nmos@159_poly-right##37 9.898
R8726 NAND1_to_NAND8#13nmos@159_poly-right##37 NAND1_to_NAND8#13nmos@159_poly-right##38 9.898
R8727 NAND1_to_NAND8#13nmos@159_poly-right##38 NAND1_to_NAND8#13nmos@159_poly-right##39 9.898
R8728 NAND1_to_NAND8#13nmos@159_poly-right##39 NAND1_to_NAND8#13nmos@159_poly-right##40 9.898
R8729 NAND1_to_NAND8#13nmos@159_poly-right##40 NAND1_to_NAND8#13nmos@159_poly-right##41 9.898
R8730 NAND1_to_NAND8#13nmos@159_poly-right##41 NAND1_to_NAND8#13nmos@159_poly-right##42 9.898
R8731 NAND1_to_NAND8#13nmos@159_poly-right##42 NAND1_to_NAND8#13nmos@159_poly-right##43 9.898
R8732 NAND1_to_NAND8#13nmos@159_poly-right##43 NAND1_to_NAND8#13nmos@159_poly-right##44 9.898
R8733 NAND1_to_NAND8#13nmos@159_poly-right##44 NAND1_to_NAND8#13nmos@159_poly-right##45 9.898
R8734 NAND1_to_NAND8#13nmos@159_poly-right##45 NAND1_to_NAND8#13nmos@159_poly-right##46 9.898
R8735 NAND1_to_NAND8#13nmos@159_poly-right##46 NAND1_to_NAND8#13nmos@159_poly-right##47 9.898
R8736 NAND1_to_NAND8#13nmos@159_poly-right##47 NAND1_to_NAND8#13nmos@159_poly-right##48 9.898
R8737 NAND1_to_NAND8#13nmos@159_poly-right##48 NAND1_to_NAND8#13nmos@159_poly-right##49 9.898
R8738 NAND1_to_NAND8#13nmos@159_poly-right##49 NAND1_to_NAND8#13nmos@159_poly-right##50 9.898
R8739 NAND1_to_NAND8#13nmos@159_poly-right##50 NAND1_to_NAND8#13nmos@159_poly-right##51 9.898
R8740 NAND1_to_NAND8#13nmos@159_poly-right##51 NAND1_to_NAND8#13nmos@159_poly-right##52 9.898
R8741 NAND1_to_NAND8#13nmos@159_poly-right##52 NAND1_to_NAND8#13nmos@159_poly-right##53 9.898
R8742 NAND1_to_NAND8#13nmos@159_poly-right##53 NAND1_to_NAND8#13nmos@159_poly-right##54 9.898
R8743 NAND1_to_NAND8#13nmos@159_poly-right##54 NAND1_to_NAND8#13nmos@159_poly-right##55 9.898
R8744 NAND1_to_NAND8#13nmos@159_poly-right##55 NAND1_to_NAND8#8pmos@159_poly-right 9.898
R8745 NAND2_to_Nand8 NAND2_to_Nand8#4nmos@157_diff-bottom 4.42
R8746 net@2929 net@2929##0 9.92
R8747 net@2929##0 net@2929##1 9.92
R8748 net@2929##1 net@2929##2 9.92
R8749 net@2929##2 net@2929##3 9.92
R8750 net@2929##3 net@2929##4 9.92
R8751 net@2929##4 net@2929##5 9.92
R8752 net@2929##5 net@2929##6 9.92
R8753 net@2929##6 net@2929##7 9.92
R8754 net@2929##7 net@2929##8 9.92
R8755 net@2929##8 net@2929##9 9.92
R8756 net@2929##9 net@2929##10 9.92
R8757 net@2929##10 net@2929##11 9.92
R8758 net@2929##11 net@2929##12 9.92
R8759 net@2929##12 net@2929##13 9.92
R8760 net@2929##13 net@2929##14 9.92
R8761 net@2929##14 net@2929##15 9.92
R8762 net@2929##15 net@2929##16 9.92
R8763 net@2929##16 net@2929##17 9.92
R8764 net@2929##17 net@2929##18 9.92
R8765 net@2929##18 net@2929#1pin@921_polysilicon-1 9.92
R8766 net@2931 net@2931##0 9.92
R8767 net@2931##0 net@2931##1 9.92
R8768 net@2931##1 net@2931##2 9.92
R8769 net@2931##2 net@2931##3 9.92
R8770 net@2931##3 net@2931##4 9.92
R8771 net@2931##4 net@2931##5 9.92
R8772 net@2931##5 net@2931##6 9.92
R8773 net@2931##6 net@2931##7 9.92
R8774 net@2931##7 net@2931##8 9.92
R8775 net@2931##8 net@2931##9 9.92
R8776 net@2931##9 net@2931##10 9.92
R8777 net@2931##10 net@2931##11 9.92
R8778 net@2931##11 net@2931##12 9.92
R8779 net@2931##12 net@2931##13 9.92
R8780 net@2931##13 net@2931##14 9.92
R8781 net@2931##14 net@2931##15 9.92
R8782 net@2931##15 net@2931##16 9.92
R8783 net@2931##16 net@2931##17 9.92
R8784 net@2931##17 net@2931##18 9.92
R8785 net@2931##18 net@2931#1pin@946_polysilicon-1 9.92
R8786 XOR1_to_NAND7#3pin@947_polysilicon-1 XOR1_to_NAND7#3pin@947_polysilicon-1##0 6.2
R8787 XOR1_to_NAND7#3pin@947_polysilicon-1##0 XOR1_to_NAND7#4pmos@172_poly-right 6.2
R8788 XOR1_to_NAND7#3pin@947_polysilicon-1 XOR1_to_NAND7#3pin@947_polysilicon-1##0 8.138
R8789 XOR1_to_NAND7#3pin@947_polysilicon-1##0 XOR1_to_NAND7#3pin@947_polysilicon-1##1 8.138
R8790 XOR1_to_NAND7#3pin@947_polysilicon-1##1 XOR1_to_NAND7#3pin@947_polysilicon-1##2 8.138
R8791 XOR1_to_NAND7#3pin@947_polysilicon-1##2 XOR1_to_NAND7#1contact@1092_metal-1-metal-2 8.138
R8792 net@2742#6pin@837_polysilicon-1 net@2742#6pin@837_polysilicon-1##0 9.92
R8793 net@2742#6pin@837_polysilicon-1##0 net@2742#6pin@837_polysilicon-1##1 9.92
R8794 net@2742#6pin@837_polysilicon-1##1 net@2742#6pin@837_polysilicon-1##2 9.92
R8795 net@2742#6pin@837_polysilicon-1##2 net@2742#6pin@837_polysilicon-1##3 9.92
R8796 net@2742#6pin@837_polysilicon-1##3 net@2742#6pin@837_polysilicon-1##4 9.92
R8797 net@2742#6pin@837_polysilicon-1##4 net@2742#6pin@837_polysilicon-1##5 9.92
R8798 net@2742#6pin@837_polysilicon-1##5 net@2742#6pin@837_polysilicon-1##6 9.92
R8799 net@2742#6pin@837_polysilicon-1##6 net@2742#6pin@837_polysilicon-1##7 9.92
R8800 net@2742#6pin@837_polysilicon-1##7 net@2742#6pin@837_polysilicon-1##8 9.92
R8801 net@2742#6pin@837_polysilicon-1##8 net@2742#6pin@837_polysilicon-1##9 9.92
R8802 net@2742#6pin@837_polysilicon-1##9 net@2742#6pin@837_polysilicon-1##10 9.92
R8803 net@2742#6pin@837_polysilicon-1##10 net@2742#6pin@837_polysilicon-1##11 9.92
R8804 net@2742#6pin@837_polysilicon-1##11 net@2742#6pin@837_polysilicon-1##12 9.92
R8805 net@2742#6pin@837_polysilicon-1##12 net@2742#6pin@837_polysilicon-1##13 9.92
R8806 net@2742#6pin@837_polysilicon-1##13 net@2742#6pin@837_polysilicon-1##14 9.92
R8807 net@2742#6pin@837_polysilicon-1##14 net@2742#6pin@837_polysilicon-1##15 9.92
R8808 net@2742#6pin@837_polysilicon-1##15 net@2742#6pin@837_polysilicon-1##16 9.92
R8809 net@2742#6pin@837_polysilicon-1##16 net@2742#6pin@837_polysilicon-1##17 9.92
R8810 net@2742#6pin@837_polysilicon-1##17 net@2742#6pin@837_polysilicon-1##18 9.92
R8811 net@2742#6pin@837_polysilicon-1##18 net@2742#9pin@838_polysilicon-1 9.92
R8812 Cin_to_XOR2___NAND7#14nmos@171_poly-right Cin_to_XOR2___NAND7#14nmos@171_poly-right##0 5.425
R8813 Cin_to_XOR2___NAND7#14nmos@171_poly-right##0 Cin_to_XOR2___NAND7#15pin@937_polysilicon-1 5.425
R8814 Cin_to_XOR2___NAND7 Cin_to_XOR2___NAND7##0 8.99
R8815 Cin_to_XOR2___NAND7##0 Cin_to_XOR2___NAND7##1 8.99
R8816 Cin_to_XOR2___NAND7##1 Cin_to_XOR2___NAND7##2 8.99
R8817 Cin_to_XOR2___NAND7##2 Cin_to_XOR2___NAND7##3 8.99
R8818 Cin_to_XOR2___NAND7##3 Cin_to_XOR2___NAND7#15pin@937_polysilicon-1 8.99
R8819 A6#3pin@922_polysilicon-1 A6#3pin@922_polysilicon-1##0 6.2
R8820 A6#3pin@922_polysilicon-1##0 A6#4pmos@165_poly-right 6.2
R8821 XOR1_to_NAND7#9pmos@167_poly-left XOR1_to_NAND7#9pmos@167_poly-left##0 8.138
R8822 XOR1_to_NAND7#9pmos@167_poly-left##0 XOR1_to_NAND7#9pmos@167_poly-left##1 8.138
R8823 XOR1_to_NAND7#9pmos@167_poly-left##1 XOR1_to_NAND7#9pmos@167_poly-left##2 8.138
R8824 XOR1_to_NAND7#9pmos@167_poly-left##2 XOR1_to_NAND7#10pin@934_polysilicon-1 8.138
R8825 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##0 9.843
R8826 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##0 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##1 9.843
R8827 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##1 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##2 9.843
R8828 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##2 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##3 9.843
R8829 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##3 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##4 9.843
R8830 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##4 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##5 9.843
R8831 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##5 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##6 9.843
R8832 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##6 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##7 9.843
R8833 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##7 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##8 9.843
R8834 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##8 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##9 9.843
R8835 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##9 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##10 9.843
R8836 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##10 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##11 9.843
R8837 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##11 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##12 9.843
R8838 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##12 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##13 9.843
R8839 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##13 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##14 9.843
R8840 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##14 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##15 9.843
R8841 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##15 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##16 9.843
R8842 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##16 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##17 9.843
R8843 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##17 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##18 9.843
R8844 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1##18 Cin_to_XOR2___NAND7#17pin@944_polysilicon-1 9.843
R8845 net@2941#4nmos@173_poly-right net@2941#4nmos@173_poly-right##0 9.3
R8846 net@2941#4nmos@173_poly-right##0 net@2941#4nmos@173_poly-right##1 9.3
R8847 net@2941#4nmos@173_poly-right##1 net@2941#5pin@939_polysilicon-1 9.3
R8848 net@2941#2contact@1078_metal-1-polysilicon-1 net@2941#2contact@1078_metal-1-polysilicon-1##0 8.99
R8849 net@2941#2contact@1078_metal-1-polysilicon-1##0 net@2941#2contact@1078_metal-1-polysilicon-1##1 8.99
R8850 net@2941#2contact@1078_metal-1-polysilicon-1##1 net@2941#2contact@1078_metal-1-polysilicon-1##2 8.99
R8851 net@2941#2contact@1078_metal-1-polysilicon-1##2 net@2941#2contact@1078_metal-1-polysilicon-1##3 8.99
R8852 net@2941#2contact@1078_metal-1-polysilicon-1##3 net@2941#5pin@939_polysilicon-1 8.99
R8853 A6#3pin@922_polysilicon-1 A6#3pin@922_polysilicon-1##0 8.138
R8854 A6#3pin@922_polysilicon-1##0 A6#3pin@922_polysilicon-1##1 8.138
R8855 A6#3pin@922_polysilicon-1##1 A6#3pin@922_polysilicon-1##2 8.138
R8856 A6#3pin@922_polysilicon-1##2 A6#1pin@961_metal-2 8.138
R8857 XOR1_to_NAND7#1contact@1092_metal-1-metal-2 XOR1_to_NAND7#1contact@1092_metal-1-metal-2##0 6.717
R8858 XOR1_to_NAND7#1contact@1092_metal-1-metal-2##0 XOR1_to_NAND7#1contact@1092_metal-1-metal-2##1 6.717
R8859 XOR1_to_NAND7#1contact@1092_metal-1-metal-2##1 XOR1_to_NAND7#12pin@935_polysilicon-1 6.717
R8860 XOR1_to_NAND7#10pin@934_polysilicon-1 XOR1_to_NAND7#10pin@934_polysilicon-1##0 7.75
R8861 XOR1_to_NAND7#10pin@934_polysilicon-1##0 XOR1_to_NAND7#10pin@934_polysilicon-1##1 7.75
R8862 XOR1_to_NAND7#10pin@934_polysilicon-1##1 XOR1_to_NAND7#12pin@935_polysilicon-1 7.75
R8863 Cin_to_XOR2___NAND7#17pin@944_polysilicon-1 Cin_to_XOR2___NAND7#17pin@944_polysilicon-1##0 9.743
R8864 Cin_to_XOR2___NAND7#17pin@944_polysilicon-1##0 Cin_to_XOR2___NAND7#17pin@944_polysilicon-1##1 9.743
R8865 Cin_to_XOR2___NAND7#17pin@944_polysilicon-1##1 Cin_to_XOR2___NAND7#17pin@944_polysilicon-1##2 9.743
R8866 Cin_to_XOR2___NAND7#17pin@944_polysilicon-1##2 Cin_to_XOR2___NAND7#17pin@944_polysilicon-1##3 9.743
R8867 Cin_to_XOR2___NAND7#17pin@944_polysilicon-1##3 Cin_to_XOR2___NAND7#17pin@944_polysilicon-1##4 9.743
R8868 Cin_to_XOR2___NAND7#17pin@944_polysilicon-1##4 Cin_to_XOR2___NAND7#17pin@944_polysilicon-1##5 9.743
R8869 Cin_to_XOR2___NAND7#17pin@944_polysilicon-1##5 Cin_to_XOR2___NAND7 9.743
R8870 A5#13pin@839_polysilicon-1 A5#13pin@839_polysilicon-1##0 6.2
R8871 A5#13pin@839_polysilicon-1##0 A5#18pmos@145_poly-right 6.2
R8872 net@2931#7pmos@168_poly-left net@2931#7pmos@168_poly-left##0 7.75
R8873 net@2931#7pmos@168_poly-left##0 net@2931 7.75
R8874 Cin_to_XOR2___NAND7#18nmos@169_poly-left Cin_to_XOR2___NAND7#18nmos@169_poly-left##0 6.2
R8875 Cin_to_XOR2___NAND7#18nmos@169_poly-left##0 Cin_to_XOR2___NAND7#16pin@927_polysilicon-1 6.2
R8876 net@2942#9nmos@170_poly-left net@2942#9nmos@170_poly-left##0 8.37
R8877 net@2942#9nmos@170_poly-left##0 net@2942#9nmos@170_poly-left##1 8.37
R8878 net@2942#9nmos@170_poly-left##1 net@2942#9nmos@170_poly-left##2 8.37
R8879 net@2942#9nmos@170_poly-left##2 net@2942#9nmos@170_poly-left##3 8.37
R8880 net@2942#9nmos@170_poly-left##3 net@2942#2contact@1053_metal-1-metal-2 8.37
R8881 XOR1_to_NAND6#20pmos@147_poly-right XOR1_to_NAND6#20pmos@147_poly-right##0 8.138
R8882 XOR1_to_NAND6#20pmos@147_poly-right##0 XOR1_to_NAND6#20pmos@147_poly-right##1 8.138
R8883 XOR1_to_NAND6#20pmos@147_poly-right##1 XOR1_to_NAND6#20pmos@147_poly-right##2 8.138
R8884 XOR1_to_NAND6#20pmos@147_poly-right##2 XOR1_to_NAND6#24pin@851_polysilicon-1 8.138
R8885 XOR1_to_NAND7 XOR1_to_NAND7##0 6.717
R8886 XOR1_to_NAND7##0 XOR1_to_NAND7##1 6.717
R8887 XOR1_to_NAND7##1 XOR1_to_NAND7#14pin@951_polysilicon-1 6.717
R8888 XOR1_to_NAND7#16pmos@174_poly-right XOR1_to_NAND7#16pmos@174_poly-right##0 6.2
R8889 XOR1_to_NAND7#16pmos@174_poly-right##0 XOR1_to_NAND7#14pin@951_polysilicon-1 6.2
R8890 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##0 9.843
R8891 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##0 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##1 9.843
R8892 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##1 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##2 9.843
R8893 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##2 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##3 9.843
R8894 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##3 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##4 9.843
R8895 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##4 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##5 9.843
R8896 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##5 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##6 9.843
R8897 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##6 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##7 9.843
R8898 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##7 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##8 9.843
R8899 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##8 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##9 9.843
R8900 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##9 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##10 9.843
R8901 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##10 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##11 9.843
R8902 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##11 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##12 9.843
R8903 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##12 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##13 9.843
R8904 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##13 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##14 9.843
R8905 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##14 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##15 9.843
R8906 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##15 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##16 9.843
R8907 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##16 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##17 9.843
R8908 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##17 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##18 9.843
R8909 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1##18 Cin_to_XOR2___NAND6#27pin@861_polysilicon-1 9.843
R8910 Cin_to_XOR2___NAND7#23pin@955_polysilicon-1 Cin_to_XOR2___NAND7#23pin@955_polysilicon-1##0 9.688
R8911 Cin_to_XOR2___NAND7#23pin@955_polysilicon-1##0 Cin_to_XOR2___NAND7#23pin@955_polysilicon-1##1 9.688
R8912 Cin_to_XOR2___NAND7#23pin@955_polysilicon-1##1 Cin_to_XOR2___NAND7#23pin@955_polysilicon-1##2 9.688
R8913 Cin_to_XOR2___NAND7#23pin@955_polysilicon-1##2 Cin_to_XOR2___NAND7#20contact@1091_metal-1-metal-2 9.688
R8914 Cin_to_XOR2___NAND7#20contact@1091_metal-1-metal-2 Cin_to_XOR2___NAND7 4.953
R8915 A6#0contact@1100_metal-1-metal-2 A6#0contact@1100_metal-1-metal-2##0 6.717
R8916 A6#0contact@1100_metal-1-metal-2##0 A6#0contact@1100_metal-1-metal-2##1 6.717
R8917 A6#0contact@1100_metal-1-metal-2##1 A6#10pin@958_polysilicon-1 6.717
R8918 A6#11pmos@176_poly-right A6#11pmos@176_poly-right##0 9.558
R8919 A6#11pmos@176_poly-right##0 A6#11pmos@176_poly-right##1 9.558
R8920 A6#11pmos@176_poly-right##1 A6#11pmos@176_poly-right##2 9.558
R8921 A6#11pmos@176_poly-right##2 A6#11pmos@176_poly-right##3 9.558
R8922 A6#11pmos@176_poly-right##3 A6#11pmos@176_poly-right##4 9.558
R8923 A6#11pmos@176_poly-right##4 A6#10pin@958_polysilicon-1 9.558
R8924 net@2767#8nmos@153_poly-right net@2767#8nmos@153_poly-right##0 9.3
R8925 net@2767#8nmos@153_poly-right##0 net@2767#8nmos@153_poly-right##1 9.3
R8926 net@2767#8nmos@153_poly-right##1 net@2767#6pin@856_polysilicon-1 9.3
R8927 B6#10pin@962_polysilicon-1 B6#10pin@962_polysilicon-1##0 8.138
R8928 B6#10pin@962_polysilicon-1##0 B6#10pin@962_polysilicon-1##1 8.138
R8929 B6#10pin@962_polysilicon-1##1 B6#10pin@962_polysilicon-1##2 8.138
R8930 B6#10pin@962_polysilicon-1##2 B6#0contact@1101_metal-1-metal-2 8.138
R8931 B6#11nmos@164_poly-right B6#11nmos@164_poly-right##0 5.425
R8932 B6#11nmos@164_poly-right##0 B6#12pin@912_polysilicon-1 5.425
R8933 net@2767#2contact@970_metal-1-polysilicon-1 net@2767#2contact@970_metal-1-polysilicon-1##0 8.99
R8934 net@2767#2contact@970_metal-1-polysilicon-1##0 net@2767#2contact@970_metal-1-polysilicon-1##1 8.99
R8935 net@2767#2contact@970_metal-1-polysilicon-1##1 net@2767#2contact@970_metal-1-polysilicon-1##2 8.99
R8936 net@2767#2contact@970_metal-1-polysilicon-1##2 net@2767#2contact@970_metal-1-polysilicon-1##3 8.99
R8937 net@2767#2contact@970_metal-1-polysilicon-1##3 net@2767#6pin@856_polysilicon-1 8.99
R8938 NAND2_to_Nand9 NAND2_to_Nand9##0 6.717
R8939 NAND2_to_Nand9##0 NAND2_to_Nand9##1 6.717
R8940 NAND2_to_Nand9##1 NAND2_to_Nand9#9pin@964_polysilicon-1 6.717
R8941 NAND2_to_Nand9#10pmos@178_poly-right NAND2_to_Nand9#10pmos@178_poly-right##0 9.558
R8942 NAND2_to_Nand9#10pmos@178_poly-right##0 NAND2_to_Nand9#10pmos@178_poly-right##1 9.558
R8943 NAND2_to_Nand9#10pmos@178_poly-right##1 NAND2_to_Nand9#10pmos@178_poly-right##2 9.558
R8944 NAND2_to_Nand9#10pmos@178_poly-right##2 NAND2_to_Nand9#10pmos@178_poly-right##3 9.558
R8945 NAND2_to_Nand9#10pmos@178_poly-right##3 NAND2_to_Nand9#10pmos@178_poly-right##4 9.558
R8946 NAND2_to_Nand9#10pmos@178_poly-right##4 NAND2_to_Nand9#9pin@964_polysilicon-1 9.558
R8947 A5#13pin@839_polysilicon-1 A5#13pin@839_polysilicon-1##0 8.138
R8948 A5#13pin@839_polysilicon-1##0 A5#13pin@839_polysilicon-1##1 8.138
R8949 A5#13pin@839_polysilicon-1##1 A5#13pin@839_polysilicon-1##2 8.138
R8950 A5#13pin@839_polysilicon-1##2 A5#1pin@878_metal-2 8.138
R8951 B6#1pin@963_metal-2 B6#1pin@963_metal-2##0 8.99
R8952 B6#1pin@963_metal-2##0 B6#1pin@963_metal-2##1 8.99
R8953 B6#1pin@963_metal-2##1 B6#1pin@963_metal-2##2 8.99
R8954 B6#1pin@963_metal-2##2 B6#1pin@963_metal-2##3 8.99
R8955 B6#1pin@963_metal-2##3 B6#12pin@912_polysilicon-1 8.99
R8956 XOR1_to_NAND6#1contact@984_metal-1-metal-2 XOR1_to_NAND6#1contact@984_metal-1-metal-2##0 6.717
R8957 XOR1_to_NAND6#1contact@984_metal-1-metal-2##0 XOR1_to_NAND6#1contact@984_metal-1-metal-2##1 6.717
R8958 XOR1_to_NAND6#1contact@984_metal-1-metal-2##1 XOR1_to_NAND6#26pin@852_polysilicon-1 6.717
R8959 NAND1_to_NAND9#11pmos@179_poly-right NAND1_to_NAND9#11pmos@179_poly-right##0 5.425
R8960 NAND1_to_NAND9#11pmos@179_poly-right##0 NAND1_to_NAND9#12pin@968_polysilicon-1 5.425
R8961 NAND1_to_NAND9#12pin@968_polysilicon-1 NAND1_to_NAND9#12pin@968_polysilicon-1##0 9.3
R8962 NAND1_to_NAND9#12pin@968_polysilicon-1##0 NAND1_to_NAND9#12pin@968_polysilicon-1##1 9.3
R8963 NAND1_to_NAND9#12pin@968_polysilicon-1##1 NAND1_to_NAND9 9.3
R8964 Cin_to_XOR2___NAND7#25nmos@175_poly-right Cin_to_XOR2___NAND7#25nmos@175_poly-right##0 8.636
R8965 Cin_to_XOR2___NAND7#25nmos@175_poly-right##0 Cin_to_XOR2___NAND7#25nmos@175_poly-right##1 8.636
R8966 Cin_to_XOR2___NAND7#25nmos@175_poly-right##1 Cin_to_XOR2___NAND7#25nmos@175_poly-right##2 8.636
R8967 Cin_to_XOR2___NAND7#25nmos@175_poly-right##2 Cin_to_XOR2___NAND7#25nmos@175_poly-right##3 8.636
R8968 Cin_to_XOR2___NAND7#25nmos@175_poly-right##3 Cin_to_XOR2___NAND7#25nmos@175_poly-right##4 8.636
R8969 Cin_to_XOR2___NAND7#25nmos@175_poly-right##4 Cin_to_XOR2___NAND7#25nmos@175_poly-right##5 8.636
R8970 Cin_to_XOR2___NAND7#25nmos@175_poly-right##5 Cin_to_XOR2___NAND7#23pin@955_polysilicon-1 8.636
R8971 B6#13nmos@177_poly-right B6#13nmos@177_poly-right##0 8.956
R8972 B6#13nmos@177_poly-right##0 B6#13nmos@177_poly-right##1 8.956
R8973 B6#13nmos@177_poly-right##1 B6#13nmos@177_poly-right##2 8.956
R8974 B6#13nmos@177_poly-right##2 B6#13nmos@177_poly-right##3 8.956
R8975 B6#13nmos@177_poly-right##3 B6#13nmos@177_poly-right##4 8.956
R8976 B6#13nmos@177_poly-right##4 B6#13nmos@177_poly-right##5 8.956
R8977 B6#13nmos@177_poly-right##5 B6#13nmos@177_poly-right##6 8.956
R8978 B6#13nmos@177_poly-right##6 B6#13nmos@177_poly-right##7 8.956
R8979 B6#13nmos@177_poly-right##7 B6#10pin@962_polysilicon-1 8.956
R8980 A6#12pmos@160_poly-left A6#12pmos@160_poly-left##0 8.138
R8981 A6#12pmos@160_poly-left##0 A6#12pmos@160_poly-left##1 8.138
R8982 A6#12pmos@160_poly-left##1 A6#12pmos@160_poly-left##2 8.138
R8983 A6#12pmos@160_poly-left##2 A6#13pin@909_polysilicon-1 8.138
R8984 B6#14pin@902_polysilicon-1 B6#14pin@902_polysilicon-1##0 9.843
R8985 B6#14pin@902_polysilicon-1##0 B6#14pin@902_polysilicon-1##1 9.843
R8986 B6#14pin@902_polysilicon-1##1 B6#14pin@902_polysilicon-1##2 9.843
R8987 B6#14pin@902_polysilicon-1##2 B6#14pin@902_polysilicon-1##3 9.843
R8988 B6#14pin@902_polysilicon-1##3 B6#14pin@902_polysilicon-1##4 9.843
R8989 B6#14pin@902_polysilicon-1##4 B6#14pin@902_polysilicon-1##5 9.843
R8990 B6#14pin@902_polysilicon-1##5 B6#14pin@902_polysilicon-1##6 9.843
R8991 B6#14pin@902_polysilicon-1##6 B6#14pin@902_polysilicon-1##7 9.843
R8992 B6#14pin@902_polysilicon-1##7 B6#14pin@902_polysilicon-1##8 9.843
R8993 B6#14pin@902_polysilicon-1##8 B6#14pin@902_polysilicon-1##9 9.843
R8994 B6#14pin@902_polysilicon-1##9 B6#14pin@902_polysilicon-1##10 9.843
R8995 B6#14pin@902_polysilicon-1##10 B6#14pin@902_polysilicon-1##11 9.843
R8996 B6#14pin@902_polysilicon-1##11 B6#14pin@902_polysilicon-1##12 9.843
R8997 B6#14pin@902_polysilicon-1##12 B6#14pin@902_polysilicon-1##13 9.843
R8998 B6#14pin@902_polysilicon-1##13 B6#14pin@902_polysilicon-1##14 9.843
R8999 B6#14pin@902_polysilicon-1##14 B6#14pin@902_polysilicon-1##15 9.843
R9000 B6#14pin@902_polysilicon-1##15 B6#14pin@902_polysilicon-1##16 9.843
R9001 B6#14pin@902_polysilicon-1##16 B6#14pin@902_polysilicon-1##17 9.843
R9002 B6#14pin@902_polysilicon-1##17 B6#14pin@902_polysilicon-1##18 9.843
R9003 B6#14pin@902_polysilicon-1##18 B6#15pin@919_polysilicon-1 9.843
R9004 net@3038#4nmos@166_poly-right net@3038#4nmos@166_poly-right##0 7.233
R9005 net@3038#4nmos@166_poly-right##0 net@3038#4nmos@166_poly-right##1 7.233
R9006 net@3038#4nmos@166_poly-right##1 net@3038#5pin@914_polysilicon-1 7.233
R9007 net@3038#2contact@1039_metal-1-polysilicon-1 net@3038#2contact@1039_metal-1-polysilicon-1##0 8.99
R9008 net@3038#2contact@1039_metal-1-polysilicon-1##0 net@3038#2contact@1039_metal-1-polysilicon-1##1 8.99
R9009 net@3038#2contact@1039_metal-1-polysilicon-1##1 net@3038#2contact@1039_metal-1-polysilicon-1##2 8.99
R9010 net@3038#2contact@1039_metal-1-polysilicon-1##2 net@3038#2contact@1039_metal-1-polysilicon-1##3 8.99
R9011 net@3038#2contact@1039_metal-1-polysilicon-1##3 net@3038#5pin@914_polysilicon-1 8.99
R9012 A6#1pin@961_metal-2 A6#1pin@961_metal-2##0 6.717
R9013 A6#1pin@961_metal-2##0 A6#1pin@961_metal-2##1 6.717
R9014 A6#1pin@961_metal-2##1 A6#15pin@910_polysilicon-1 6.717
R9015 A6#13pin@909_polysilicon-1 A6#13pin@909_polysilicon-1##0 7.75
R9016 A6#13pin@909_polysilicon-1##0 A6#13pin@909_polysilicon-1##1 7.75
R9017 A6#13pin@909_polysilicon-1##1 A6#15pin@910_polysilicon-1 7.75
R9018 B6#15pin@919_polysilicon-1 B6#15pin@919_polysilicon-1##0 9.743
R9019 B6#15pin@919_polysilicon-1##0 B6#15pin@919_polysilicon-1##1 9.743
R9020 B6#15pin@919_polysilicon-1##1 B6#15pin@919_polysilicon-1##2 9.743
R9021 B6#15pin@919_polysilicon-1##2 B6#15pin@919_polysilicon-1##3 9.743
R9022 B6#15pin@919_polysilicon-1##3 B6#15pin@919_polysilicon-1##4 9.743
R9023 B6#15pin@919_polysilicon-1##4 B6#15pin@919_polysilicon-1##5 9.743
R9024 B6#15pin@919_polysilicon-1##5 B6#1pin@963_metal-2 9.743
R9025 net@2929#7pmos@161_poly-left net@2929#7pmos@161_poly-left##0 7.75
R9026 net@2929#7pmos@161_poly-left##0 net@2929 7.75
R9027 net@2789#8pin@862_polysilicon-1 net@2789#8pin@862_polysilicon-1##0 9.92
R9028 net@2789#8pin@862_polysilicon-1##0 net@2789#8pin@862_polysilicon-1##1 9.92
R9029 net@2789#8pin@862_polysilicon-1##1 net@2789#8pin@862_polysilicon-1##2 9.92
R9030 net@2789#8pin@862_polysilicon-1##2 net@2789#8pin@862_polysilicon-1##3 9.92
R9031 net@2789#8pin@862_polysilicon-1##3 net@2789#8pin@862_polysilicon-1##4 9.92
R9032 net@2789#8pin@862_polysilicon-1##4 net@2789#8pin@862_polysilicon-1##5 9.92
R9033 net@2789#8pin@862_polysilicon-1##5 net@2789#8pin@862_polysilicon-1##6 9.92
R9034 net@2789#8pin@862_polysilicon-1##6 net@2789#8pin@862_polysilicon-1##7 9.92
R9035 net@2789#8pin@862_polysilicon-1##7 net@2789#8pin@862_polysilicon-1##8 9.92
R9036 net@2789#8pin@862_polysilicon-1##8 net@2789#8pin@862_polysilicon-1##9 9.92
R9037 net@2789#8pin@862_polysilicon-1##9 net@2789#8pin@862_polysilicon-1##10 9.92
R9038 net@2789#8pin@862_polysilicon-1##10 net@2789#8pin@862_polysilicon-1##11 9.92
R9039 net@2789#8pin@862_polysilicon-1##11 net@2789#8pin@862_polysilicon-1##12 9.92
R9040 net@2789#8pin@862_polysilicon-1##12 net@2789#8pin@862_polysilicon-1##13 9.92
R9041 net@2789#8pin@862_polysilicon-1##13 net@2789#8pin@862_polysilicon-1##14 9.92
R9042 net@2789#8pin@862_polysilicon-1##14 net@2789#8pin@862_polysilicon-1##15 9.92
R9043 net@2789#8pin@862_polysilicon-1##15 net@2789#8pin@862_polysilicon-1##16 9.92
R9044 net@2789#8pin@862_polysilicon-1##16 net@2789#8pin@862_polysilicon-1##17 9.92
R9045 net@2789#8pin@862_polysilicon-1##17 net@2789#8pin@862_polysilicon-1##18 9.92
R9046 net@2789#8pin@862_polysilicon-1##18 net@2789#4pin@863_polysilicon-1 9.92
R9047 B6#16nmos@162_poly-left B6#16nmos@162_poly-left##0 6.2
R9048 B6#16nmos@162_poly-left##0 B6#14pin@902_polysilicon-1 6.2
R9049 net@3046#9nmos@163_poly-left net@3046#9nmos@163_poly-left##0 8.37
R9050 net@3046#9nmos@163_poly-left##0 net@3046#9nmos@163_poly-left##1 8.37
R9051 net@3046#9nmos@163_poly-left##1 net@3046#9nmos@163_poly-left##2 8.37
R9052 net@3046#9nmos@163_poly-left##2 net@3046#9nmos@163_poly-left##3 8.37
R9053 net@3046#9nmos@163_poly-left##3 net@3046#2contact@1015_metal-1-metal-2 8.37
R9054 XOR1_to_NAND6#24pin@851_polysilicon-1 XOR1_to_NAND6#24pin@851_polysilicon-1##0 7.75
R9055 XOR1_to_NAND6#24pin@851_polysilicon-1##0 XOR1_to_NAND6#24pin@851_polysilicon-1##1 7.75
R9056 XOR1_to_NAND6#24pin@851_polysilicon-1##1 XOR1_to_NAND6#26pin@852_polysilicon-1 7.75
R9057 A6#3pin@922_polysilicon-1 A6#3pin@922_polysilicon-1##0 9.881
R9058 A6#3pin@922_polysilicon-1##0 A6#3pin@922_polysilicon-1##1 9.881
R9059 A6#3pin@922_polysilicon-1##1 A6#3pin@922_polysilicon-1##2 9.881
R9060 A6#3pin@922_polysilicon-1##2 A6#3pin@922_polysilicon-1##3 9.881
R9061 A6#3pin@922_polysilicon-1##3 A6#3pin@922_polysilicon-1##4 9.881
R9062 A6#3pin@922_polysilicon-1##4 A6#3pin@922_polysilicon-1##5 9.881
R9063 A6#3pin@922_polysilicon-1##5 A6#3pin@922_polysilicon-1##6 9.881
R9064 A6#3pin@922_polysilicon-1##6 A6#3pin@922_polysilicon-1##7 9.881
R9065 A6#3pin@922_polysilicon-1##7 A6#3pin@922_polysilicon-1##8 9.881
R9066 A6#3pin@922_polysilicon-1##8 A6#3pin@922_polysilicon-1##9 9.881
R9067 A6#3pin@922_polysilicon-1##9 A6#3pin@922_polysilicon-1##10 9.881
R9068 A6#3pin@922_polysilicon-1##10 A6#3pin@922_polysilicon-1##11 9.881
R9069 A6#3pin@922_polysilicon-1##11 A6#3pin@922_polysilicon-1##12 9.881
R9070 A6#3pin@922_polysilicon-1##12 A6#3pin@922_polysilicon-1##13 9.881
R9071 A6#3pin@922_polysilicon-1##13 A6#3pin@922_polysilicon-1##14 9.881
R9072 A6#3pin@922_polysilicon-1##14 A6#3pin@922_polysilicon-1##15 9.881
R9073 A6#3pin@922_polysilicon-1##15 A6#3pin@922_polysilicon-1##16 9.881
R9074 A6#3pin@922_polysilicon-1##16 A6#3pin@922_polysilicon-1##17 9.881
R9075 A6#3pin@922_polysilicon-1##17 A6#3pin@922_polysilicon-1##18 9.881
R9076 A6#3pin@922_polysilicon-1##18 A6#3pin@922_polysilicon-1##19 9.881
R9077 A6#3pin@922_polysilicon-1##19 A6#3pin@922_polysilicon-1##20 9.881
R9078 A6#3pin@922_polysilicon-1##20 A6#3pin@922_polysilicon-1##21 9.881
R9079 A6#3pin@922_polysilicon-1##21 A6#3pin@922_polysilicon-1##22 9.881
R9080 A6#3pin@922_polysilicon-1##22 A6#3pin@922_polysilicon-1##23 9.881
R9081 A6#3pin@922_polysilicon-1##23 A6#3pin@922_polysilicon-1##24 9.881
R9082 A6#3pin@922_polysilicon-1##24 A6#3pin@922_polysilicon-1##25 9.881
R9083 A6#3pin@922_polysilicon-1##25 A6#3pin@922_polysilicon-1##26 9.881
R9084 A6#3pin@922_polysilicon-1##26 A6#3pin@922_polysilicon-1##27 9.881
R9085 A6#3pin@922_polysilicon-1##27 A6#3pin@922_polysilicon-1##28 9.881
R9086 A6#3pin@922_polysilicon-1##28 A6#3pin@922_polysilicon-1##29 9.881
R9087 A6#3pin@922_polysilicon-1##29 A6#3pin@922_polysilicon-1##30 9.881
R9088 A6#3pin@922_polysilicon-1##30 A6#3pin@922_polysilicon-1##31 9.881
R9089 A6#3pin@922_polysilicon-1##31 A6#3pin@922_polysilicon-1##32 9.881
R9090 A6#3pin@922_polysilicon-1##32 A6#3pin@922_polysilicon-1##33 9.881
R9091 A6#3pin@922_polysilicon-1##33 A6#3pin@922_polysilicon-1##34 9.881
R9092 A6#3pin@922_polysilicon-1##34 A6#3pin@922_polysilicon-1##35 9.881
R9093 A6#3pin@922_polysilicon-1##35 A6#3pin@922_polysilicon-1##36 9.881
R9094 A6#3pin@922_polysilicon-1##36 A6#3pin@922_polysilicon-1##37 9.881
R9095 A6#3pin@922_polysilicon-1##37 A6#3pin@922_polysilicon-1##38 9.881
R9096 A6#3pin@922_polysilicon-1##38 A6#3pin@922_polysilicon-1##39 9.881
R9097 A6#3pin@922_polysilicon-1##39 A6#3pin@922_polysilicon-1##40 9.881
R9098 A6#3pin@922_polysilicon-1##40 A6#3pin@922_polysilicon-1##41 9.881
R9099 A6#3pin@922_polysilicon-1##41 A6#3pin@922_polysilicon-1##42 9.881
R9100 A6#3pin@922_polysilicon-1##42 A6#3pin@922_polysilicon-1##43 9.881
R9101 A6#3pin@922_polysilicon-1##43 A6#3pin@922_polysilicon-1##44 9.881
R9102 A6#3pin@922_polysilicon-1##44 A6#3pin@922_polysilicon-1##45 9.881
R9103 A6#3pin@922_polysilicon-1##45 A6#3pin@922_polysilicon-1##46 9.881
R9104 A6#3pin@922_polysilicon-1##46 A6#3pin@922_polysilicon-1##47 9.881
R9105 A6#3pin@922_polysilicon-1##47 A6#3pin@922_polysilicon-1##48 9.881
R9106 A6#3pin@922_polysilicon-1##48 A6#3pin@922_polysilicon-1##49 9.881
R9107 A6#3pin@922_polysilicon-1##49 A6#3pin@922_polysilicon-1##50 9.881
R9108 A6#3pin@922_polysilicon-1##50 A6#3pin@922_polysilicon-1##51 9.881
R9109 A6#3pin@922_polysilicon-1##51 A6#3pin@922_polysilicon-1##52 9.881
R9110 A6#3pin@922_polysilicon-1##52 A6#3pin@922_polysilicon-1##53 9.881
R9111 A6#3pin@922_polysilicon-1##53 A6#3pin@922_polysilicon-1##54 9.881
R9112 A6#3pin@922_polysilicon-1##54 A6#16nmos@165_poly-right 9.881
R9113 net@2929#5pmos@165_diff-top net@2929#2pin@911_metal-1 4.81
R9114 net@2929#1pin@921_polysilicon-1 net@2929#1pin@921_polysilicon-1##0 9.85
R9115 net@2929#1pin@921_polysilicon-1##0 net@2929#1pin@921_polysilicon-1##1 9.85
R9116 net@2929#1pin@921_polysilicon-1##1 net@2929#1pin@921_polysilicon-1##2 9.85
R9117 net@2929#1pin@921_polysilicon-1##2 net@2929#1pin@921_polysilicon-1##3 9.85
R9118 net@2929#1pin@921_polysilicon-1##3 net@2929#1pin@921_polysilicon-1##4 9.85
R9119 net@2929#1pin@921_polysilicon-1##4 net@2929#1pin@921_polysilicon-1##5 9.85
R9120 net@2929#1pin@921_polysilicon-1##5 net@2929#1pin@921_polysilicon-1##6 9.85
R9121 net@2929#1pin@921_polysilicon-1##6 net@2929#1pin@921_polysilicon-1##7 9.85
R9122 net@2929#1pin@921_polysilicon-1##7 net@2929#1pin@921_polysilicon-1##8 9.85
R9123 net@2929#1pin@921_polysilicon-1##8 net@2929#1pin@921_polysilicon-1##9 9.85
R9124 net@2929#1pin@921_polysilicon-1##9 net@2929#1pin@921_polysilicon-1##10 9.85
R9125 net@2929#1pin@921_polysilicon-1##10 net@2929#1pin@921_polysilicon-1##11 9.85
R9126 net@2929#1pin@921_polysilicon-1##11 net@2929#1pin@921_polysilicon-1##12 9.85
R9127 net@2929#1pin@921_polysilicon-1##12 net@2929#1pin@921_polysilicon-1##13 9.85
R9128 net@2929#1pin@921_polysilicon-1##13 net@2929#1pin@921_polysilicon-1##14 9.85
R9129 net@2929#1pin@921_polysilicon-1##14 net@2929#1pin@921_polysilicon-1##15 9.85
R9130 net@2929#1pin@921_polysilicon-1##15 net@2929#1pin@921_polysilicon-1##16 9.85
R9131 net@2929#1pin@921_polysilicon-1##16 net@2929#1pin@921_polysilicon-1##17 9.85
R9132 net@2929#1pin@921_polysilicon-1##17 net@2929#1pin@921_polysilicon-1##18 9.85
R9133 net@2929#1pin@921_polysilicon-1##18 net@2929#1pin@921_polysilicon-1##19 9.85
R9134 net@2929#1pin@921_polysilicon-1##19 net@2929#1pin@921_polysilicon-1##20 9.85
R9135 net@2929#1pin@921_polysilicon-1##20 net@2929#1pin@921_polysilicon-1##21 9.85
R9136 net@2929#1pin@921_polysilicon-1##21 net@2929#1pin@921_polysilicon-1##22 9.85
R9137 net@2929#1pin@921_polysilicon-1##22 net@2929#1pin@921_polysilicon-1##23 9.85
R9138 net@2929#1pin@921_polysilicon-1##23 net@2929#1pin@921_polysilicon-1##24 9.85
R9139 net@2929#1pin@921_polysilicon-1##24 net@2929#1pin@921_polysilicon-1##25 9.85
R9140 net@2929#1pin@921_polysilicon-1##25 net@2929#1pin@921_polysilicon-1##26 9.85
R9141 net@2929#1pin@921_polysilicon-1##26 net@2929#1pin@921_polysilicon-1##27 9.85
R9142 net@2929#1pin@921_polysilicon-1##27 net@2929#1pin@921_polysilicon-1##28 9.85
R9143 net@2929#1pin@921_polysilicon-1##28 net@2929#1pin@921_polysilicon-1##29 9.85
R9144 net@2929#1pin@921_polysilicon-1##29 net@2929#1pin@921_polysilicon-1##30 9.85
R9145 net@2929#1pin@921_polysilicon-1##30 net@2929#1pin@921_polysilicon-1##31 9.85
R9146 net@2929#1pin@921_polysilicon-1##31 net@2929#1pin@921_polysilicon-1##32 9.85
R9147 net@2929#1pin@921_polysilicon-1##32 net@2929#1pin@921_polysilicon-1##33 9.85
R9148 net@2929#1pin@921_polysilicon-1##33 net@2929#1pin@921_polysilicon-1##34 9.85
R9149 net@2929#1pin@921_polysilicon-1##34 net@2929#1pin@921_polysilicon-1##35 9.85
R9150 net@2929#1pin@921_polysilicon-1##35 net@2929#1pin@921_polysilicon-1##36 9.85
R9151 net@2929#1pin@921_polysilicon-1##36 net@2929#1pin@921_polysilicon-1##37 9.85
R9152 net@2929#1pin@921_polysilicon-1##37 net@2929#1pin@921_polysilicon-1##38 9.85
R9153 net@2929#1pin@921_polysilicon-1##38 net@2929#1pin@921_polysilicon-1##39 9.85
R9154 net@2929#1pin@921_polysilicon-1##39 net@2929#1pin@921_polysilicon-1##40 9.85
R9155 net@2929#1pin@921_polysilicon-1##40 net@2929#1pin@921_polysilicon-1##41 9.85
R9156 net@2929#1pin@921_polysilicon-1##41 net@2929#1pin@921_polysilicon-1##42 9.85
R9157 net@2929#1pin@921_polysilicon-1##42 net@2929#1pin@921_polysilicon-1##43 9.85
R9158 net@2929#1pin@921_polysilicon-1##43 net@2929#1pin@921_polysilicon-1##44 9.85
R9159 net@2929#1pin@921_polysilicon-1##44 net@2929#1pin@921_polysilicon-1##45 9.85
R9160 net@2929#1pin@921_polysilicon-1##45 net@2929#1pin@921_polysilicon-1##46 9.85
R9161 net@2929#1pin@921_polysilicon-1##46 net@2929#1pin@921_polysilicon-1##47 9.85
R9162 net@2929#1pin@921_polysilicon-1##47 net@2929#1pin@921_polysilicon-1##48 9.85
R9163 net@2929#1pin@921_polysilicon-1##48 net@2929#1pin@921_polysilicon-1##49 9.85
R9164 net@2929#1pin@921_polysilicon-1##49 net@2929#1pin@921_polysilicon-1##50 9.85
R9165 net@2929#1pin@921_polysilicon-1##50 net@2929#1pin@921_polysilicon-1##51 9.85
R9166 net@2929#1pin@921_polysilicon-1##51 net@2929#1pin@921_polysilicon-1##52 9.85
R9167 net@2929#1pin@921_polysilicon-1##52 net@2929#1pin@921_polysilicon-1##53 9.85
R9168 net@2929#1pin@921_polysilicon-1##53 net@2929#1pin@921_polysilicon-1##54 9.85
R9169 net@2929#1pin@921_polysilicon-1##54 net@2929#1pin@921_polysilicon-1##55 9.85
R9170 net@2929#1pin@921_polysilicon-1##55 net@2929#1pin@921_polysilicon-1##56 9.85
R9171 net@2929#1pin@921_polysilicon-1##56 net@2929#1pin@921_polysilicon-1##57 9.85
R9172 net@2929#1pin@921_polysilicon-1##57 net@2929#1pin@921_polysilicon-1##58 9.85
R9173 net@2929#1pin@921_polysilicon-1##58 net@2929#1pin@921_polysilicon-1##59 9.85
R9174 net@2929#1pin@921_polysilicon-1##59 net@2929#1pin@921_polysilicon-1##60 9.85
R9175 net@2929#1pin@921_polysilicon-1##60 net@2929#2pin@911_metal-1 9.85
R9176 B6#17pmos@164_poly-right B6#17pmos@164_poly-right##0 9.854
R9177 B6#17pmos@164_poly-right##0 B6#17pmos@164_poly-right##1 9.854
R9178 B6#17pmos@164_poly-right##1 B6#17pmos@164_poly-right##2 9.854
R9179 B6#17pmos@164_poly-right##2 B6#17pmos@164_poly-right##3 9.854
R9180 B6#17pmos@164_poly-right##3 B6#17pmos@164_poly-right##4 9.854
R9181 B6#17pmos@164_poly-right##4 B6#17pmos@164_poly-right##5 9.854
R9182 B6#17pmos@164_poly-right##5 B6#17pmos@164_poly-right##6 9.854
R9183 B6#17pmos@164_poly-right##6 B6#17pmos@164_poly-right##7 9.854
R9184 B6#17pmos@164_poly-right##7 B6#17pmos@164_poly-right##8 9.854
R9185 B6#17pmos@164_poly-right##8 B6#17pmos@164_poly-right##9 9.854
R9186 B6#17pmos@164_poly-right##9 B6#17pmos@164_poly-right##10 9.854
R9187 B6#17pmos@164_poly-right##10 B6#17pmos@164_poly-right##11 9.854
R9188 B6#17pmos@164_poly-right##11 B6#17pmos@164_poly-right##12 9.854
R9189 B6#17pmos@164_poly-right##12 B6#17pmos@164_poly-right##13 9.854
R9190 B6#17pmos@164_poly-right##13 B6#17pmos@164_poly-right##14 9.854
R9191 B6#17pmos@164_poly-right##14 B6#17pmos@164_poly-right##15 9.854
R9192 B6#17pmos@164_poly-right##15 B6#17pmos@164_poly-right##16 9.854
R9193 B6#17pmos@164_poly-right##16 B6#17pmos@164_poly-right##17 9.854
R9194 B6#17pmos@164_poly-right##17 B6#17pmos@164_poly-right##18 9.854
R9195 B6#17pmos@164_poly-right##18 B6#17pmos@164_poly-right##19 9.854
R9196 B6#17pmos@164_poly-right##19 B6#17pmos@164_poly-right##20 9.854
R9197 B6#17pmos@164_poly-right##20 B6#17pmos@164_poly-right##21 9.854
R9198 B6#17pmos@164_poly-right##21 B6#17pmos@164_poly-right##22 9.854
R9199 B6#17pmos@164_poly-right##22 B6#17pmos@164_poly-right##23 9.854
R9200 B6#17pmos@164_poly-right##23 B6#17pmos@164_poly-right##24 9.854
R9201 B6#17pmos@164_poly-right##24 B6#17pmos@164_poly-right##25 9.854
R9202 B6#17pmos@164_poly-right##25 B6#17pmos@164_poly-right##26 9.854
R9203 B6#17pmos@164_poly-right##26 B6#17pmos@164_poly-right##27 9.854
R9204 B6#17pmos@164_poly-right##27 B6#17pmos@164_poly-right##28 9.854
R9205 B6#17pmos@164_poly-right##28 B6#17pmos@164_poly-right##29 9.854
R9206 B6#17pmos@164_poly-right##29 B6#17pmos@164_poly-right##30 9.854
R9207 B6#17pmos@164_poly-right##30 B6#17pmos@164_poly-right##31 9.854
R9208 B6#17pmos@164_poly-right##31 B6#17pmos@164_poly-right##32 9.854
R9209 B6#17pmos@164_poly-right##32 B6#17pmos@164_poly-right##33 9.854
R9210 B6#17pmos@164_poly-right##33 B6#17pmos@164_poly-right##34 9.854
R9211 B6#17pmos@164_poly-right##34 B6#17pmos@164_poly-right##35 9.854
R9212 B6#17pmos@164_poly-right##35 B6#17pmos@164_poly-right##36 9.854
R9213 B6#17pmos@164_poly-right##36 B6#17pmos@164_poly-right##37 9.854
R9214 B6#17pmos@164_poly-right##37 B6#17pmos@164_poly-right##38 9.854
R9215 B6#17pmos@164_poly-right##38 B6#17pmos@164_poly-right##39 9.854
R9216 B6#17pmos@164_poly-right##39 B6#17pmos@164_poly-right##40 9.854
R9217 B6#17pmos@164_poly-right##40 B6#17pmos@164_poly-right##41 9.854
R9218 B6#17pmos@164_poly-right##41 B6#17pmos@164_poly-right##42 9.854
R9219 B6#17pmos@164_poly-right##42 B6#17pmos@164_poly-right##43 9.854
R9220 B6#17pmos@164_poly-right##43 B6#17pmos@164_poly-right##44 9.854
R9221 B6#17pmos@164_poly-right##44 B6#17pmos@164_poly-right##45 9.854
R9222 B6#17pmos@164_poly-right##45 B6#17pmos@164_poly-right##46 9.854
R9223 B6#17pmos@164_poly-right##46 B6#17pmos@164_poly-right##47 9.854
R9224 B6#17pmos@164_poly-right##47 B6#17pmos@164_poly-right##48 9.854
R9225 B6#17pmos@164_poly-right##48 B6#17pmos@164_poly-right##49 9.854
R9226 B6#17pmos@164_poly-right##49 B6#17pmos@164_poly-right##50 9.854
R9227 B6#17pmos@164_poly-right##50 B6#17pmos@164_poly-right##51 9.854
R9228 B6#17pmos@164_poly-right##51 B6#17pmos@164_poly-right##52 9.854
R9229 B6#17pmos@164_poly-right##52 B6#17pmos@164_poly-right##53 9.854
R9230 B6#17pmos@164_poly-right##53 B6#17pmos@164_poly-right##54 9.854
R9231 B6#17pmos@164_poly-right##54 B6#12pin@912_polysilicon-1 9.854
R9232 net@3046 net@3046#2contact@1015_metal-1-metal-2 4.797
R9233 A6#17nmos@160_poly-right A6#17nmos@160_poly-right##0 9.871
R9234 A6#17nmos@160_poly-right##0 A6#17nmos@160_poly-right##1 9.871
R9235 A6#17nmos@160_poly-right##1 A6#17nmos@160_poly-right##2 9.871
R9236 A6#17nmos@160_poly-right##2 A6#17nmos@160_poly-right##3 9.871
R9237 A6#17nmos@160_poly-right##3 A6#17nmos@160_poly-right##4 9.871
R9238 A6#17nmos@160_poly-right##4 A6#17nmos@160_poly-right##5 9.871
R9239 A6#17nmos@160_poly-right##5 A6#17nmos@160_poly-right##6 9.871
R9240 A6#17nmos@160_poly-right##6 A6#17nmos@160_poly-right##7 9.871
R9241 A6#17nmos@160_poly-right##7 A6#17nmos@160_poly-right##8 9.871
R9242 A6#17nmos@160_poly-right##8 A6#17nmos@160_poly-right##9 9.871
R9243 A6#17nmos@160_poly-right##9 A6#17nmos@160_poly-right##10 9.871
R9244 A6#17nmos@160_poly-right##10 A6#17nmos@160_poly-right##11 9.871
R9245 A6#17nmos@160_poly-right##11 A6#17nmos@160_poly-right##12 9.871
R9246 A6#17nmos@160_poly-right##12 A6#17nmos@160_poly-right##13 9.871
R9247 A6#17nmos@160_poly-right##13 A6#17nmos@160_poly-right##14 9.871
R9248 A6#17nmos@160_poly-right##14 A6#17nmos@160_poly-right##15 9.871
R9249 A6#17nmos@160_poly-right##15 A6#17nmos@160_poly-right##16 9.871
R9250 A6#17nmos@160_poly-right##16 A6#17nmos@160_poly-right##17 9.871
R9251 A6#17nmos@160_poly-right##17 A6#17nmos@160_poly-right##18 9.871
R9252 A6#17nmos@160_poly-right##18 A6#17nmos@160_poly-right##19 9.871
R9253 A6#17nmos@160_poly-right##19 A6#17nmos@160_poly-right##20 9.871
R9254 A6#17nmos@160_poly-right##20 A6#17nmos@160_poly-right##21 9.871
R9255 A6#17nmos@160_poly-right##21 A6#17nmos@160_poly-right##22 9.871
R9256 A6#17nmos@160_poly-right##22 A6#17nmos@160_poly-right##23 9.871
R9257 A6#17nmos@160_poly-right##23 A6#17nmos@160_poly-right##24 9.871
R9258 A6#17nmos@160_poly-right##24 A6#17nmos@160_poly-right##25 9.871
R9259 A6#17nmos@160_poly-right##25 A6#17nmos@160_poly-right##26 9.871
R9260 A6#17nmos@160_poly-right##26 A6#17nmos@160_poly-right##27 9.871
R9261 A6#17nmos@160_poly-right##27 A6#17nmos@160_poly-right##28 9.871
R9262 A6#17nmos@160_poly-right##28 A6#17nmos@160_poly-right##29 9.871
R9263 A6#17nmos@160_poly-right##29 A6#17nmos@160_poly-right##30 9.871
R9264 A6#17nmos@160_poly-right##30 A6#17nmos@160_poly-right##31 9.871
R9265 A6#17nmos@160_poly-right##31 A6#17nmos@160_poly-right##32 9.871
R9266 A6#17nmos@160_poly-right##32 A6#17nmos@160_poly-right##33 9.871
R9267 A6#17nmos@160_poly-right##33 A6#17nmos@160_poly-right##34 9.871
R9268 A6#17nmos@160_poly-right##34 A6#17nmos@160_poly-right##35 9.871
R9269 A6#17nmos@160_poly-right##35 A6#17nmos@160_poly-right##36 9.871
R9270 A6#17nmos@160_poly-right##36 A6#17nmos@160_poly-right##37 9.871
R9271 A6#17nmos@160_poly-right##37 A6#17nmos@160_poly-right##38 9.871
R9272 A6#17nmos@160_poly-right##38 A6#17nmos@160_poly-right##39 9.871
R9273 A6#17nmos@160_poly-right##39 A6#17nmos@160_poly-right##40 9.871
R9274 A6#17nmos@160_poly-right##40 A6#17nmos@160_poly-right##41 9.871
R9275 A6#17nmos@160_poly-right##41 A6#17nmos@160_poly-right##42 9.871
R9276 A6#17nmos@160_poly-right##42 A6#17nmos@160_poly-right##43 9.871
R9277 A6#17nmos@160_poly-right##43 A6#17nmos@160_poly-right##44 9.871
R9278 A6#17nmos@160_poly-right##44 A6#17nmos@160_poly-right##45 9.871
R9279 A6#17nmos@160_poly-right##45 A6#17nmos@160_poly-right##46 9.871
R9280 A6#17nmos@160_poly-right##46 A6#17nmos@160_poly-right##47 9.871
R9281 A6#17nmos@160_poly-right##47 A6#17nmos@160_poly-right##48 9.871
R9282 A6#17nmos@160_poly-right##48 A6#17nmos@160_poly-right##49 9.871
R9283 A6#17nmos@160_poly-right##49 A6#17nmos@160_poly-right##50 9.871
R9284 A6#17nmos@160_poly-right##50 A6#17nmos@160_poly-right##51 9.871
R9285 A6#17nmos@160_poly-right##51 A6#17nmos@160_poly-right##52 9.871
R9286 A6#17nmos@160_poly-right##52 A6#17nmos@160_poly-right##53 9.871
R9287 A6#17nmos@160_poly-right##53 A6#17nmos@160_poly-right##54 9.871
R9288 A6#17nmos@160_poly-right##54 A6#17nmos@160_poly-right##55 9.871
R9289 A6#17nmos@160_poly-right##55 A6#12pmos@160_poly-left 9.871
R9290 Cin_to_XOR2___NAND6#27pin@861_polysilicon-1 Cin_to_XOR2___NAND6#27pin@861_polysilicon-1##0 9.743
R9291 Cin_to_XOR2___NAND6#27pin@861_polysilicon-1##0 Cin_to_XOR2___NAND6#27pin@861_polysilicon-1##1 9.743
R9292 Cin_to_XOR2___NAND6#27pin@861_polysilicon-1##1 Cin_to_XOR2___NAND6#27pin@861_polysilicon-1##2 9.743
R9293 Cin_to_XOR2___NAND6#27pin@861_polysilicon-1##2 Cin_to_XOR2___NAND6#27pin@861_polysilicon-1##3 9.743
R9294 Cin_to_XOR2___NAND6#27pin@861_polysilicon-1##3 Cin_to_XOR2___NAND6#27pin@861_polysilicon-1##4 9.743
R9295 Cin_to_XOR2___NAND6#27pin@861_polysilicon-1##4 Cin_to_XOR2___NAND6#27pin@861_polysilicon-1##5 9.743
R9296 Cin_to_XOR2___NAND6#27pin@861_polysilicon-1##5 Cin_to_XOR2___NAND6 9.743
R9297 net@2929#7pmos@161_poly-left net@2929#7pmos@161_poly-left##0 9.871
R9298 net@2929#7pmos@161_poly-left##0 net@2929#7pmos@161_poly-left##1 9.871
R9299 net@2929#7pmos@161_poly-left##1 net@2929#7pmos@161_poly-left##2 9.871
R9300 net@2929#7pmos@161_poly-left##2 net@2929#7pmos@161_poly-left##3 9.871
R9301 net@2929#7pmos@161_poly-left##3 net@2929#7pmos@161_poly-left##4 9.871
R9302 net@2929#7pmos@161_poly-left##4 net@2929#7pmos@161_poly-left##5 9.871
R9303 net@2929#7pmos@161_poly-left##5 net@2929#7pmos@161_poly-left##6 9.871
R9304 net@2929#7pmos@161_poly-left##6 net@2929#7pmos@161_poly-left##7 9.871
R9305 net@2929#7pmos@161_poly-left##7 net@2929#7pmos@161_poly-left##8 9.871
R9306 net@2929#7pmos@161_poly-left##8 net@2929#7pmos@161_poly-left##9 9.871
R9307 net@2929#7pmos@161_poly-left##9 net@2929#7pmos@161_poly-left##10 9.871
R9308 net@2929#7pmos@161_poly-left##10 net@2929#7pmos@161_poly-left##11 9.871
R9309 net@2929#7pmos@161_poly-left##11 net@2929#7pmos@161_poly-left##12 9.871
R9310 net@2929#7pmos@161_poly-left##12 net@2929#7pmos@161_poly-left##13 9.871
R9311 net@2929#7pmos@161_poly-left##13 net@2929#7pmos@161_poly-left##14 9.871
R9312 net@2929#7pmos@161_poly-left##14 net@2929#7pmos@161_poly-left##15 9.871
R9313 net@2929#7pmos@161_poly-left##15 net@2929#7pmos@161_poly-left##16 9.871
R9314 net@2929#7pmos@161_poly-left##16 net@2929#7pmos@161_poly-left##17 9.871
R9315 net@2929#7pmos@161_poly-left##17 net@2929#7pmos@161_poly-left##18 9.871
R9316 net@2929#7pmos@161_poly-left##18 net@2929#7pmos@161_poly-left##19 9.871
R9317 net@2929#7pmos@161_poly-left##19 net@2929#7pmos@161_poly-left##20 9.871
R9318 net@2929#7pmos@161_poly-left##20 net@2929#7pmos@161_poly-left##21 9.871
R9319 net@2929#7pmos@161_poly-left##21 net@2929#7pmos@161_poly-left##22 9.871
R9320 net@2929#7pmos@161_poly-left##22 net@2929#7pmos@161_poly-left##23 9.871
R9321 net@2929#7pmos@161_poly-left##23 net@2929#7pmos@161_poly-left##24 9.871
R9322 net@2929#7pmos@161_poly-left##24 net@2929#7pmos@161_poly-left##25 9.871
R9323 net@2929#7pmos@161_poly-left##25 net@2929#7pmos@161_poly-left##26 9.871
R9324 net@2929#7pmos@161_poly-left##26 net@2929#7pmos@161_poly-left##27 9.871
R9325 net@2929#7pmos@161_poly-left##27 net@2929#7pmos@161_poly-left##28 9.871
R9326 net@2929#7pmos@161_poly-left##28 net@2929#7pmos@161_poly-left##29 9.871
R9327 net@2929#7pmos@161_poly-left##29 net@2929#7pmos@161_poly-left##30 9.871
R9328 net@2929#7pmos@161_poly-left##30 net@2929#7pmos@161_poly-left##31 9.871
R9329 net@2929#7pmos@161_poly-left##31 net@2929#7pmos@161_poly-left##32 9.871
R9330 net@2929#7pmos@161_poly-left##32 net@2929#7pmos@161_poly-left##33 9.871
R9331 net@2929#7pmos@161_poly-left##33 net@2929#7pmos@161_poly-left##34 9.871
R9332 net@2929#7pmos@161_poly-left##34 net@2929#7pmos@161_poly-left##35 9.871
R9333 net@2929#7pmos@161_poly-left##35 net@2929#7pmos@161_poly-left##36 9.871
R9334 net@2929#7pmos@161_poly-left##36 net@2929#7pmos@161_poly-left##37 9.871
R9335 net@2929#7pmos@161_poly-left##37 net@2929#7pmos@161_poly-left##38 9.871
R9336 net@2929#7pmos@161_poly-left##38 net@2929#7pmos@161_poly-left##39 9.871
R9337 net@2929#7pmos@161_poly-left##39 net@2929#7pmos@161_poly-left##40 9.871
R9338 net@2929#7pmos@161_poly-left##40 net@2929#7pmos@161_poly-left##41 9.871
R9339 net@2929#7pmos@161_poly-left##41 net@2929#7pmos@161_poly-left##42 9.871
R9340 net@2929#7pmos@161_poly-left##42 net@2929#7pmos@161_poly-left##43 9.871
R9341 net@2929#7pmos@161_poly-left##43 net@2929#7pmos@161_poly-left##44 9.871
R9342 net@2929#7pmos@161_poly-left##44 net@2929#7pmos@161_poly-left##45 9.871
R9343 net@2929#7pmos@161_poly-left##45 net@2929#7pmos@161_poly-left##46 9.871
R9344 net@2929#7pmos@161_poly-left##46 net@2929#7pmos@161_poly-left##47 9.871
R9345 net@2929#7pmos@161_poly-left##47 net@2929#7pmos@161_poly-left##48 9.871
R9346 net@2929#7pmos@161_poly-left##48 net@2929#7pmos@161_poly-left##49 9.871
R9347 net@2929#7pmos@161_poly-left##49 net@2929#7pmos@161_poly-left##50 9.871
R9348 net@2929#7pmos@161_poly-left##50 net@2929#7pmos@161_poly-left##51 9.871
R9349 net@2929#7pmos@161_poly-left##51 net@2929#7pmos@161_poly-left##52 9.871
R9350 net@2929#7pmos@161_poly-left##52 net@2929#7pmos@161_poly-left##53 9.871
R9351 net@2929#7pmos@161_poly-left##53 net@2929#7pmos@161_poly-left##54 9.871
R9352 net@2929#7pmos@161_poly-left##54 net@2929#7pmos@161_poly-left##55 9.871
R9353 net@2929#7pmos@161_poly-left##55 net@2929#11nmos@161_poly-right 9.871
R9354 B6#18pmos@162_poly-right B6#18pmos@162_poly-right##0 9.871
R9355 B6#18pmos@162_poly-right##0 B6#18pmos@162_poly-right##1 9.871
R9356 B6#18pmos@162_poly-right##1 B6#18pmos@162_poly-right##2 9.871
R9357 B6#18pmos@162_poly-right##2 B6#18pmos@162_poly-right##3 9.871
R9358 B6#18pmos@162_poly-right##3 B6#18pmos@162_poly-right##4 9.871
R9359 B6#18pmos@162_poly-right##4 B6#18pmos@162_poly-right##5 9.871
R9360 B6#18pmos@162_poly-right##5 B6#18pmos@162_poly-right##6 9.871
R9361 B6#18pmos@162_poly-right##6 B6#18pmos@162_poly-right##7 9.871
R9362 B6#18pmos@162_poly-right##7 B6#18pmos@162_poly-right##8 9.871
R9363 B6#18pmos@162_poly-right##8 B6#18pmos@162_poly-right##9 9.871
R9364 B6#18pmos@162_poly-right##9 B6#18pmos@162_poly-right##10 9.871
R9365 B6#18pmos@162_poly-right##10 B6#18pmos@162_poly-right##11 9.871
R9366 B6#18pmos@162_poly-right##11 B6#18pmos@162_poly-right##12 9.871
R9367 B6#18pmos@162_poly-right##12 B6#18pmos@162_poly-right##13 9.871
R9368 B6#18pmos@162_poly-right##13 B6#18pmos@162_poly-right##14 9.871
R9369 B6#18pmos@162_poly-right##14 B6#18pmos@162_poly-right##15 9.871
R9370 B6#18pmos@162_poly-right##15 B6#18pmos@162_poly-right##16 9.871
R9371 B6#18pmos@162_poly-right##16 B6#18pmos@162_poly-right##17 9.871
R9372 B6#18pmos@162_poly-right##17 B6#18pmos@162_poly-right##18 9.871
R9373 B6#18pmos@162_poly-right##18 B6#18pmos@162_poly-right##19 9.871
R9374 B6#18pmos@162_poly-right##19 B6#18pmos@162_poly-right##20 9.871
R9375 B6#18pmos@162_poly-right##20 B6#18pmos@162_poly-right##21 9.871
R9376 B6#18pmos@162_poly-right##21 B6#18pmos@162_poly-right##22 9.871
R9377 B6#18pmos@162_poly-right##22 B6#18pmos@162_poly-right##23 9.871
R9378 B6#18pmos@162_poly-right##23 B6#18pmos@162_poly-right##24 9.871
R9379 B6#18pmos@162_poly-right##24 B6#18pmos@162_poly-right##25 9.871
R9380 B6#18pmos@162_poly-right##25 B6#18pmos@162_poly-right##26 9.871
R9381 B6#18pmos@162_poly-right##26 B6#18pmos@162_poly-right##27 9.871
R9382 B6#18pmos@162_poly-right##27 B6#18pmos@162_poly-right##28 9.871
R9383 B6#18pmos@162_poly-right##28 B6#18pmos@162_poly-right##29 9.871
R9384 B6#18pmos@162_poly-right##29 B6#18pmos@162_poly-right##30 9.871
R9385 B6#18pmos@162_poly-right##30 B6#18pmos@162_poly-right##31 9.871
R9386 B6#18pmos@162_poly-right##31 B6#18pmos@162_poly-right##32 9.871
R9387 B6#18pmos@162_poly-right##32 B6#18pmos@162_poly-right##33 9.871
R9388 B6#18pmos@162_poly-right##33 B6#18pmos@162_poly-right##34 9.871
R9389 B6#18pmos@162_poly-right##34 B6#18pmos@162_poly-right##35 9.871
R9390 B6#18pmos@162_poly-right##35 B6#18pmos@162_poly-right##36 9.871
R9391 B6#18pmos@162_poly-right##36 B6#18pmos@162_poly-right##37 9.871
R9392 B6#18pmos@162_poly-right##37 B6#18pmos@162_poly-right##38 9.871
R9393 B6#18pmos@162_poly-right##38 B6#18pmos@162_poly-right##39 9.871
R9394 B6#18pmos@162_poly-right##39 B6#18pmos@162_poly-right##40 9.871
R9395 B6#18pmos@162_poly-right##40 B6#18pmos@162_poly-right##41 9.871
R9396 B6#18pmos@162_poly-right##41 B6#18pmos@162_poly-right##42 9.871
R9397 B6#18pmos@162_poly-right##42 B6#18pmos@162_poly-right##43 9.871
R9398 B6#18pmos@162_poly-right##43 B6#18pmos@162_poly-right##44 9.871
R9399 B6#18pmos@162_poly-right##44 B6#18pmos@162_poly-right##45 9.871
R9400 B6#18pmos@162_poly-right##45 B6#18pmos@162_poly-right##46 9.871
R9401 B6#18pmos@162_poly-right##46 B6#18pmos@162_poly-right##47 9.871
R9402 B6#18pmos@162_poly-right##47 B6#18pmos@162_poly-right##48 9.871
R9403 B6#18pmos@162_poly-right##48 B6#18pmos@162_poly-right##49 9.871
R9404 B6#18pmos@162_poly-right##49 B6#18pmos@162_poly-right##50 9.871
R9405 B6#18pmos@162_poly-right##50 B6#18pmos@162_poly-right##51 9.871
R9406 B6#18pmos@162_poly-right##51 B6#18pmos@162_poly-right##52 9.871
R9407 B6#18pmos@162_poly-right##52 B6#18pmos@162_poly-right##53 9.871
R9408 B6#18pmos@162_poly-right##53 B6#18pmos@162_poly-right##54 9.871
R9409 B6#18pmos@162_poly-right##54 B6#18pmos@162_poly-right##55 9.871
R9410 B6#18pmos@162_poly-right##55 B6#16nmos@162_poly-left 9.871
R9411 net@3046#14pmos@163_poly-right net@3046#14pmos@163_poly-right##0 9.871
R9412 net@3046#14pmos@163_poly-right##0 net@3046#14pmos@163_poly-right##1 9.871
R9413 net@3046#14pmos@163_poly-right##1 net@3046#14pmos@163_poly-right##2 9.871
R9414 net@3046#14pmos@163_poly-right##2 net@3046#14pmos@163_poly-right##3 9.871
R9415 net@3046#14pmos@163_poly-right##3 net@3046#14pmos@163_poly-right##4 9.871
R9416 net@3046#14pmos@163_poly-right##4 net@3046#14pmos@163_poly-right##5 9.871
R9417 net@3046#14pmos@163_poly-right##5 net@3046#14pmos@163_poly-right##6 9.871
R9418 net@3046#14pmos@163_poly-right##6 net@3046#14pmos@163_poly-right##7 9.871
R9419 net@3046#14pmos@163_poly-right##7 net@3046#14pmos@163_poly-right##8 9.871
R9420 net@3046#14pmos@163_poly-right##8 net@3046#14pmos@163_poly-right##9 9.871
R9421 net@3046#14pmos@163_poly-right##9 net@3046#14pmos@163_poly-right##10 9.871
R9422 net@3046#14pmos@163_poly-right##10 net@3046#14pmos@163_poly-right##11 9.871
R9423 net@3046#14pmos@163_poly-right##11 net@3046#14pmos@163_poly-right##12 9.871
R9424 net@3046#14pmos@163_poly-right##12 net@3046#14pmos@163_poly-right##13 9.871
R9425 net@3046#14pmos@163_poly-right##13 net@3046#14pmos@163_poly-right##14 9.871
R9426 net@3046#14pmos@163_poly-right##14 net@3046#14pmos@163_poly-right##15 9.871
R9427 net@3046#14pmos@163_poly-right##15 net@3046#14pmos@163_poly-right##16 9.871
R9428 net@3046#14pmos@163_poly-right##16 net@3046#14pmos@163_poly-right##17 9.871
R9429 net@3046#14pmos@163_poly-right##17 net@3046#14pmos@163_poly-right##18 9.871
R9430 net@3046#14pmos@163_poly-right##18 net@3046#14pmos@163_poly-right##19 9.871
R9431 net@3046#14pmos@163_poly-right##19 net@3046#14pmos@163_poly-right##20 9.871
R9432 net@3046#14pmos@163_poly-right##20 net@3046#14pmos@163_poly-right##21 9.871
R9433 net@3046#14pmos@163_poly-right##21 net@3046#14pmos@163_poly-right##22 9.871
R9434 net@3046#14pmos@163_poly-right##22 net@3046#14pmos@163_poly-right##23 9.871
R9435 net@3046#14pmos@163_poly-right##23 net@3046#14pmos@163_poly-right##24 9.871
R9436 net@3046#14pmos@163_poly-right##24 net@3046#14pmos@163_poly-right##25 9.871
R9437 net@3046#14pmos@163_poly-right##25 net@3046#14pmos@163_poly-right##26 9.871
R9438 net@3046#14pmos@163_poly-right##26 net@3046#14pmos@163_poly-right##27 9.871
R9439 net@3046#14pmos@163_poly-right##27 net@3046#14pmos@163_poly-right##28 9.871
R9440 net@3046#14pmos@163_poly-right##28 net@3046#14pmos@163_poly-right##29 9.871
R9441 net@3046#14pmos@163_poly-right##29 net@3046#14pmos@163_poly-right##30 9.871
R9442 net@3046#14pmos@163_poly-right##30 net@3046#14pmos@163_poly-right##31 9.871
R9443 net@3046#14pmos@163_poly-right##31 net@3046#14pmos@163_poly-right##32 9.871
R9444 net@3046#14pmos@163_poly-right##32 net@3046#14pmos@163_poly-right##33 9.871
R9445 net@3046#14pmos@163_poly-right##33 net@3046#14pmos@163_poly-right##34 9.871
R9446 net@3046#14pmos@163_poly-right##34 net@3046#14pmos@163_poly-right##35 9.871
R9447 net@3046#14pmos@163_poly-right##35 net@3046#14pmos@163_poly-right##36 9.871
R9448 net@3046#14pmos@163_poly-right##36 net@3046#14pmos@163_poly-right##37 9.871
R9449 net@3046#14pmos@163_poly-right##37 net@3046#14pmos@163_poly-right##38 9.871
R9450 net@3046#14pmos@163_poly-right##38 net@3046#14pmos@163_poly-right##39 9.871
R9451 net@3046#14pmos@163_poly-right##39 net@3046#14pmos@163_poly-right##40 9.871
R9452 net@3046#14pmos@163_poly-right##40 net@3046#14pmos@163_poly-right##41 9.871
R9453 net@3046#14pmos@163_poly-right##41 net@3046#14pmos@163_poly-right##42 9.871
R9454 net@3046#14pmos@163_poly-right##42 net@3046#14pmos@163_poly-right##43 9.871
R9455 net@3046#14pmos@163_poly-right##43 net@3046#14pmos@163_poly-right##44 9.871
R9456 net@3046#14pmos@163_poly-right##44 net@3046#14pmos@163_poly-right##45 9.871
R9457 net@3046#14pmos@163_poly-right##45 net@3046#14pmos@163_poly-right##46 9.871
R9458 net@3046#14pmos@163_poly-right##46 net@3046#14pmos@163_poly-right##47 9.871
R9459 net@3046#14pmos@163_poly-right##47 net@3046#14pmos@163_poly-right##48 9.871
R9460 net@3046#14pmos@163_poly-right##48 net@3046#14pmos@163_poly-right##49 9.871
R9461 net@3046#14pmos@163_poly-right##49 net@3046#14pmos@163_poly-right##50 9.871
R9462 net@3046#14pmos@163_poly-right##50 net@3046#14pmos@163_poly-right##51 9.871
R9463 net@3046#14pmos@163_poly-right##51 net@3046#14pmos@163_poly-right##52 9.871
R9464 net@3046#14pmos@163_poly-right##52 net@3046#14pmos@163_poly-right##53 9.871
R9465 net@3046#14pmos@163_poly-right##53 net@3046#14pmos@163_poly-right##54 9.871
R9466 net@3046#14pmos@163_poly-right##54 net@3046#14pmos@163_poly-right##55 9.871
R9467 net@3046#14pmos@163_poly-right##55 net@3046#9nmos@163_poly-left 9.871
R9468 net@3038#2contact@1039_metal-1-polysilicon-1 net@3038 4.706
R9469 net@3038#12pmos@166_poly-right net@3038#12pmos@166_poly-right##0 9.864
R9470 net@3038#12pmos@166_poly-right##0 net@3038#12pmos@166_poly-right##1 9.864
R9471 net@3038#12pmos@166_poly-right##1 net@3038#12pmos@166_poly-right##2 9.864
R9472 net@3038#12pmos@166_poly-right##2 net@3038#12pmos@166_poly-right##3 9.864
R9473 net@3038#12pmos@166_poly-right##3 net@3038#12pmos@166_poly-right##4 9.864
R9474 net@3038#12pmos@166_poly-right##4 net@3038#12pmos@166_poly-right##5 9.864
R9475 net@3038#12pmos@166_poly-right##5 net@3038#12pmos@166_poly-right##6 9.864
R9476 net@3038#12pmos@166_poly-right##6 net@3038#12pmos@166_poly-right##7 9.864
R9477 net@3038#12pmos@166_poly-right##7 net@3038#12pmos@166_poly-right##8 9.864
R9478 net@3038#12pmos@166_poly-right##8 net@3038#12pmos@166_poly-right##9 9.864
R9479 net@3038#12pmos@166_poly-right##9 net@3038#12pmos@166_poly-right##10 9.864
R9480 net@3038#12pmos@166_poly-right##10 net@3038#12pmos@166_poly-right##11 9.864
R9481 net@3038#12pmos@166_poly-right##11 net@3038#12pmos@166_poly-right##12 9.864
R9482 net@3038#12pmos@166_poly-right##12 net@3038#12pmos@166_poly-right##13 9.864
R9483 net@3038#12pmos@166_poly-right##13 net@3038#12pmos@166_poly-right##14 9.864
R9484 net@3038#12pmos@166_poly-right##14 net@3038#12pmos@166_poly-right##15 9.864
R9485 net@3038#12pmos@166_poly-right##15 net@3038#12pmos@166_poly-right##16 9.864
R9486 net@3038#12pmos@166_poly-right##16 net@3038#12pmos@166_poly-right##17 9.864
R9487 net@3038#12pmos@166_poly-right##17 net@3038#12pmos@166_poly-right##18 9.864
R9488 net@3038#12pmos@166_poly-right##18 net@3038#12pmos@166_poly-right##19 9.864
R9489 net@3038#12pmos@166_poly-right##19 net@3038#12pmos@166_poly-right##20 9.864
R9490 net@3038#12pmos@166_poly-right##20 net@3038#12pmos@166_poly-right##21 9.864
R9491 net@3038#12pmos@166_poly-right##21 net@3038#12pmos@166_poly-right##22 9.864
R9492 net@3038#12pmos@166_poly-right##22 net@3038#12pmos@166_poly-right##23 9.864
R9493 net@3038#12pmos@166_poly-right##23 net@3038#12pmos@166_poly-right##24 9.864
R9494 net@3038#12pmos@166_poly-right##24 net@3038#12pmos@166_poly-right##25 9.864
R9495 net@3038#12pmos@166_poly-right##25 net@3038#12pmos@166_poly-right##26 9.864
R9496 net@3038#12pmos@166_poly-right##26 net@3038#12pmos@166_poly-right##27 9.864
R9497 net@3038#12pmos@166_poly-right##27 net@3038#12pmos@166_poly-right##28 9.864
R9498 net@3038#12pmos@166_poly-right##28 net@3038#12pmos@166_poly-right##29 9.864
R9499 net@3038#12pmos@166_poly-right##29 net@3038#12pmos@166_poly-right##30 9.864
R9500 net@3038#12pmos@166_poly-right##30 net@3038#12pmos@166_poly-right##31 9.864
R9501 net@3038#12pmos@166_poly-right##31 net@3038#12pmos@166_poly-right##32 9.864
R9502 net@3038#12pmos@166_poly-right##32 net@3038#12pmos@166_poly-right##33 9.864
R9503 net@3038#12pmos@166_poly-right##33 net@3038#12pmos@166_poly-right##34 9.864
R9504 net@3038#12pmos@166_poly-right##34 net@3038#12pmos@166_poly-right##35 9.864
R9505 net@3038#12pmos@166_poly-right##35 net@3038#12pmos@166_poly-right##36 9.864
R9506 net@3038#12pmos@166_poly-right##36 net@3038#12pmos@166_poly-right##37 9.864
R9507 net@3038#12pmos@166_poly-right##37 net@3038#12pmos@166_poly-right##38 9.864
R9508 net@3038#12pmos@166_poly-right##38 net@3038#12pmos@166_poly-right##39 9.864
R9509 net@3038#12pmos@166_poly-right##39 net@3038#12pmos@166_poly-right##40 9.864
R9510 net@3038#12pmos@166_poly-right##40 net@3038#12pmos@166_poly-right##41 9.864
R9511 net@3038#12pmos@166_poly-right##41 net@3038#12pmos@166_poly-right##42 9.864
R9512 net@3038#12pmos@166_poly-right##42 net@3038#12pmos@166_poly-right##43 9.864
R9513 net@3038#12pmos@166_poly-right##43 net@3038#12pmos@166_poly-right##44 9.864
R9514 net@3038#12pmos@166_poly-right##44 net@3038#12pmos@166_poly-right##45 9.864
R9515 net@3038#12pmos@166_poly-right##45 net@3038#12pmos@166_poly-right##46 9.864
R9516 net@3038#12pmos@166_poly-right##46 net@3038#12pmos@166_poly-right##47 9.864
R9517 net@3038#12pmos@166_poly-right##47 net@3038#12pmos@166_poly-right##48 9.864
R9518 net@3038#12pmos@166_poly-right##48 net@3038#12pmos@166_poly-right##49 9.864
R9519 net@3038#12pmos@166_poly-right##49 net@3038#12pmos@166_poly-right##50 9.864
R9520 net@3038#12pmos@166_poly-right##50 net@3038#12pmos@166_poly-right##51 9.864
R9521 net@3038#12pmos@166_poly-right##51 net@3038#12pmos@166_poly-right##52 9.864
R9522 net@3038#12pmos@166_poly-right##52 net@3038#12pmos@166_poly-right##53 9.864
R9523 net@3038#12pmos@166_poly-right##53 net@3038#5pin@914_polysilicon-1 9.864
R9524 XOR1_to_NAND7#22pmos@166_diff-top XOR1_to_NAND7#1contact@1092_metal-1-metal-2 4.862
R9525 XOR1_to_NAND7#3pin@947_polysilicon-1 XOR1_to_NAND7#3pin@947_polysilicon-1##0 9.881
R9526 XOR1_to_NAND7#3pin@947_polysilicon-1##0 XOR1_to_NAND7#3pin@947_polysilicon-1##1 9.881
R9527 XOR1_to_NAND7#3pin@947_polysilicon-1##1 XOR1_to_NAND7#3pin@947_polysilicon-1##2 9.881
R9528 XOR1_to_NAND7#3pin@947_polysilicon-1##2 XOR1_to_NAND7#3pin@947_polysilicon-1##3 9.881
R9529 XOR1_to_NAND7#3pin@947_polysilicon-1##3 XOR1_to_NAND7#3pin@947_polysilicon-1##4 9.881
R9530 XOR1_to_NAND7#3pin@947_polysilicon-1##4 XOR1_to_NAND7#3pin@947_polysilicon-1##5 9.881
R9531 XOR1_to_NAND7#3pin@947_polysilicon-1##5 XOR1_to_NAND7#3pin@947_polysilicon-1##6 9.881
R9532 XOR1_to_NAND7#3pin@947_polysilicon-1##6 XOR1_to_NAND7#3pin@947_polysilicon-1##7 9.881
R9533 XOR1_to_NAND7#3pin@947_polysilicon-1##7 XOR1_to_NAND7#3pin@947_polysilicon-1##8 9.881
R9534 XOR1_to_NAND7#3pin@947_polysilicon-1##8 XOR1_to_NAND7#3pin@947_polysilicon-1##9 9.881
R9535 XOR1_to_NAND7#3pin@947_polysilicon-1##9 XOR1_to_NAND7#3pin@947_polysilicon-1##10 9.881
R9536 XOR1_to_NAND7#3pin@947_polysilicon-1##10 XOR1_to_NAND7#3pin@947_polysilicon-1##11 9.881
R9537 XOR1_to_NAND7#3pin@947_polysilicon-1##11 XOR1_to_NAND7#3pin@947_polysilicon-1##12 9.881
R9538 XOR1_to_NAND7#3pin@947_polysilicon-1##12 XOR1_to_NAND7#3pin@947_polysilicon-1##13 9.881
R9539 XOR1_to_NAND7#3pin@947_polysilicon-1##13 XOR1_to_NAND7#3pin@947_polysilicon-1##14 9.881
R9540 XOR1_to_NAND7#3pin@947_polysilicon-1##14 XOR1_to_NAND7#3pin@947_polysilicon-1##15 9.881
R9541 XOR1_to_NAND7#3pin@947_polysilicon-1##15 XOR1_to_NAND7#3pin@947_polysilicon-1##16 9.881
R9542 XOR1_to_NAND7#3pin@947_polysilicon-1##16 XOR1_to_NAND7#3pin@947_polysilicon-1##17 9.881
R9543 XOR1_to_NAND7#3pin@947_polysilicon-1##17 XOR1_to_NAND7#3pin@947_polysilicon-1##18 9.881
R9544 XOR1_to_NAND7#3pin@947_polysilicon-1##18 XOR1_to_NAND7#3pin@947_polysilicon-1##19 9.881
R9545 XOR1_to_NAND7#3pin@947_polysilicon-1##19 XOR1_to_NAND7#3pin@947_polysilicon-1##20 9.881
R9546 XOR1_to_NAND7#3pin@947_polysilicon-1##20 XOR1_to_NAND7#3pin@947_polysilicon-1##21 9.881
R9547 XOR1_to_NAND7#3pin@947_polysilicon-1##21 XOR1_to_NAND7#3pin@947_polysilicon-1##22 9.881
R9548 XOR1_to_NAND7#3pin@947_polysilicon-1##22 XOR1_to_NAND7#3pin@947_polysilicon-1##23 9.881
R9549 XOR1_to_NAND7#3pin@947_polysilicon-1##23 XOR1_to_NAND7#3pin@947_polysilicon-1##24 9.881
R9550 XOR1_to_NAND7#3pin@947_polysilicon-1##24 XOR1_to_NAND7#3pin@947_polysilicon-1##25 9.881
R9551 XOR1_to_NAND7#3pin@947_polysilicon-1##25 XOR1_to_NAND7#3pin@947_polysilicon-1##26 9.881
R9552 XOR1_to_NAND7#3pin@947_polysilicon-1##26 XOR1_to_NAND7#3pin@947_polysilicon-1##27 9.881
R9553 XOR1_to_NAND7#3pin@947_polysilicon-1##27 XOR1_to_NAND7#3pin@947_polysilicon-1##28 9.881
R9554 XOR1_to_NAND7#3pin@947_polysilicon-1##28 XOR1_to_NAND7#3pin@947_polysilicon-1##29 9.881
R9555 XOR1_to_NAND7#3pin@947_polysilicon-1##29 XOR1_to_NAND7#3pin@947_polysilicon-1##30 9.881
R9556 XOR1_to_NAND7#3pin@947_polysilicon-1##30 XOR1_to_NAND7#3pin@947_polysilicon-1##31 9.881
R9557 XOR1_to_NAND7#3pin@947_polysilicon-1##31 XOR1_to_NAND7#3pin@947_polysilicon-1##32 9.881
R9558 XOR1_to_NAND7#3pin@947_polysilicon-1##32 XOR1_to_NAND7#3pin@947_polysilicon-1##33 9.881
R9559 XOR1_to_NAND7#3pin@947_polysilicon-1##33 XOR1_to_NAND7#3pin@947_polysilicon-1##34 9.881
R9560 XOR1_to_NAND7#3pin@947_polysilicon-1##34 XOR1_to_NAND7#3pin@947_polysilicon-1##35 9.881
R9561 XOR1_to_NAND7#3pin@947_polysilicon-1##35 XOR1_to_NAND7#3pin@947_polysilicon-1##36 9.881
R9562 XOR1_to_NAND7#3pin@947_polysilicon-1##36 XOR1_to_NAND7#3pin@947_polysilicon-1##37 9.881
R9563 XOR1_to_NAND7#3pin@947_polysilicon-1##37 XOR1_to_NAND7#3pin@947_polysilicon-1##38 9.881
R9564 XOR1_to_NAND7#3pin@947_polysilicon-1##38 XOR1_to_NAND7#3pin@947_polysilicon-1##39 9.881
R9565 XOR1_to_NAND7#3pin@947_polysilicon-1##39 XOR1_to_NAND7#3pin@947_polysilicon-1##40 9.881
R9566 XOR1_to_NAND7#3pin@947_polysilicon-1##40 XOR1_to_NAND7#3pin@947_polysilicon-1##41 9.881
R9567 XOR1_to_NAND7#3pin@947_polysilicon-1##41 XOR1_to_NAND7#3pin@947_polysilicon-1##42 9.881
R9568 XOR1_to_NAND7#3pin@947_polysilicon-1##42 XOR1_to_NAND7#3pin@947_polysilicon-1##43 9.881
R9569 XOR1_to_NAND7#3pin@947_polysilicon-1##43 XOR1_to_NAND7#3pin@947_polysilicon-1##44 9.881
R9570 XOR1_to_NAND7#3pin@947_polysilicon-1##44 XOR1_to_NAND7#3pin@947_polysilicon-1##45 9.881
R9571 XOR1_to_NAND7#3pin@947_polysilicon-1##45 XOR1_to_NAND7#3pin@947_polysilicon-1##46 9.881
R9572 XOR1_to_NAND7#3pin@947_polysilicon-1##46 XOR1_to_NAND7#3pin@947_polysilicon-1##47 9.881
R9573 XOR1_to_NAND7#3pin@947_polysilicon-1##47 XOR1_to_NAND7#3pin@947_polysilicon-1##48 9.881
R9574 XOR1_to_NAND7#3pin@947_polysilicon-1##48 XOR1_to_NAND7#3pin@947_polysilicon-1##49 9.881
R9575 XOR1_to_NAND7#3pin@947_polysilicon-1##49 XOR1_to_NAND7#3pin@947_polysilicon-1##50 9.881
R9576 XOR1_to_NAND7#3pin@947_polysilicon-1##50 XOR1_to_NAND7#3pin@947_polysilicon-1##51 9.881
R9577 XOR1_to_NAND7#3pin@947_polysilicon-1##51 XOR1_to_NAND7#3pin@947_polysilicon-1##52 9.881
R9578 XOR1_to_NAND7#3pin@947_polysilicon-1##52 XOR1_to_NAND7#3pin@947_polysilicon-1##53 9.881
R9579 XOR1_to_NAND7#3pin@947_polysilicon-1##53 XOR1_to_NAND7#3pin@947_polysilicon-1##54 9.881
R9580 XOR1_to_NAND7#3pin@947_polysilicon-1##54 XOR1_to_NAND7#24nmos@172_poly-right 9.881
R9581 net@2931#5pmos@172_diff-top net@2931#2pin@936_metal-1 4.81
R9582 net@2931#1pin@946_polysilicon-1 net@2931#1pin@946_polysilicon-1##0 9.85
R9583 net@2931#1pin@946_polysilicon-1##0 net@2931#1pin@946_polysilicon-1##1 9.85
R9584 net@2931#1pin@946_polysilicon-1##1 net@2931#1pin@946_polysilicon-1##2 9.85
R9585 net@2931#1pin@946_polysilicon-1##2 net@2931#1pin@946_polysilicon-1##3 9.85
R9586 net@2931#1pin@946_polysilicon-1##3 net@2931#1pin@946_polysilicon-1##4 9.85
R9587 net@2931#1pin@946_polysilicon-1##4 net@2931#1pin@946_polysilicon-1##5 9.85
R9588 net@2931#1pin@946_polysilicon-1##5 net@2931#1pin@946_polysilicon-1##6 9.85
R9589 net@2931#1pin@946_polysilicon-1##6 net@2931#1pin@946_polysilicon-1##7 9.85
R9590 net@2931#1pin@946_polysilicon-1##7 net@2931#1pin@946_polysilicon-1##8 9.85
R9591 net@2931#1pin@946_polysilicon-1##8 net@2931#1pin@946_polysilicon-1##9 9.85
R9592 net@2931#1pin@946_polysilicon-1##9 net@2931#1pin@946_polysilicon-1##10 9.85
R9593 net@2931#1pin@946_polysilicon-1##10 net@2931#1pin@946_polysilicon-1##11 9.85
R9594 net@2931#1pin@946_polysilicon-1##11 net@2931#1pin@946_polysilicon-1##12 9.85
R9595 net@2931#1pin@946_polysilicon-1##12 net@2931#1pin@946_polysilicon-1##13 9.85
R9596 net@2931#1pin@946_polysilicon-1##13 net@2931#1pin@946_polysilicon-1##14 9.85
R9597 net@2931#1pin@946_polysilicon-1##14 net@2931#1pin@946_polysilicon-1##15 9.85
R9598 net@2931#1pin@946_polysilicon-1##15 net@2931#1pin@946_polysilicon-1##16 9.85
R9599 net@2931#1pin@946_polysilicon-1##16 net@2931#1pin@946_polysilicon-1##17 9.85
R9600 net@2931#1pin@946_polysilicon-1##17 net@2931#1pin@946_polysilicon-1##18 9.85
R9601 net@2931#1pin@946_polysilicon-1##18 net@2931#1pin@946_polysilicon-1##19 9.85
R9602 net@2931#1pin@946_polysilicon-1##19 net@2931#1pin@946_polysilicon-1##20 9.85
R9603 net@2931#1pin@946_polysilicon-1##20 net@2931#1pin@946_polysilicon-1##21 9.85
R9604 net@2931#1pin@946_polysilicon-1##21 net@2931#1pin@946_polysilicon-1##22 9.85
R9605 net@2931#1pin@946_polysilicon-1##22 net@2931#1pin@946_polysilicon-1##23 9.85
R9606 net@2931#1pin@946_polysilicon-1##23 net@2931#1pin@946_polysilicon-1##24 9.85
R9607 net@2931#1pin@946_polysilicon-1##24 net@2931#1pin@946_polysilicon-1##25 9.85
R9608 net@2931#1pin@946_polysilicon-1##25 net@2931#1pin@946_polysilicon-1##26 9.85
R9609 net@2931#1pin@946_polysilicon-1##26 net@2931#1pin@946_polysilicon-1##27 9.85
R9610 net@2931#1pin@946_polysilicon-1##27 net@2931#1pin@946_polysilicon-1##28 9.85
R9611 net@2931#1pin@946_polysilicon-1##28 net@2931#1pin@946_polysilicon-1##29 9.85
R9612 net@2931#1pin@946_polysilicon-1##29 net@2931#1pin@946_polysilicon-1##30 9.85
R9613 net@2931#1pin@946_polysilicon-1##30 net@2931#1pin@946_polysilicon-1##31 9.85
R9614 net@2931#1pin@946_polysilicon-1##31 net@2931#1pin@946_polysilicon-1##32 9.85
R9615 net@2931#1pin@946_polysilicon-1##32 net@2931#1pin@946_polysilicon-1##33 9.85
R9616 net@2931#1pin@946_polysilicon-1##33 net@2931#1pin@946_polysilicon-1##34 9.85
R9617 net@2931#1pin@946_polysilicon-1##34 net@2931#1pin@946_polysilicon-1##35 9.85
R9618 net@2931#1pin@946_polysilicon-1##35 net@2931#1pin@946_polysilicon-1##36 9.85
R9619 net@2931#1pin@946_polysilicon-1##36 net@2931#1pin@946_polysilicon-1##37 9.85
R9620 net@2931#1pin@946_polysilicon-1##37 net@2931#1pin@946_polysilicon-1##38 9.85
R9621 net@2931#1pin@946_polysilicon-1##38 net@2931#1pin@946_polysilicon-1##39 9.85
R9622 net@2931#1pin@946_polysilicon-1##39 net@2931#1pin@946_polysilicon-1##40 9.85
R9623 net@2931#1pin@946_polysilicon-1##40 net@2931#1pin@946_polysilicon-1##41 9.85
R9624 net@2931#1pin@946_polysilicon-1##41 net@2931#1pin@946_polysilicon-1##42 9.85
R9625 net@2931#1pin@946_polysilicon-1##42 net@2931#1pin@946_polysilicon-1##43 9.85
R9626 net@2931#1pin@946_polysilicon-1##43 net@2931#1pin@946_polysilicon-1##44 9.85
R9627 net@2931#1pin@946_polysilicon-1##44 net@2931#1pin@946_polysilicon-1##45 9.85
R9628 net@2931#1pin@946_polysilicon-1##45 net@2931#1pin@946_polysilicon-1##46 9.85
R9629 net@2931#1pin@946_polysilicon-1##46 net@2931#1pin@946_polysilicon-1##47 9.85
R9630 net@2931#1pin@946_polysilicon-1##47 net@2931#1pin@946_polysilicon-1##48 9.85
R9631 net@2931#1pin@946_polysilicon-1##48 net@2931#1pin@946_polysilicon-1##49 9.85
R9632 net@2931#1pin@946_polysilicon-1##49 net@2931#1pin@946_polysilicon-1##50 9.85
R9633 net@2931#1pin@946_polysilicon-1##50 net@2931#1pin@946_polysilicon-1##51 9.85
R9634 net@2931#1pin@946_polysilicon-1##51 net@2931#1pin@946_polysilicon-1##52 9.85
R9635 net@2931#1pin@946_polysilicon-1##52 net@2931#1pin@946_polysilicon-1##53 9.85
R9636 net@2931#1pin@946_polysilicon-1##53 net@2931#1pin@946_polysilicon-1##54 9.85
R9637 net@2931#1pin@946_polysilicon-1##54 net@2931#1pin@946_polysilicon-1##55 9.85
R9638 net@2931#1pin@946_polysilicon-1##55 net@2931#1pin@946_polysilicon-1##56 9.85
R9639 net@2931#1pin@946_polysilicon-1##56 net@2931#1pin@946_polysilicon-1##57 9.85
R9640 net@2931#1pin@946_polysilicon-1##57 net@2931#1pin@946_polysilicon-1##58 9.85
R9641 net@2931#1pin@946_polysilicon-1##58 net@2931#1pin@946_polysilicon-1##59 9.85
R9642 net@2931#1pin@946_polysilicon-1##59 net@2931#1pin@946_polysilicon-1##60 9.85
R9643 net@2931#1pin@946_polysilicon-1##60 net@2931#2pin@936_metal-1 9.85
R9644 Cin_to_XOR2___NAND7#26pmos@171_poly-right Cin_to_XOR2___NAND7#26pmos@171_poly-right##0 9.854
R9645 Cin_to_XOR2___NAND7#26pmos@171_poly-right##0 Cin_to_XOR2___NAND7#26pmos@171_poly-right##1 9.854
R9646 Cin_to_XOR2___NAND7#26pmos@171_poly-right##1 Cin_to_XOR2___NAND7#26pmos@171_poly-right##2 9.854
R9647 Cin_to_XOR2___NAND7#26pmos@171_poly-right##2 Cin_to_XOR2___NAND7#26pmos@171_poly-right##3 9.854
R9648 Cin_to_XOR2___NAND7#26pmos@171_poly-right##3 Cin_to_XOR2___NAND7#26pmos@171_poly-right##4 9.854
R9649 Cin_to_XOR2___NAND7#26pmos@171_poly-right##4 Cin_to_XOR2___NAND7#26pmos@171_poly-right##5 9.854
R9650 Cin_to_XOR2___NAND7#26pmos@171_poly-right##5 Cin_to_XOR2___NAND7#26pmos@171_poly-right##6 9.854
R9651 Cin_to_XOR2___NAND7#26pmos@171_poly-right##6 Cin_to_XOR2___NAND7#26pmos@171_poly-right##7 9.854
R9652 Cin_to_XOR2___NAND7#26pmos@171_poly-right##7 Cin_to_XOR2___NAND7#26pmos@171_poly-right##8 9.854
R9653 Cin_to_XOR2___NAND7#26pmos@171_poly-right##8 Cin_to_XOR2___NAND7#26pmos@171_poly-right##9 9.854
R9654 Cin_to_XOR2___NAND7#26pmos@171_poly-right##9 Cin_to_XOR2___NAND7#26pmos@171_poly-right##10 9.854
R9655 Cin_to_XOR2___NAND7#26pmos@171_poly-right##10 Cin_to_XOR2___NAND7#26pmos@171_poly-right##11 9.854
R9656 Cin_to_XOR2___NAND7#26pmos@171_poly-right##11 Cin_to_XOR2___NAND7#26pmos@171_poly-right##12 9.854
R9657 Cin_to_XOR2___NAND7#26pmos@171_poly-right##12 Cin_to_XOR2___NAND7#26pmos@171_poly-right##13 9.854
R9658 Cin_to_XOR2___NAND7#26pmos@171_poly-right##13 Cin_to_XOR2___NAND7#26pmos@171_poly-right##14 9.854
R9659 Cin_to_XOR2___NAND7#26pmos@171_poly-right##14 Cin_to_XOR2___NAND7#26pmos@171_poly-right##15 9.854
R9660 Cin_to_XOR2___NAND7#26pmos@171_poly-right##15 Cin_to_XOR2___NAND7#26pmos@171_poly-right##16 9.854
R9661 Cin_to_XOR2___NAND7#26pmos@171_poly-right##16 Cin_to_XOR2___NAND7#26pmos@171_poly-right##17 9.854
R9662 Cin_to_XOR2___NAND7#26pmos@171_poly-right##17 Cin_to_XOR2___NAND7#26pmos@171_poly-right##18 9.854
R9663 Cin_to_XOR2___NAND7#26pmos@171_poly-right##18 Cin_to_XOR2___NAND7#26pmos@171_poly-right##19 9.854
R9664 Cin_to_XOR2___NAND7#26pmos@171_poly-right##19 Cin_to_XOR2___NAND7#26pmos@171_poly-right##20 9.854
R9665 Cin_to_XOR2___NAND7#26pmos@171_poly-right##20 Cin_to_XOR2___NAND7#26pmos@171_poly-right##21 9.854
R9666 Cin_to_XOR2___NAND7#26pmos@171_poly-right##21 Cin_to_XOR2___NAND7#26pmos@171_poly-right##22 9.854
R9667 Cin_to_XOR2___NAND7#26pmos@171_poly-right##22 Cin_to_XOR2___NAND7#26pmos@171_poly-right##23 9.854
R9668 Cin_to_XOR2___NAND7#26pmos@171_poly-right##23 Cin_to_XOR2___NAND7#26pmos@171_poly-right##24 9.854
R9669 Cin_to_XOR2___NAND7#26pmos@171_poly-right##24 Cin_to_XOR2___NAND7#26pmos@171_poly-right##25 9.854
R9670 Cin_to_XOR2___NAND7#26pmos@171_poly-right##25 Cin_to_XOR2___NAND7#26pmos@171_poly-right##26 9.854
R9671 Cin_to_XOR2___NAND7#26pmos@171_poly-right##26 Cin_to_XOR2___NAND7#26pmos@171_poly-right##27 9.854
R9672 Cin_to_XOR2___NAND7#26pmos@171_poly-right##27 Cin_to_XOR2___NAND7#26pmos@171_poly-right##28 9.854
R9673 Cin_to_XOR2___NAND7#26pmos@171_poly-right##28 Cin_to_XOR2___NAND7#26pmos@171_poly-right##29 9.854
R9674 Cin_to_XOR2___NAND7#26pmos@171_poly-right##29 Cin_to_XOR2___NAND7#26pmos@171_poly-right##30 9.854
R9675 Cin_to_XOR2___NAND7#26pmos@171_poly-right##30 Cin_to_XOR2___NAND7#26pmos@171_poly-right##31 9.854
R9676 Cin_to_XOR2___NAND7#26pmos@171_poly-right##31 Cin_to_XOR2___NAND7#26pmos@171_poly-right##32 9.854
R9677 Cin_to_XOR2___NAND7#26pmos@171_poly-right##32 Cin_to_XOR2___NAND7#26pmos@171_poly-right##33 9.854
R9678 Cin_to_XOR2___NAND7#26pmos@171_poly-right##33 Cin_to_XOR2___NAND7#26pmos@171_poly-right##34 9.854
R9679 Cin_to_XOR2___NAND7#26pmos@171_poly-right##34 Cin_to_XOR2___NAND7#26pmos@171_poly-right##35 9.854
R9680 Cin_to_XOR2___NAND7#26pmos@171_poly-right##35 Cin_to_XOR2___NAND7#26pmos@171_poly-right##36 9.854
R9681 Cin_to_XOR2___NAND7#26pmos@171_poly-right##36 Cin_to_XOR2___NAND7#26pmos@171_poly-right##37 9.854
R9682 Cin_to_XOR2___NAND7#26pmos@171_poly-right##37 Cin_to_XOR2___NAND7#26pmos@171_poly-right##38 9.854
R9683 Cin_to_XOR2___NAND7#26pmos@171_poly-right##38 Cin_to_XOR2___NAND7#26pmos@171_poly-right##39 9.854
R9684 Cin_to_XOR2___NAND7#26pmos@171_poly-right##39 Cin_to_XOR2___NAND7#26pmos@171_poly-right##40 9.854
R9685 Cin_to_XOR2___NAND7#26pmos@171_poly-right##40 Cin_to_XOR2___NAND7#26pmos@171_poly-right##41 9.854
R9686 Cin_to_XOR2___NAND7#26pmos@171_poly-right##41 Cin_to_XOR2___NAND7#26pmos@171_poly-right##42 9.854
R9687 Cin_to_XOR2___NAND7#26pmos@171_poly-right##42 Cin_to_XOR2___NAND7#26pmos@171_poly-right##43 9.854
R9688 Cin_to_XOR2___NAND7#26pmos@171_poly-right##43 Cin_to_XOR2___NAND7#26pmos@171_poly-right##44 9.854
R9689 Cin_to_XOR2___NAND7#26pmos@171_poly-right##44 Cin_to_XOR2___NAND7#26pmos@171_poly-right##45 9.854
R9690 Cin_to_XOR2___NAND7#26pmos@171_poly-right##45 Cin_to_XOR2___NAND7#26pmos@171_poly-right##46 9.854
R9691 Cin_to_XOR2___NAND7#26pmos@171_poly-right##46 Cin_to_XOR2___NAND7#26pmos@171_poly-right##47 9.854
R9692 Cin_to_XOR2___NAND7#26pmos@171_poly-right##47 Cin_to_XOR2___NAND7#26pmos@171_poly-right##48 9.854
R9693 Cin_to_XOR2___NAND7#26pmos@171_poly-right##48 Cin_to_XOR2___NAND7#26pmos@171_poly-right##49 9.854
R9694 Cin_to_XOR2___NAND7#26pmos@171_poly-right##49 Cin_to_XOR2___NAND7#26pmos@171_poly-right##50 9.854
R9695 Cin_to_XOR2___NAND7#26pmos@171_poly-right##50 Cin_to_XOR2___NAND7#26pmos@171_poly-right##51 9.854
R9696 Cin_to_XOR2___NAND7#26pmos@171_poly-right##51 Cin_to_XOR2___NAND7#26pmos@171_poly-right##52 9.854
R9697 Cin_to_XOR2___NAND7#26pmos@171_poly-right##52 Cin_to_XOR2___NAND7#26pmos@171_poly-right##53 9.854
R9698 Cin_to_XOR2___NAND7#26pmos@171_poly-right##53 Cin_to_XOR2___NAND7#26pmos@171_poly-right##54 9.854
R9699 Cin_to_XOR2___NAND7#26pmos@171_poly-right##54 Cin_to_XOR2___NAND7#15pin@937_polysilicon-1 9.854
R9700 net@2942 net@2942#2contact@1053_metal-1-metal-2 4.797
R9701 XOR1_to_NAND7#9pmos@167_poly-left XOR1_to_NAND7#9pmos@167_poly-left##0 9.871
R9702 XOR1_to_NAND7#9pmos@167_poly-left##0 XOR1_to_NAND7#9pmos@167_poly-left##1 9.871
R9703 XOR1_to_NAND7#9pmos@167_poly-left##1 XOR1_to_NAND7#9pmos@167_poly-left##2 9.871
R9704 XOR1_to_NAND7#9pmos@167_poly-left##2 XOR1_to_NAND7#9pmos@167_poly-left##3 9.871
R9705 XOR1_to_NAND7#9pmos@167_poly-left##3 XOR1_to_NAND7#9pmos@167_poly-left##4 9.871
R9706 XOR1_to_NAND7#9pmos@167_poly-left##4 XOR1_to_NAND7#9pmos@167_poly-left##5 9.871
R9707 XOR1_to_NAND7#9pmos@167_poly-left##5 XOR1_to_NAND7#9pmos@167_poly-left##6 9.871
R9708 XOR1_to_NAND7#9pmos@167_poly-left##6 XOR1_to_NAND7#9pmos@167_poly-left##7 9.871
R9709 XOR1_to_NAND7#9pmos@167_poly-left##7 XOR1_to_NAND7#9pmos@167_poly-left##8 9.871
R9710 XOR1_to_NAND7#9pmos@167_poly-left##8 XOR1_to_NAND7#9pmos@167_poly-left##9 9.871
R9711 XOR1_to_NAND7#9pmos@167_poly-left##9 XOR1_to_NAND7#9pmos@167_poly-left##10 9.871
R9712 XOR1_to_NAND7#9pmos@167_poly-left##10 XOR1_to_NAND7#9pmos@167_poly-left##11 9.871
R9713 XOR1_to_NAND7#9pmos@167_poly-left##11 XOR1_to_NAND7#9pmos@167_poly-left##12 9.871
R9714 XOR1_to_NAND7#9pmos@167_poly-left##12 XOR1_to_NAND7#9pmos@167_poly-left##13 9.871
R9715 XOR1_to_NAND7#9pmos@167_poly-left##13 XOR1_to_NAND7#9pmos@167_poly-left##14 9.871
R9716 XOR1_to_NAND7#9pmos@167_poly-left##14 XOR1_to_NAND7#9pmos@167_poly-left##15 9.871
R9717 XOR1_to_NAND7#9pmos@167_poly-left##15 XOR1_to_NAND7#9pmos@167_poly-left##16 9.871
R9718 XOR1_to_NAND7#9pmos@167_poly-left##16 XOR1_to_NAND7#9pmos@167_poly-left##17 9.871
R9719 XOR1_to_NAND7#9pmos@167_poly-left##17 XOR1_to_NAND7#9pmos@167_poly-left##18 9.871
R9720 XOR1_to_NAND7#9pmos@167_poly-left##18 XOR1_to_NAND7#9pmos@167_poly-left##19 9.871
R9721 XOR1_to_NAND7#9pmos@167_poly-left##19 XOR1_to_NAND7#9pmos@167_poly-left##20 9.871
R9722 XOR1_to_NAND7#9pmos@167_poly-left##20 XOR1_to_NAND7#9pmos@167_poly-left##21 9.871
R9723 XOR1_to_NAND7#9pmos@167_poly-left##21 XOR1_to_NAND7#9pmos@167_poly-left##22 9.871
R9724 XOR1_to_NAND7#9pmos@167_poly-left##22 XOR1_to_NAND7#9pmos@167_poly-left##23 9.871
R9725 XOR1_to_NAND7#9pmos@167_poly-left##23 XOR1_to_NAND7#9pmos@167_poly-left##24 9.871
R9726 XOR1_to_NAND7#9pmos@167_poly-left##24 XOR1_to_NAND7#9pmos@167_poly-left##25 9.871
R9727 XOR1_to_NAND7#9pmos@167_poly-left##25 XOR1_to_NAND7#9pmos@167_poly-left##26 9.871
R9728 XOR1_to_NAND7#9pmos@167_poly-left##26 XOR1_to_NAND7#9pmos@167_poly-left##27 9.871
R9729 XOR1_to_NAND7#9pmos@167_poly-left##27 XOR1_to_NAND7#9pmos@167_poly-left##28 9.871
R9730 XOR1_to_NAND7#9pmos@167_poly-left##28 XOR1_to_NAND7#9pmos@167_poly-left##29 9.871
R9731 XOR1_to_NAND7#9pmos@167_poly-left##29 XOR1_to_NAND7#9pmos@167_poly-left##30 9.871
R9732 XOR1_to_NAND7#9pmos@167_poly-left##30 XOR1_to_NAND7#9pmos@167_poly-left##31 9.871
R9733 XOR1_to_NAND7#9pmos@167_poly-left##31 XOR1_to_NAND7#9pmos@167_poly-left##32 9.871
R9734 XOR1_to_NAND7#9pmos@167_poly-left##32 XOR1_to_NAND7#9pmos@167_poly-left##33 9.871
R9735 XOR1_to_NAND7#9pmos@167_poly-left##33 XOR1_to_NAND7#9pmos@167_poly-left##34 9.871
R9736 XOR1_to_NAND7#9pmos@167_poly-left##34 XOR1_to_NAND7#9pmos@167_poly-left##35 9.871
R9737 XOR1_to_NAND7#9pmos@167_poly-left##35 XOR1_to_NAND7#9pmos@167_poly-left##36 9.871
R9738 XOR1_to_NAND7#9pmos@167_poly-left##36 XOR1_to_NAND7#9pmos@167_poly-left##37 9.871
R9739 XOR1_to_NAND7#9pmos@167_poly-left##37 XOR1_to_NAND7#9pmos@167_poly-left##38 9.871
R9740 XOR1_to_NAND7#9pmos@167_poly-left##38 XOR1_to_NAND7#9pmos@167_poly-left##39 9.871
R9741 XOR1_to_NAND7#9pmos@167_poly-left##39 XOR1_to_NAND7#9pmos@167_poly-left##40 9.871
R9742 XOR1_to_NAND7#9pmos@167_poly-left##40 XOR1_to_NAND7#9pmos@167_poly-left##41 9.871
R9743 XOR1_to_NAND7#9pmos@167_poly-left##41 XOR1_to_NAND7#9pmos@167_poly-left##42 9.871
R9744 XOR1_to_NAND7#9pmos@167_poly-left##42 XOR1_to_NAND7#9pmos@167_poly-left##43 9.871
R9745 XOR1_to_NAND7#9pmos@167_poly-left##43 XOR1_to_NAND7#9pmos@167_poly-left##44 9.871
R9746 XOR1_to_NAND7#9pmos@167_poly-left##44 XOR1_to_NAND7#9pmos@167_poly-left##45 9.871
R9747 XOR1_to_NAND7#9pmos@167_poly-left##45 XOR1_to_NAND7#9pmos@167_poly-left##46 9.871
R9748 XOR1_to_NAND7#9pmos@167_poly-left##46 XOR1_to_NAND7#9pmos@167_poly-left##47 9.871
R9749 XOR1_to_NAND7#9pmos@167_poly-left##47 XOR1_to_NAND7#9pmos@167_poly-left##48 9.871
R9750 XOR1_to_NAND7#9pmos@167_poly-left##48 XOR1_to_NAND7#9pmos@167_poly-left##49 9.871
R9751 XOR1_to_NAND7#9pmos@167_poly-left##49 XOR1_to_NAND7#9pmos@167_poly-left##50 9.871
R9752 XOR1_to_NAND7#9pmos@167_poly-left##50 XOR1_to_NAND7#9pmos@167_poly-left##51 9.871
R9753 XOR1_to_NAND7#9pmos@167_poly-left##51 XOR1_to_NAND7#9pmos@167_poly-left##52 9.871
R9754 XOR1_to_NAND7#9pmos@167_poly-left##52 XOR1_to_NAND7#9pmos@167_poly-left##53 9.871
R9755 XOR1_to_NAND7#9pmos@167_poly-left##53 XOR1_to_NAND7#9pmos@167_poly-left##54 9.871
R9756 XOR1_to_NAND7#9pmos@167_poly-left##54 XOR1_to_NAND7#9pmos@167_poly-left##55 9.871
R9757 XOR1_to_NAND7#9pmos@167_poly-left##55 XOR1_to_NAND7#26nmos@167_poly-right 9.871
R9758 net@2931#7pmos@168_poly-left net@2931#7pmos@168_poly-left##0 9.871
R9759 net@2931#7pmos@168_poly-left##0 net@2931#7pmos@168_poly-left##1 9.871
R9760 net@2931#7pmos@168_poly-left##1 net@2931#7pmos@168_poly-left##2 9.871
R9761 net@2931#7pmos@168_poly-left##2 net@2931#7pmos@168_poly-left##3 9.871
R9762 net@2931#7pmos@168_poly-left##3 net@2931#7pmos@168_poly-left##4 9.871
R9763 net@2931#7pmos@168_poly-left##4 net@2931#7pmos@168_poly-left##5 9.871
R9764 net@2931#7pmos@168_poly-left##5 net@2931#7pmos@168_poly-left##6 9.871
R9765 net@2931#7pmos@168_poly-left##6 net@2931#7pmos@168_poly-left##7 9.871
R9766 net@2931#7pmos@168_poly-left##7 net@2931#7pmos@168_poly-left##8 9.871
R9767 net@2931#7pmos@168_poly-left##8 net@2931#7pmos@168_poly-left##9 9.871
R9768 net@2931#7pmos@168_poly-left##9 net@2931#7pmos@168_poly-left##10 9.871
R9769 net@2931#7pmos@168_poly-left##10 net@2931#7pmos@168_poly-left##11 9.871
R9770 net@2931#7pmos@168_poly-left##11 net@2931#7pmos@168_poly-left##12 9.871
R9771 net@2931#7pmos@168_poly-left##12 net@2931#7pmos@168_poly-left##13 9.871
R9772 net@2931#7pmos@168_poly-left##13 net@2931#7pmos@168_poly-left##14 9.871
R9773 net@2931#7pmos@168_poly-left##14 net@2931#7pmos@168_poly-left##15 9.871
R9774 net@2931#7pmos@168_poly-left##15 net@2931#7pmos@168_poly-left##16 9.871
R9775 net@2931#7pmos@168_poly-left##16 net@2931#7pmos@168_poly-left##17 9.871
R9776 net@2931#7pmos@168_poly-left##17 net@2931#7pmos@168_poly-left##18 9.871
R9777 net@2931#7pmos@168_poly-left##18 net@2931#7pmos@168_poly-left##19 9.871
R9778 net@2931#7pmos@168_poly-left##19 net@2931#7pmos@168_poly-left##20 9.871
R9779 net@2931#7pmos@168_poly-left##20 net@2931#7pmos@168_poly-left##21 9.871
R9780 net@2931#7pmos@168_poly-left##21 net@2931#7pmos@168_poly-left##22 9.871
R9781 net@2931#7pmos@168_poly-left##22 net@2931#7pmos@168_poly-left##23 9.871
R9782 net@2931#7pmos@168_poly-left##23 net@2931#7pmos@168_poly-left##24 9.871
R9783 net@2931#7pmos@168_poly-left##24 net@2931#7pmos@168_poly-left##25 9.871
R9784 net@2931#7pmos@168_poly-left##25 net@2931#7pmos@168_poly-left##26 9.871
R9785 net@2931#7pmos@168_poly-left##26 net@2931#7pmos@168_poly-left##27 9.871
R9786 net@2931#7pmos@168_poly-left##27 net@2931#7pmos@168_poly-left##28 9.871
R9787 net@2931#7pmos@168_poly-left##28 net@2931#7pmos@168_poly-left##29 9.871
R9788 net@2931#7pmos@168_poly-left##29 net@2931#7pmos@168_poly-left##30 9.871
R9789 net@2931#7pmos@168_poly-left##30 net@2931#7pmos@168_poly-left##31 9.871
R9790 net@2931#7pmos@168_poly-left##31 net@2931#7pmos@168_poly-left##32 9.871
R9791 net@2931#7pmos@168_poly-left##32 net@2931#7pmos@168_poly-left##33 9.871
R9792 net@2931#7pmos@168_poly-left##33 net@2931#7pmos@168_poly-left##34 9.871
R9793 net@2931#7pmos@168_poly-left##34 net@2931#7pmos@168_poly-left##35 9.871
R9794 net@2931#7pmos@168_poly-left##35 net@2931#7pmos@168_poly-left##36 9.871
R9795 net@2931#7pmos@168_poly-left##36 net@2931#7pmos@168_poly-left##37 9.871
R9796 net@2931#7pmos@168_poly-left##37 net@2931#7pmos@168_poly-left##38 9.871
R9797 net@2931#7pmos@168_poly-left##38 net@2931#7pmos@168_poly-left##39 9.871
R9798 net@2931#7pmos@168_poly-left##39 net@2931#7pmos@168_poly-left##40 9.871
R9799 net@2931#7pmos@168_poly-left##40 net@2931#7pmos@168_poly-left##41 9.871
R9800 net@2931#7pmos@168_poly-left##41 net@2931#7pmos@168_poly-left##42 9.871
R9801 net@2931#7pmos@168_poly-left##42 net@2931#7pmos@168_poly-left##43 9.871
R9802 net@2931#7pmos@168_poly-left##43 net@2931#7pmos@168_poly-left##44 9.871
R9803 net@2931#7pmos@168_poly-left##44 net@2931#7pmos@168_poly-left##45 9.871
R9804 net@2931#7pmos@168_poly-left##45 net@2931#7pmos@168_poly-left##46 9.871
R9805 net@2931#7pmos@168_poly-left##46 net@2931#7pmos@168_poly-left##47 9.871
R9806 net@2931#7pmos@168_poly-left##47 net@2931#7pmos@168_poly-left##48 9.871
R9807 net@2931#7pmos@168_poly-left##48 net@2931#7pmos@168_poly-left##49 9.871
R9808 net@2931#7pmos@168_poly-left##49 net@2931#7pmos@168_poly-left##50 9.871
R9809 net@2931#7pmos@168_poly-left##50 net@2931#7pmos@168_poly-left##51 9.871
R9810 net@2931#7pmos@168_poly-left##51 net@2931#7pmos@168_poly-left##52 9.871
R9811 net@2931#7pmos@168_poly-left##52 net@2931#7pmos@168_poly-left##53 9.871
R9812 net@2931#7pmos@168_poly-left##53 net@2931#7pmos@168_poly-left##54 9.871
R9813 net@2931#7pmos@168_poly-left##54 net@2931#7pmos@168_poly-left##55 9.871
R9814 net@2931#7pmos@168_poly-left##55 net@2931#11nmos@168_poly-right 9.871
R9815 Cin_to_XOR2___NAND7#27pmos@169_poly-right Cin_to_XOR2___NAND7#27pmos@169_poly-right##0 9.871
R9816 Cin_to_XOR2___NAND7#27pmos@169_poly-right##0 Cin_to_XOR2___NAND7#27pmos@169_poly-right##1 9.871
R9817 Cin_to_XOR2___NAND7#27pmos@169_poly-right##1 Cin_to_XOR2___NAND7#27pmos@169_poly-right##2 9.871
R9818 Cin_to_XOR2___NAND7#27pmos@169_poly-right##2 Cin_to_XOR2___NAND7#27pmos@169_poly-right##3 9.871
R9819 Cin_to_XOR2___NAND7#27pmos@169_poly-right##3 Cin_to_XOR2___NAND7#27pmos@169_poly-right##4 9.871
R9820 Cin_to_XOR2___NAND7#27pmos@169_poly-right##4 Cin_to_XOR2___NAND7#27pmos@169_poly-right##5 9.871
R9821 Cin_to_XOR2___NAND7#27pmos@169_poly-right##5 Cin_to_XOR2___NAND7#27pmos@169_poly-right##6 9.871
R9822 Cin_to_XOR2___NAND7#27pmos@169_poly-right##6 Cin_to_XOR2___NAND7#27pmos@169_poly-right##7 9.871
R9823 Cin_to_XOR2___NAND7#27pmos@169_poly-right##7 Cin_to_XOR2___NAND7#27pmos@169_poly-right##8 9.871
R9824 Cin_to_XOR2___NAND7#27pmos@169_poly-right##8 Cin_to_XOR2___NAND7#27pmos@169_poly-right##9 9.871
R9825 Cin_to_XOR2___NAND7#27pmos@169_poly-right##9 Cin_to_XOR2___NAND7#27pmos@169_poly-right##10 9.871
R9826 Cin_to_XOR2___NAND7#27pmos@169_poly-right##10 Cin_to_XOR2___NAND7#27pmos@169_poly-right##11 9.871
R9827 Cin_to_XOR2___NAND7#27pmos@169_poly-right##11 Cin_to_XOR2___NAND7#27pmos@169_poly-right##12 9.871
R9828 Cin_to_XOR2___NAND7#27pmos@169_poly-right##12 Cin_to_XOR2___NAND7#27pmos@169_poly-right##13 9.871
R9829 Cin_to_XOR2___NAND7#27pmos@169_poly-right##13 Cin_to_XOR2___NAND7#27pmos@169_poly-right##14 9.871
R9830 Cin_to_XOR2___NAND7#27pmos@169_poly-right##14 Cin_to_XOR2___NAND7#27pmos@169_poly-right##15 9.871
R9831 Cin_to_XOR2___NAND7#27pmos@169_poly-right##15 Cin_to_XOR2___NAND7#27pmos@169_poly-right##16 9.871
R9832 Cin_to_XOR2___NAND7#27pmos@169_poly-right##16 Cin_to_XOR2___NAND7#27pmos@169_poly-right##17 9.871
R9833 Cin_to_XOR2___NAND7#27pmos@169_poly-right##17 Cin_to_XOR2___NAND7#27pmos@169_poly-right##18 9.871
R9834 Cin_to_XOR2___NAND7#27pmos@169_poly-right##18 Cin_to_XOR2___NAND7#27pmos@169_poly-right##19 9.871
R9835 Cin_to_XOR2___NAND7#27pmos@169_poly-right##19 Cin_to_XOR2___NAND7#27pmos@169_poly-right##20 9.871
R9836 Cin_to_XOR2___NAND7#27pmos@169_poly-right##20 Cin_to_XOR2___NAND7#27pmos@169_poly-right##21 9.871
R9837 Cin_to_XOR2___NAND7#27pmos@169_poly-right##21 Cin_to_XOR2___NAND7#27pmos@169_poly-right##22 9.871
R9838 Cin_to_XOR2___NAND7#27pmos@169_poly-right##22 Cin_to_XOR2___NAND7#27pmos@169_poly-right##23 9.871
R9839 Cin_to_XOR2___NAND7#27pmos@169_poly-right##23 Cin_to_XOR2___NAND7#27pmos@169_poly-right##24 9.871
R9840 Cin_to_XOR2___NAND7#27pmos@169_poly-right##24 Cin_to_XOR2___NAND7#27pmos@169_poly-right##25 9.871
R9841 Cin_to_XOR2___NAND7#27pmos@169_poly-right##25 Cin_to_XOR2___NAND7#27pmos@169_poly-right##26 9.871
R9842 Cin_to_XOR2___NAND7#27pmos@169_poly-right##26 Cin_to_XOR2___NAND7#27pmos@169_poly-right##27 9.871
R9843 Cin_to_XOR2___NAND7#27pmos@169_poly-right##27 Cin_to_XOR2___NAND7#27pmos@169_poly-right##28 9.871
R9844 Cin_to_XOR2___NAND7#27pmos@169_poly-right##28 Cin_to_XOR2___NAND7#27pmos@169_poly-right##29 9.871
R9845 Cin_to_XOR2___NAND7#27pmos@169_poly-right##29 Cin_to_XOR2___NAND7#27pmos@169_poly-right##30 9.871
R9846 Cin_to_XOR2___NAND7#27pmos@169_poly-right##30 Cin_to_XOR2___NAND7#27pmos@169_poly-right##31 9.871
R9847 Cin_to_XOR2___NAND7#27pmos@169_poly-right##31 Cin_to_XOR2___NAND7#27pmos@169_poly-right##32 9.871
R9848 Cin_to_XOR2___NAND7#27pmos@169_poly-right##32 Cin_to_XOR2___NAND7#27pmos@169_poly-right##33 9.871
R9849 Cin_to_XOR2___NAND7#27pmos@169_poly-right##33 Cin_to_XOR2___NAND7#27pmos@169_poly-right##34 9.871
R9850 Cin_to_XOR2___NAND7#27pmos@169_poly-right##34 Cin_to_XOR2___NAND7#27pmos@169_poly-right##35 9.871
R9851 Cin_to_XOR2___NAND7#27pmos@169_poly-right##35 Cin_to_XOR2___NAND7#27pmos@169_poly-right##36 9.871
R9852 Cin_to_XOR2___NAND7#27pmos@169_poly-right##36 Cin_to_XOR2___NAND7#27pmos@169_poly-right##37 9.871
R9853 Cin_to_XOR2___NAND7#27pmos@169_poly-right##37 Cin_to_XOR2___NAND7#27pmos@169_poly-right##38 9.871
R9854 Cin_to_XOR2___NAND7#27pmos@169_poly-right##38 Cin_to_XOR2___NAND7#27pmos@169_poly-right##39 9.871
R9855 Cin_to_XOR2___NAND7#27pmos@169_poly-right##39 Cin_to_XOR2___NAND7#27pmos@169_poly-right##40 9.871
R9856 Cin_to_XOR2___NAND7#27pmos@169_poly-right##40 Cin_to_XOR2___NAND7#27pmos@169_poly-right##41 9.871
R9857 Cin_to_XOR2___NAND7#27pmos@169_poly-right##41 Cin_to_XOR2___NAND7#27pmos@169_poly-right##42 9.871
R9858 Cin_to_XOR2___NAND7#27pmos@169_poly-right##42 Cin_to_XOR2___NAND7#27pmos@169_poly-right##43 9.871
R9859 Cin_to_XOR2___NAND7#27pmos@169_poly-right##43 Cin_to_XOR2___NAND7#27pmos@169_poly-right##44 9.871
R9860 Cin_to_XOR2___NAND7#27pmos@169_poly-right##44 Cin_to_XOR2___NAND7#27pmos@169_poly-right##45 9.871
R9861 Cin_to_XOR2___NAND7#27pmos@169_poly-right##45 Cin_to_XOR2___NAND7#27pmos@169_poly-right##46 9.871
R9862 Cin_to_XOR2___NAND7#27pmos@169_poly-right##46 Cin_to_XOR2___NAND7#27pmos@169_poly-right##47 9.871
R9863 Cin_to_XOR2___NAND7#27pmos@169_poly-right##47 Cin_to_XOR2___NAND7#27pmos@169_poly-right##48 9.871
R9864 Cin_to_XOR2___NAND7#27pmos@169_poly-right##48 Cin_to_XOR2___NAND7#27pmos@169_poly-right##49 9.871
R9865 Cin_to_XOR2___NAND7#27pmos@169_poly-right##49 Cin_to_XOR2___NAND7#27pmos@169_poly-right##50 9.871
R9866 Cin_to_XOR2___NAND7#27pmos@169_poly-right##50 Cin_to_XOR2___NAND7#27pmos@169_poly-right##51 9.871
R9867 Cin_to_XOR2___NAND7#27pmos@169_poly-right##51 Cin_to_XOR2___NAND7#27pmos@169_poly-right##52 9.871
R9868 Cin_to_XOR2___NAND7#27pmos@169_poly-right##52 Cin_to_XOR2___NAND7#27pmos@169_poly-right##53 9.871
R9869 Cin_to_XOR2___NAND7#27pmos@169_poly-right##53 Cin_to_XOR2___NAND7#27pmos@169_poly-right##54 9.871
R9870 Cin_to_XOR2___NAND7#27pmos@169_poly-right##54 Cin_to_XOR2___NAND7#27pmos@169_poly-right##55 9.871
R9871 Cin_to_XOR2___NAND7#27pmos@169_poly-right##55 Cin_to_XOR2___NAND7#18nmos@169_poly-left 9.871
R9872 net@2942#14pmos@170_poly-right net@2942#14pmos@170_poly-right##0 9.871
R9873 net@2942#14pmos@170_poly-right##0 net@2942#14pmos@170_poly-right##1 9.871
R9874 net@2942#14pmos@170_poly-right##1 net@2942#14pmos@170_poly-right##2 9.871
R9875 net@2942#14pmos@170_poly-right##2 net@2942#14pmos@170_poly-right##3 9.871
R9876 net@2942#14pmos@170_poly-right##3 net@2942#14pmos@170_poly-right##4 9.871
R9877 net@2942#14pmos@170_poly-right##4 net@2942#14pmos@170_poly-right##5 9.871
R9878 net@2942#14pmos@170_poly-right##5 net@2942#14pmos@170_poly-right##6 9.871
R9879 net@2942#14pmos@170_poly-right##6 net@2942#14pmos@170_poly-right##7 9.871
R9880 net@2942#14pmos@170_poly-right##7 net@2942#14pmos@170_poly-right##8 9.871
R9881 net@2942#14pmos@170_poly-right##8 net@2942#14pmos@170_poly-right##9 9.871
R9882 net@2942#14pmos@170_poly-right##9 net@2942#14pmos@170_poly-right##10 9.871
R9883 net@2942#14pmos@170_poly-right##10 net@2942#14pmos@170_poly-right##11 9.871
R9884 net@2942#14pmos@170_poly-right##11 net@2942#14pmos@170_poly-right##12 9.871
R9885 net@2942#14pmos@170_poly-right##12 net@2942#14pmos@170_poly-right##13 9.871
R9886 net@2942#14pmos@170_poly-right##13 net@2942#14pmos@170_poly-right##14 9.871
R9887 net@2942#14pmos@170_poly-right##14 net@2942#14pmos@170_poly-right##15 9.871
R9888 net@2942#14pmos@170_poly-right##15 net@2942#14pmos@170_poly-right##16 9.871
R9889 net@2942#14pmos@170_poly-right##16 net@2942#14pmos@170_poly-right##17 9.871
R9890 net@2942#14pmos@170_poly-right##17 net@2942#14pmos@170_poly-right##18 9.871
R9891 net@2942#14pmos@170_poly-right##18 net@2942#14pmos@170_poly-right##19 9.871
R9892 net@2942#14pmos@170_poly-right##19 net@2942#14pmos@170_poly-right##20 9.871
R9893 net@2942#14pmos@170_poly-right##20 net@2942#14pmos@170_poly-right##21 9.871
R9894 net@2942#14pmos@170_poly-right##21 net@2942#14pmos@170_poly-right##22 9.871
R9895 net@2942#14pmos@170_poly-right##22 net@2942#14pmos@170_poly-right##23 9.871
R9896 net@2942#14pmos@170_poly-right##23 net@2942#14pmos@170_poly-right##24 9.871
R9897 net@2942#14pmos@170_poly-right##24 net@2942#14pmos@170_poly-right##25 9.871
R9898 net@2942#14pmos@170_poly-right##25 net@2942#14pmos@170_poly-right##26 9.871
R9899 net@2942#14pmos@170_poly-right##26 net@2942#14pmos@170_poly-right##27 9.871
R9900 net@2942#14pmos@170_poly-right##27 net@2942#14pmos@170_poly-right##28 9.871
R9901 net@2942#14pmos@170_poly-right##28 net@2942#14pmos@170_poly-right##29 9.871
R9902 net@2942#14pmos@170_poly-right##29 net@2942#14pmos@170_poly-right##30 9.871
R9903 net@2942#14pmos@170_poly-right##30 net@2942#14pmos@170_poly-right##31 9.871
R9904 net@2942#14pmos@170_poly-right##31 net@2942#14pmos@170_poly-right##32 9.871
R9905 net@2942#14pmos@170_poly-right##32 net@2942#14pmos@170_poly-right##33 9.871
R9906 net@2942#14pmos@170_poly-right##33 net@2942#14pmos@170_poly-right##34 9.871
R9907 net@2942#14pmos@170_poly-right##34 net@2942#14pmos@170_poly-right##35 9.871
R9908 net@2942#14pmos@170_poly-right##35 net@2942#14pmos@170_poly-right##36 9.871
R9909 net@2942#14pmos@170_poly-right##36 net@2942#14pmos@170_poly-right##37 9.871
R9910 net@2942#14pmos@170_poly-right##37 net@2942#14pmos@170_poly-right##38 9.871
R9911 net@2942#14pmos@170_poly-right##38 net@2942#14pmos@170_poly-right##39 9.871
R9912 net@2942#14pmos@170_poly-right##39 net@2942#14pmos@170_poly-right##40 9.871
R9913 net@2942#14pmos@170_poly-right##40 net@2942#14pmos@170_poly-right##41 9.871
R9914 net@2942#14pmos@170_poly-right##41 net@2942#14pmos@170_poly-right##42 9.871
R9915 net@2942#14pmos@170_poly-right##42 net@2942#14pmos@170_poly-right##43 9.871
R9916 net@2942#14pmos@170_poly-right##43 net@2942#14pmos@170_poly-right##44 9.871
R9917 net@2942#14pmos@170_poly-right##44 net@2942#14pmos@170_poly-right##45 9.871
R9918 net@2942#14pmos@170_poly-right##45 net@2942#14pmos@170_poly-right##46 9.871
R9919 net@2942#14pmos@170_poly-right##46 net@2942#14pmos@170_poly-right##47 9.871
R9920 net@2942#14pmos@170_poly-right##47 net@2942#14pmos@170_poly-right##48 9.871
R9921 net@2942#14pmos@170_poly-right##48 net@2942#14pmos@170_poly-right##49 9.871
R9922 net@2942#14pmos@170_poly-right##49 net@2942#14pmos@170_poly-right##50 9.871
R9923 net@2942#14pmos@170_poly-right##50 net@2942#14pmos@170_poly-right##51 9.871
R9924 net@2942#14pmos@170_poly-right##51 net@2942#14pmos@170_poly-right##52 9.871
R9925 net@2942#14pmos@170_poly-right##52 net@2942#14pmos@170_poly-right##53 9.871
R9926 net@2942#14pmos@170_poly-right##53 net@2942#14pmos@170_poly-right##54 9.871
R9927 net@2942#14pmos@170_poly-right##54 net@2942#14pmos@170_poly-right##55 9.871
R9928 net@2942#14pmos@170_poly-right##55 net@2942#9nmos@170_poly-left 9.871
R9929 net@2941#2contact@1078_metal-1-polysilicon-1 net@2941 4.654
R9930 net@2941#12pmos@173_poly-right net@2941#12pmos@173_poly-right##0 9.931
R9931 net@2941#12pmos@173_poly-right##0 net@2941#12pmos@173_poly-right##1 9.931
R9932 net@2941#12pmos@173_poly-right##1 net@2941#12pmos@173_poly-right##2 9.931
R9933 net@2941#12pmos@173_poly-right##2 net@2941#12pmos@173_poly-right##3 9.931
R9934 net@2941#12pmos@173_poly-right##3 net@2941#12pmos@173_poly-right##4 9.931
R9935 net@2941#12pmos@173_poly-right##4 net@2941#12pmos@173_poly-right##5 9.931
R9936 net@2941#12pmos@173_poly-right##5 net@2941#12pmos@173_poly-right##6 9.931
R9937 net@2941#12pmos@173_poly-right##6 net@2941#12pmos@173_poly-right##7 9.931
R9938 net@2941#12pmos@173_poly-right##7 net@2941#12pmos@173_poly-right##8 9.931
R9939 net@2941#12pmos@173_poly-right##8 net@2941#12pmos@173_poly-right##9 9.931
R9940 net@2941#12pmos@173_poly-right##9 net@2941#12pmos@173_poly-right##10 9.931
R9941 net@2941#12pmos@173_poly-right##10 net@2941#12pmos@173_poly-right##11 9.931
R9942 net@2941#12pmos@173_poly-right##11 net@2941#12pmos@173_poly-right##12 9.931
R9943 net@2941#12pmos@173_poly-right##12 net@2941#12pmos@173_poly-right##13 9.931
R9944 net@2941#12pmos@173_poly-right##13 net@2941#12pmos@173_poly-right##14 9.931
R9945 net@2941#12pmos@173_poly-right##14 net@2941#12pmos@173_poly-right##15 9.931
R9946 net@2941#12pmos@173_poly-right##15 net@2941#12pmos@173_poly-right##16 9.931
R9947 net@2941#12pmos@173_poly-right##16 net@2941#12pmos@173_poly-right##17 9.931
R9948 net@2941#12pmos@173_poly-right##17 net@2941#12pmos@173_poly-right##18 9.931
R9949 net@2941#12pmos@173_poly-right##18 net@2941#12pmos@173_poly-right##19 9.931
R9950 net@2941#12pmos@173_poly-right##19 net@2941#12pmos@173_poly-right##20 9.931
R9951 net@2941#12pmos@173_poly-right##20 net@2941#12pmos@173_poly-right##21 9.931
R9952 net@2941#12pmos@173_poly-right##21 net@2941#12pmos@173_poly-right##22 9.931
R9953 net@2941#12pmos@173_poly-right##22 net@2941#12pmos@173_poly-right##23 9.931
R9954 net@2941#12pmos@173_poly-right##23 net@2941#12pmos@173_poly-right##24 9.931
R9955 net@2941#12pmos@173_poly-right##24 net@2941#12pmos@173_poly-right##25 9.931
R9956 net@2941#12pmos@173_poly-right##25 net@2941#12pmos@173_poly-right##26 9.931
R9957 net@2941#12pmos@173_poly-right##26 net@2941#12pmos@173_poly-right##27 9.931
R9958 net@2941#12pmos@173_poly-right##27 net@2941#12pmos@173_poly-right##28 9.931
R9959 net@2941#12pmos@173_poly-right##28 net@2941#12pmos@173_poly-right##29 9.931
R9960 net@2941#12pmos@173_poly-right##29 net@2941#12pmos@173_poly-right##30 9.931
R9961 net@2941#12pmos@173_poly-right##30 net@2941#12pmos@173_poly-right##31 9.931
R9962 net@2941#12pmos@173_poly-right##31 net@2941#12pmos@173_poly-right##32 9.931
R9963 net@2941#12pmos@173_poly-right##32 net@2941#12pmos@173_poly-right##33 9.931
R9964 net@2941#12pmos@173_poly-right##33 net@2941#12pmos@173_poly-right##34 9.931
R9965 net@2941#12pmos@173_poly-right##34 net@2941#12pmos@173_poly-right##35 9.931
R9966 net@2941#12pmos@173_poly-right##35 net@2941#12pmos@173_poly-right##36 9.931
R9967 net@2941#12pmos@173_poly-right##36 net@2941#12pmos@173_poly-right##37 9.931
R9968 net@2941#12pmos@173_poly-right##37 net@2941#12pmos@173_poly-right##38 9.931
R9969 net@2941#12pmos@173_poly-right##38 net@2941#12pmos@173_poly-right##39 9.931
R9970 net@2941#12pmos@173_poly-right##39 net@2941#12pmos@173_poly-right##40 9.931
R9971 net@2941#12pmos@173_poly-right##40 net@2941#12pmos@173_poly-right##41 9.931
R9972 net@2941#12pmos@173_poly-right##41 net@2941#12pmos@173_poly-right##42 9.931
R9973 net@2941#12pmos@173_poly-right##42 net@2941#12pmos@173_poly-right##43 9.931
R9974 net@2941#12pmos@173_poly-right##43 net@2941#12pmos@173_poly-right##44 9.931
R9975 net@2941#12pmos@173_poly-right##44 net@2941#12pmos@173_poly-right##45 9.931
R9976 net@2941#12pmos@173_poly-right##45 net@2941#12pmos@173_poly-right##46 9.931
R9977 net@2941#12pmos@173_poly-right##46 net@2941#12pmos@173_poly-right##47 9.931
R9978 net@2941#12pmos@173_poly-right##47 net@2941#12pmos@173_poly-right##48 9.931
R9979 net@2941#12pmos@173_poly-right##48 net@2941#12pmos@173_poly-right##49 9.931
R9980 net@2941#12pmos@173_poly-right##49 net@2941#12pmos@173_poly-right##50 9.931
R9981 net@2941#12pmos@173_poly-right##50 net@2941#12pmos@173_poly-right##51 9.931
R9982 net@2941#12pmos@173_poly-right##51 net@2941#12pmos@173_poly-right##52 9.931
R9983 net@2941#12pmos@173_poly-right##52 net@2941#5pin@939_polysilicon-1 9.931
R9984 net@2962#4pmos@173_diff-top net@2962 4.823
R9985 XOR1_to_NAND7#14pin@951_polysilicon-1 XOR1_to_NAND7#14pin@951_polysilicon-1##0 9.854
R9986 XOR1_to_NAND7#14pin@951_polysilicon-1##0 XOR1_to_NAND7#14pin@951_polysilicon-1##1 9.854
R9987 XOR1_to_NAND7#14pin@951_polysilicon-1##1 XOR1_to_NAND7#14pin@951_polysilicon-1##2 9.854
R9988 XOR1_to_NAND7#14pin@951_polysilicon-1##2 XOR1_to_NAND7#14pin@951_polysilicon-1##3 9.854
R9989 XOR1_to_NAND7#14pin@951_polysilicon-1##3 XOR1_to_NAND7#14pin@951_polysilicon-1##4 9.854
R9990 XOR1_to_NAND7#14pin@951_polysilicon-1##4 XOR1_to_NAND7#14pin@951_polysilicon-1##5 9.854
R9991 XOR1_to_NAND7#14pin@951_polysilicon-1##5 XOR1_to_NAND7#14pin@951_polysilicon-1##6 9.854
R9992 XOR1_to_NAND7#14pin@951_polysilicon-1##6 XOR1_to_NAND7#14pin@951_polysilicon-1##7 9.854
R9993 XOR1_to_NAND7#14pin@951_polysilicon-1##7 XOR1_to_NAND7#14pin@951_polysilicon-1##8 9.854
R9994 XOR1_to_NAND7#14pin@951_polysilicon-1##8 XOR1_to_NAND7#14pin@951_polysilicon-1##9 9.854
R9995 XOR1_to_NAND7#14pin@951_polysilicon-1##9 XOR1_to_NAND7#14pin@951_polysilicon-1##10 9.854
R9996 XOR1_to_NAND7#14pin@951_polysilicon-1##10 XOR1_to_NAND7#14pin@951_polysilicon-1##11 9.854
R9997 XOR1_to_NAND7#14pin@951_polysilicon-1##11 XOR1_to_NAND7#14pin@951_polysilicon-1##12 9.854
R9998 XOR1_to_NAND7#14pin@951_polysilicon-1##12 XOR1_to_NAND7#14pin@951_polysilicon-1##13 9.854
R9999 XOR1_to_NAND7#14pin@951_polysilicon-1##13 XOR1_to_NAND7#14pin@951_polysilicon-1##14 9.854
R10000 XOR1_to_NAND7#14pin@951_polysilicon-1##14 XOR1_to_NAND7#14pin@951_polysilicon-1##15 9.854
R10001 XOR1_to_NAND7#14pin@951_polysilicon-1##15 XOR1_to_NAND7#14pin@951_polysilicon-1##16 9.854
R10002 XOR1_to_NAND7#14pin@951_polysilicon-1##16 XOR1_to_NAND7#14pin@951_polysilicon-1##17 9.854
R10003 XOR1_to_NAND7#14pin@951_polysilicon-1##17 XOR1_to_NAND7#14pin@951_polysilicon-1##18 9.854
R10004 XOR1_to_NAND7#14pin@951_polysilicon-1##18 XOR1_to_NAND7#14pin@951_polysilicon-1##19 9.854
R10005 XOR1_to_NAND7#14pin@951_polysilicon-1##19 XOR1_to_NAND7#14pin@951_polysilicon-1##20 9.854
R10006 XOR1_to_NAND7#14pin@951_polysilicon-1##20 XOR1_to_NAND7#14pin@951_polysilicon-1##21 9.854
R10007 XOR1_to_NAND7#14pin@951_polysilicon-1##21 XOR1_to_NAND7#14pin@951_polysilicon-1##22 9.854
R10008 XOR1_to_NAND7#14pin@951_polysilicon-1##22 XOR1_to_NAND7#14pin@951_polysilicon-1##23 9.854
R10009 XOR1_to_NAND7#14pin@951_polysilicon-1##23 XOR1_to_NAND7#14pin@951_polysilicon-1##24 9.854
R10010 XOR1_to_NAND7#14pin@951_polysilicon-1##24 XOR1_to_NAND7#14pin@951_polysilicon-1##25 9.854
R10011 XOR1_to_NAND7#14pin@951_polysilicon-1##25 XOR1_to_NAND7#14pin@951_polysilicon-1##26 9.854
R10012 XOR1_to_NAND7#14pin@951_polysilicon-1##26 XOR1_to_NAND7#14pin@951_polysilicon-1##27 9.854
R10013 XOR1_to_NAND7#14pin@951_polysilicon-1##27 XOR1_to_NAND7#14pin@951_polysilicon-1##28 9.854
R10014 XOR1_to_NAND7#14pin@951_polysilicon-1##28 XOR1_to_NAND7#14pin@951_polysilicon-1##29 9.854
R10015 XOR1_to_NAND7#14pin@951_polysilicon-1##29 XOR1_to_NAND7#14pin@951_polysilicon-1##30 9.854
R10016 XOR1_to_NAND7#14pin@951_polysilicon-1##30 XOR1_to_NAND7#14pin@951_polysilicon-1##31 9.854
R10017 XOR1_to_NAND7#14pin@951_polysilicon-1##31 XOR1_to_NAND7#14pin@951_polysilicon-1##32 9.854
R10018 XOR1_to_NAND7#14pin@951_polysilicon-1##32 XOR1_to_NAND7#14pin@951_polysilicon-1##33 9.854
R10019 XOR1_to_NAND7#14pin@951_polysilicon-1##33 XOR1_to_NAND7#14pin@951_polysilicon-1##34 9.854
R10020 XOR1_to_NAND7#14pin@951_polysilicon-1##34 XOR1_to_NAND7#14pin@951_polysilicon-1##35 9.854
R10021 XOR1_to_NAND7#14pin@951_polysilicon-1##35 XOR1_to_NAND7#14pin@951_polysilicon-1##36 9.854
R10022 XOR1_to_NAND7#14pin@951_polysilicon-1##36 XOR1_to_NAND7#14pin@951_polysilicon-1##37 9.854
R10023 XOR1_to_NAND7#14pin@951_polysilicon-1##37 XOR1_to_NAND7#14pin@951_polysilicon-1##38 9.854
R10024 XOR1_to_NAND7#14pin@951_polysilicon-1##38 XOR1_to_NAND7#14pin@951_polysilicon-1##39 9.854
R10025 XOR1_to_NAND7#14pin@951_polysilicon-1##39 XOR1_to_NAND7#14pin@951_polysilicon-1##40 9.854
R10026 XOR1_to_NAND7#14pin@951_polysilicon-1##40 XOR1_to_NAND7#14pin@951_polysilicon-1##41 9.854
R10027 XOR1_to_NAND7#14pin@951_polysilicon-1##41 XOR1_to_NAND7#14pin@951_polysilicon-1##42 9.854
R10028 XOR1_to_NAND7#14pin@951_polysilicon-1##42 XOR1_to_NAND7#14pin@951_polysilicon-1##43 9.854
R10029 XOR1_to_NAND7#14pin@951_polysilicon-1##43 XOR1_to_NAND7#14pin@951_polysilicon-1##44 9.854
R10030 XOR1_to_NAND7#14pin@951_polysilicon-1##44 XOR1_to_NAND7#14pin@951_polysilicon-1##45 9.854
R10031 XOR1_to_NAND7#14pin@951_polysilicon-1##45 XOR1_to_NAND7#14pin@951_polysilicon-1##46 9.854
R10032 XOR1_to_NAND7#14pin@951_polysilicon-1##46 XOR1_to_NAND7#14pin@951_polysilicon-1##47 9.854
R10033 XOR1_to_NAND7#14pin@951_polysilicon-1##47 XOR1_to_NAND7#14pin@951_polysilicon-1##48 9.854
R10034 XOR1_to_NAND7#14pin@951_polysilicon-1##48 XOR1_to_NAND7#14pin@951_polysilicon-1##49 9.854
R10035 XOR1_to_NAND7#14pin@951_polysilicon-1##49 XOR1_to_NAND7#14pin@951_polysilicon-1##50 9.854
R10036 XOR1_to_NAND7#14pin@951_polysilicon-1##50 XOR1_to_NAND7#14pin@951_polysilicon-1##51 9.854
R10037 XOR1_to_NAND7#14pin@951_polysilicon-1##51 XOR1_to_NAND7#14pin@951_polysilicon-1##52 9.854
R10038 XOR1_to_NAND7#14pin@951_polysilicon-1##52 XOR1_to_NAND7#14pin@951_polysilicon-1##53 9.854
R10039 XOR1_to_NAND7#14pin@951_polysilicon-1##53 XOR1_to_NAND7#14pin@951_polysilicon-1##54 9.854
R10040 XOR1_to_NAND7#14pin@951_polysilicon-1##54 XOR1_to_NAND7#27nmos@174_poly-right 9.854
R10041 Cin_to_XOR2___NAND7#29pmos@175_poly-right Cin_to_XOR2___NAND7#29pmos@175_poly-right##0 9.877
R10042 Cin_to_XOR2___NAND7#29pmos@175_poly-right##0 Cin_to_XOR2___NAND7#29pmos@175_poly-right##1 9.877
R10043 Cin_to_XOR2___NAND7#29pmos@175_poly-right##1 Cin_to_XOR2___NAND7#29pmos@175_poly-right##2 9.877
R10044 Cin_to_XOR2___NAND7#29pmos@175_poly-right##2 Cin_to_XOR2___NAND7#29pmos@175_poly-right##3 9.877
R10045 Cin_to_XOR2___NAND7#29pmos@175_poly-right##3 Cin_to_XOR2___NAND7#29pmos@175_poly-right##4 9.877
R10046 Cin_to_XOR2___NAND7#29pmos@175_poly-right##4 Cin_to_XOR2___NAND7#29pmos@175_poly-right##5 9.877
R10047 Cin_to_XOR2___NAND7#29pmos@175_poly-right##5 Cin_to_XOR2___NAND7#29pmos@175_poly-right##6 9.877
R10048 Cin_to_XOR2___NAND7#29pmos@175_poly-right##6 Cin_to_XOR2___NAND7#29pmos@175_poly-right##7 9.877
R10049 Cin_to_XOR2___NAND7#29pmos@175_poly-right##7 Cin_to_XOR2___NAND7#29pmos@175_poly-right##8 9.877
R10050 Cin_to_XOR2___NAND7#29pmos@175_poly-right##8 Cin_to_XOR2___NAND7#29pmos@175_poly-right##9 9.877
R10051 Cin_to_XOR2___NAND7#29pmos@175_poly-right##9 Cin_to_XOR2___NAND7#29pmos@175_poly-right##10 9.877
R10052 Cin_to_XOR2___NAND7#29pmos@175_poly-right##10 Cin_to_XOR2___NAND7#29pmos@175_poly-right##11 9.877
R10053 Cin_to_XOR2___NAND7#29pmos@175_poly-right##11 Cin_to_XOR2___NAND7#29pmos@175_poly-right##12 9.877
R10054 Cin_to_XOR2___NAND7#29pmos@175_poly-right##12 Cin_to_XOR2___NAND7#29pmos@175_poly-right##13 9.877
R10055 Cin_to_XOR2___NAND7#29pmos@175_poly-right##13 Cin_to_XOR2___NAND7#29pmos@175_poly-right##14 9.877
R10056 Cin_to_XOR2___NAND7#29pmos@175_poly-right##14 Cin_to_XOR2___NAND7#29pmos@175_poly-right##15 9.877
R10057 Cin_to_XOR2___NAND7#29pmos@175_poly-right##15 Cin_to_XOR2___NAND7#29pmos@175_poly-right##16 9.877
R10058 Cin_to_XOR2___NAND7#29pmos@175_poly-right##16 Cin_to_XOR2___NAND7#29pmos@175_poly-right##17 9.877
R10059 Cin_to_XOR2___NAND7#29pmos@175_poly-right##17 Cin_to_XOR2___NAND7#29pmos@175_poly-right##18 9.877
R10060 Cin_to_XOR2___NAND7#29pmos@175_poly-right##18 Cin_to_XOR2___NAND7#29pmos@175_poly-right##19 9.877
R10061 Cin_to_XOR2___NAND7#29pmos@175_poly-right##19 Cin_to_XOR2___NAND7#29pmos@175_poly-right##20 9.877
R10062 Cin_to_XOR2___NAND7#29pmos@175_poly-right##20 Cin_to_XOR2___NAND7#29pmos@175_poly-right##21 9.877
R10063 Cin_to_XOR2___NAND7#29pmos@175_poly-right##21 Cin_to_XOR2___NAND7#29pmos@175_poly-right##22 9.877
R10064 Cin_to_XOR2___NAND7#29pmos@175_poly-right##22 Cin_to_XOR2___NAND7#29pmos@175_poly-right##23 9.877
R10065 Cin_to_XOR2___NAND7#29pmos@175_poly-right##23 Cin_to_XOR2___NAND7#29pmos@175_poly-right##24 9.877
R10066 Cin_to_XOR2___NAND7#29pmos@175_poly-right##24 Cin_to_XOR2___NAND7#29pmos@175_poly-right##25 9.877
R10067 Cin_to_XOR2___NAND7#29pmos@175_poly-right##25 Cin_to_XOR2___NAND7#29pmos@175_poly-right##26 9.877
R10068 Cin_to_XOR2___NAND7#29pmos@175_poly-right##26 Cin_to_XOR2___NAND7#29pmos@175_poly-right##27 9.877
R10069 Cin_to_XOR2___NAND7#29pmos@175_poly-right##27 Cin_to_XOR2___NAND7#29pmos@175_poly-right##28 9.877
R10070 Cin_to_XOR2___NAND7#29pmos@175_poly-right##28 Cin_to_XOR2___NAND7#29pmos@175_poly-right##29 9.877
R10071 Cin_to_XOR2___NAND7#29pmos@175_poly-right##29 Cin_to_XOR2___NAND7#29pmos@175_poly-right##30 9.877
R10072 Cin_to_XOR2___NAND7#29pmos@175_poly-right##30 Cin_to_XOR2___NAND7#29pmos@175_poly-right##31 9.877
R10073 Cin_to_XOR2___NAND7#29pmos@175_poly-right##31 Cin_to_XOR2___NAND7#29pmos@175_poly-right##32 9.877
R10074 Cin_to_XOR2___NAND7#29pmos@175_poly-right##32 Cin_to_XOR2___NAND7#29pmos@175_poly-right##33 9.877
R10075 Cin_to_XOR2___NAND7#29pmos@175_poly-right##33 Cin_to_XOR2___NAND7#29pmos@175_poly-right##34 9.877
R10076 Cin_to_XOR2___NAND7#29pmos@175_poly-right##34 Cin_to_XOR2___NAND7#29pmos@175_poly-right##35 9.877
R10077 Cin_to_XOR2___NAND7#29pmos@175_poly-right##35 Cin_to_XOR2___NAND7#29pmos@175_poly-right##36 9.877
R10078 Cin_to_XOR2___NAND7#29pmos@175_poly-right##36 Cin_to_XOR2___NAND7#29pmos@175_poly-right##37 9.877
R10079 Cin_to_XOR2___NAND7#29pmos@175_poly-right##37 Cin_to_XOR2___NAND7#29pmos@175_poly-right##38 9.877
R10080 Cin_to_XOR2___NAND7#29pmos@175_poly-right##38 Cin_to_XOR2___NAND7#29pmos@175_poly-right##39 9.877
R10081 Cin_to_XOR2___NAND7#29pmos@175_poly-right##39 Cin_to_XOR2___NAND7#29pmos@175_poly-right##40 9.877
R10082 Cin_to_XOR2___NAND7#29pmos@175_poly-right##40 Cin_to_XOR2___NAND7#29pmos@175_poly-right##41 9.877
R10083 Cin_to_XOR2___NAND7#29pmos@175_poly-right##41 Cin_to_XOR2___NAND7#29pmos@175_poly-right##42 9.877
R10084 Cin_to_XOR2___NAND7#29pmos@175_poly-right##42 Cin_to_XOR2___NAND7#29pmos@175_poly-right##43 9.877
R10085 Cin_to_XOR2___NAND7#29pmos@175_poly-right##43 Cin_to_XOR2___NAND7#29pmos@175_poly-right##44 9.877
R10086 Cin_to_XOR2___NAND7#29pmos@175_poly-right##44 Cin_to_XOR2___NAND7#29pmos@175_poly-right##45 9.877
R10087 Cin_to_XOR2___NAND7#29pmos@175_poly-right##45 Cin_to_XOR2___NAND7#29pmos@175_poly-right##46 9.877
R10088 Cin_to_XOR2___NAND7#29pmos@175_poly-right##46 Cin_to_XOR2___NAND7#29pmos@175_poly-right##47 9.877
R10089 Cin_to_XOR2___NAND7#29pmos@175_poly-right##47 Cin_to_XOR2___NAND7#29pmos@175_poly-right##48 9.877
R10090 Cin_to_XOR2___NAND7#29pmos@175_poly-right##48 Cin_to_XOR2___NAND7#29pmos@175_poly-right##49 9.877
R10091 Cin_to_XOR2___NAND7#29pmos@175_poly-right##49 Cin_to_XOR2___NAND7#23pin@955_polysilicon-1 9.877
R10092 NAND1_to_NAND9 NAND1_to_NAND9#4nmos@175_diff-bottom 4.823
R10093 A6#10pin@958_polysilicon-1 A6#10pin@958_polysilicon-1##0 9.938
R10094 A6#10pin@958_polysilicon-1##0 A6#10pin@958_polysilicon-1##1 9.938
R10095 A6#10pin@958_polysilicon-1##1 A6#10pin@958_polysilicon-1##2 9.938
R10096 A6#10pin@958_polysilicon-1##2 A6#10pin@958_polysilicon-1##3 9.938
R10097 A6#10pin@958_polysilicon-1##3 A6#10pin@958_polysilicon-1##4 9.938
R10098 A6#10pin@958_polysilicon-1##4 A6#10pin@958_polysilicon-1##5 9.938
R10099 A6#10pin@958_polysilicon-1##5 A6#10pin@958_polysilicon-1##6 9.938
R10100 A6#10pin@958_polysilicon-1##6 A6#10pin@958_polysilicon-1##7 9.938
R10101 A6#10pin@958_polysilicon-1##7 A6#10pin@958_polysilicon-1##8 9.938
R10102 A6#10pin@958_polysilicon-1##8 A6#10pin@958_polysilicon-1##9 9.938
R10103 A6#10pin@958_polysilicon-1##9 A6#10pin@958_polysilicon-1##10 9.938
R10104 A6#10pin@958_polysilicon-1##10 A6#10pin@958_polysilicon-1##11 9.938
R10105 A6#10pin@958_polysilicon-1##11 A6#10pin@958_polysilicon-1##12 9.938
R10106 A6#10pin@958_polysilicon-1##12 A6#10pin@958_polysilicon-1##13 9.938
R10107 A6#10pin@958_polysilicon-1##13 A6#10pin@958_polysilicon-1##14 9.938
R10108 A6#10pin@958_polysilicon-1##14 A6#10pin@958_polysilicon-1##15 9.938
R10109 A6#10pin@958_polysilicon-1##15 A6#10pin@958_polysilicon-1##16 9.938
R10110 A6#10pin@958_polysilicon-1##16 A6#10pin@958_polysilicon-1##17 9.938
R10111 A6#10pin@958_polysilicon-1##17 A6#10pin@958_polysilicon-1##18 9.938
R10112 A6#10pin@958_polysilicon-1##18 A6#10pin@958_polysilicon-1##19 9.938
R10113 A6#10pin@958_polysilicon-1##19 A6#10pin@958_polysilicon-1##20 9.938
R10114 A6#10pin@958_polysilicon-1##20 A6#10pin@958_polysilicon-1##21 9.938
R10115 A6#10pin@958_polysilicon-1##21 A6#10pin@958_polysilicon-1##22 9.938
R10116 A6#10pin@958_polysilicon-1##22 A6#10pin@958_polysilicon-1##23 9.938
R10117 A6#10pin@958_polysilicon-1##23 A6#10pin@958_polysilicon-1##24 9.938
R10118 A6#10pin@958_polysilicon-1##24 A6#10pin@958_polysilicon-1##25 9.938
R10119 A6#10pin@958_polysilicon-1##25 A6#10pin@958_polysilicon-1##26 9.938
R10120 A6#10pin@958_polysilicon-1##26 A6#10pin@958_polysilicon-1##27 9.938
R10121 A6#10pin@958_polysilicon-1##27 A6#10pin@958_polysilicon-1##28 9.938
R10122 A6#10pin@958_polysilicon-1##28 A6#10pin@958_polysilicon-1##29 9.938
R10123 A6#10pin@958_polysilicon-1##29 A6#10pin@958_polysilicon-1##30 9.938
R10124 A6#10pin@958_polysilicon-1##30 A6#10pin@958_polysilicon-1##31 9.938
R10125 A6#10pin@958_polysilicon-1##31 A6#10pin@958_polysilicon-1##32 9.938
R10126 A6#10pin@958_polysilicon-1##32 A6#10pin@958_polysilicon-1##33 9.938
R10127 A6#10pin@958_polysilicon-1##33 A6#10pin@958_polysilicon-1##34 9.938
R10128 A6#10pin@958_polysilicon-1##34 A6#10pin@958_polysilicon-1##35 9.938
R10129 A6#10pin@958_polysilicon-1##35 A6#10pin@958_polysilicon-1##36 9.938
R10130 A6#10pin@958_polysilicon-1##36 A6#10pin@958_polysilicon-1##37 9.938
R10131 A6#10pin@958_polysilicon-1##37 A6#10pin@958_polysilicon-1##38 9.938
R10132 A6#10pin@958_polysilicon-1##38 A6#10pin@958_polysilicon-1##39 9.938
R10133 A6#10pin@958_polysilicon-1##39 A6#10pin@958_polysilicon-1##40 9.938
R10134 A6#10pin@958_polysilicon-1##40 A6#10pin@958_polysilicon-1##41 9.938
R10135 A6#10pin@958_polysilicon-1##41 A6#10pin@958_polysilicon-1##42 9.938
R10136 A6#10pin@958_polysilicon-1##42 A6#10pin@958_polysilicon-1##43 9.938
R10137 A6#10pin@958_polysilicon-1##43 A6#10pin@958_polysilicon-1##44 9.938
R10138 A6#10pin@958_polysilicon-1##44 A6#10pin@958_polysilicon-1##45 9.938
R10139 A6#10pin@958_polysilicon-1##45 A6#10pin@958_polysilicon-1##46 9.938
R10140 A6#10pin@958_polysilicon-1##46 A6#10pin@958_polysilicon-1##47 9.938
R10141 A6#10pin@958_polysilicon-1##47 A6#10pin@958_polysilicon-1##48 9.938
R10142 A6#10pin@958_polysilicon-1##48 A6#10pin@958_polysilicon-1##49 9.938
R10143 A6#10pin@958_polysilicon-1##49 A6#19nmos@176_poly-right 9.938
R10144 B6#20pmos@177_poly-right B6#20pmos@177_poly-right##0 9.869
R10145 B6#20pmos@177_poly-right##0 B6#20pmos@177_poly-right##1 9.869
R10146 B6#20pmos@177_poly-right##1 B6#20pmos@177_poly-right##2 9.869
R10147 B6#20pmos@177_poly-right##2 B6#20pmos@177_poly-right##3 9.869
R10148 B6#20pmos@177_poly-right##3 B6#20pmos@177_poly-right##4 9.869
R10149 B6#20pmos@177_poly-right##4 B6#20pmos@177_poly-right##5 9.869
R10150 B6#20pmos@177_poly-right##5 B6#20pmos@177_poly-right##6 9.869
R10151 B6#20pmos@177_poly-right##6 B6#20pmos@177_poly-right##7 9.869
R10152 B6#20pmos@177_poly-right##7 B6#20pmos@177_poly-right##8 9.869
R10153 B6#20pmos@177_poly-right##8 B6#20pmos@177_poly-right##9 9.869
R10154 B6#20pmos@177_poly-right##9 B6#20pmos@177_poly-right##10 9.869
R10155 B6#20pmos@177_poly-right##10 B6#20pmos@177_poly-right##11 9.869
R10156 B6#20pmos@177_poly-right##11 B6#20pmos@177_poly-right##12 9.869
R10157 B6#20pmos@177_poly-right##12 B6#20pmos@177_poly-right##13 9.869
R10158 B6#20pmos@177_poly-right##13 B6#20pmos@177_poly-right##14 9.869
R10159 B6#20pmos@177_poly-right##14 B6#20pmos@177_poly-right##15 9.869
R10160 B6#20pmos@177_poly-right##15 B6#20pmos@177_poly-right##16 9.869
R10161 B6#20pmos@177_poly-right##16 B6#20pmos@177_poly-right##17 9.869
R10162 B6#20pmos@177_poly-right##17 B6#20pmos@177_poly-right##18 9.869
R10163 B6#20pmos@177_poly-right##18 B6#20pmos@177_poly-right##19 9.869
R10164 B6#20pmos@177_poly-right##19 B6#20pmos@177_poly-right##20 9.869
R10165 B6#20pmos@177_poly-right##20 B6#20pmos@177_poly-right##21 9.869
R10166 B6#20pmos@177_poly-right##21 B6#20pmos@177_poly-right##22 9.869
R10167 B6#20pmos@177_poly-right##22 B6#20pmos@177_poly-right##23 9.869
R10168 B6#20pmos@177_poly-right##23 B6#20pmos@177_poly-right##24 9.869
R10169 B6#20pmos@177_poly-right##24 B6#20pmos@177_poly-right##25 9.869
R10170 B6#20pmos@177_poly-right##25 B6#20pmos@177_poly-right##26 9.869
R10171 B6#20pmos@177_poly-right##26 B6#20pmos@177_poly-right##27 9.869
R10172 B6#20pmos@177_poly-right##27 B6#20pmos@177_poly-right##28 9.869
R10173 B6#20pmos@177_poly-right##28 B6#20pmos@177_poly-right##29 9.869
R10174 B6#20pmos@177_poly-right##29 B6#20pmos@177_poly-right##30 9.869
R10175 B6#20pmos@177_poly-right##30 B6#20pmos@177_poly-right##31 9.869
R10176 B6#20pmos@177_poly-right##31 B6#20pmos@177_poly-right##32 9.869
R10177 B6#20pmos@177_poly-right##32 B6#20pmos@177_poly-right##33 9.869
R10178 B6#20pmos@177_poly-right##33 B6#20pmos@177_poly-right##34 9.869
R10179 B6#20pmos@177_poly-right##34 B6#20pmos@177_poly-right##35 9.869
R10180 B6#20pmos@177_poly-right##35 B6#20pmos@177_poly-right##36 9.869
R10181 B6#20pmos@177_poly-right##36 B6#20pmos@177_poly-right##37 9.869
R10182 B6#20pmos@177_poly-right##37 B6#20pmos@177_poly-right##38 9.869
R10183 B6#20pmos@177_poly-right##38 B6#20pmos@177_poly-right##39 9.869
R10184 B6#20pmos@177_poly-right##39 B6#20pmos@177_poly-right##40 9.869
R10185 B6#20pmos@177_poly-right##40 B6#20pmos@177_poly-right##41 9.869
R10186 B6#20pmos@177_poly-right##41 B6#20pmos@177_poly-right##42 9.869
R10187 B6#20pmos@177_poly-right##42 B6#20pmos@177_poly-right##43 9.869
R10188 B6#20pmos@177_poly-right##43 B6#20pmos@177_poly-right##44 9.869
R10189 B6#20pmos@177_poly-right##44 B6#20pmos@177_poly-right##45 9.869
R10190 B6#20pmos@177_poly-right##45 B6#20pmos@177_poly-right##46 9.869
R10191 B6#20pmos@177_poly-right##46 B6#20pmos@177_poly-right##47 9.869
R10192 B6#20pmos@177_poly-right##47 B6#10pin@962_polysilicon-1 9.869
R10193 NAND2_to_Nand9#9pin@964_polysilicon-1 NAND2_to_Nand9#9pin@964_polysilicon-1##0 9.938
R10194 NAND2_to_Nand9#9pin@964_polysilicon-1##0 NAND2_to_Nand9#9pin@964_polysilicon-1##1 9.938
R10195 NAND2_to_Nand9#9pin@964_polysilicon-1##1 NAND2_to_Nand9#9pin@964_polysilicon-1##2 9.938
R10196 NAND2_to_Nand9#9pin@964_polysilicon-1##2 NAND2_to_Nand9#9pin@964_polysilicon-1##3 9.938
R10197 NAND2_to_Nand9#9pin@964_polysilicon-1##3 NAND2_to_Nand9#9pin@964_polysilicon-1##4 9.938
R10198 NAND2_to_Nand9#9pin@964_polysilicon-1##4 NAND2_to_Nand9#9pin@964_polysilicon-1##5 9.938
R10199 NAND2_to_Nand9#9pin@964_polysilicon-1##5 NAND2_to_Nand9#9pin@964_polysilicon-1##6 9.938
R10200 NAND2_to_Nand9#9pin@964_polysilicon-1##6 NAND2_to_Nand9#9pin@964_polysilicon-1##7 9.938
R10201 NAND2_to_Nand9#9pin@964_polysilicon-1##7 NAND2_to_Nand9#9pin@964_polysilicon-1##8 9.938
R10202 NAND2_to_Nand9#9pin@964_polysilicon-1##8 NAND2_to_Nand9#9pin@964_polysilicon-1##9 9.938
R10203 NAND2_to_Nand9#9pin@964_polysilicon-1##9 NAND2_to_Nand9#9pin@964_polysilicon-1##10 9.938
R10204 NAND2_to_Nand9#9pin@964_polysilicon-1##10 NAND2_to_Nand9#9pin@964_polysilicon-1##11 9.938
R10205 NAND2_to_Nand9#9pin@964_polysilicon-1##11 NAND2_to_Nand9#9pin@964_polysilicon-1##12 9.938
R10206 NAND2_to_Nand9#9pin@964_polysilicon-1##12 NAND2_to_Nand9#9pin@964_polysilicon-1##13 9.938
R10207 NAND2_to_Nand9#9pin@964_polysilicon-1##13 NAND2_to_Nand9#9pin@964_polysilicon-1##14 9.938
R10208 NAND2_to_Nand9#9pin@964_polysilicon-1##14 NAND2_to_Nand9#9pin@964_polysilicon-1##15 9.938
R10209 NAND2_to_Nand9#9pin@964_polysilicon-1##15 NAND2_to_Nand9#9pin@964_polysilicon-1##16 9.938
R10210 NAND2_to_Nand9#9pin@964_polysilicon-1##16 NAND2_to_Nand9#9pin@964_polysilicon-1##17 9.938
R10211 NAND2_to_Nand9#9pin@964_polysilicon-1##17 NAND2_to_Nand9#9pin@964_polysilicon-1##18 9.938
R10212 NAND2_to_Nand9#9pin@964_polysilicon-1##18 NAND2_to_Nand9#9pin@964_polysilicon-1##19 9.938
R10213 NAND2_to_Nand9#9pin@964_polysilicon-1##19 NAND2_to_Nand9#9pin@964_polysilicon-1##20 9.938
R10214 NAND2_to_Nand9#9pin@964_polysilicon-1##20 NAND2_to_Nand9#9pin@964_polysilicon-1##21 9.938
R10215 NAND2_to_Nand9#9pin@964_polysilicon-1##21 NAND2_to_Nand9#9pin@964_polysilicon-1##22 9.938
R10216 NAND2_to_Nand9#9pin@964_polysilicon-1##22 NAND2_to_Nand9#9pin@964_polysilicon-1##23 9.938
R10217 NAND2_to_Nand9#9pin@964_polysilicon-1##23 NAND2_to_Nand9#9pin@964_polysilicon-1##24 9.938
R10218 NAND2_to_Nand9#9pin@964_polysilicon-1##24 NAND2_to_Nand9#9pin@964_polysilicon-1##25 9.938
R10219 NAND2_to_Nand9#9pin@964_polysilicon-1##25 NAND2_to_Nand9#9pin@964_polysilicon-1##26 9.938
R10220 NAND2_to_Nand9#9pin@964_polysilicon-1##26 NAND2_to_Nand9#9pin@964_polysilicon-1##27 9.938
R10221 NAND2_to_Nand9#9pin@964_polysilicon-1##27 NAND2_to_Nand9#9pin@964_polysilicon-1##28 9.938
R10222 NAND2_to_Nand9#9pin@964_polysilicon-1##28 NAND2_to_Nand9#9pin@964_polysilicon-1##29 9.938
R10223 NAND2_to_Nand9#9pin@964_polysilicon-1##29 NAND2_to_Nand9#9pin@964_polysilicon-1##30 9.938
R10224 NAND2_to_Nand9#9pin@964_polysilicon-1##30 NAND2_to_Nand9#9pin@964_polysilicon-1##31 9.938
R10225 NAND2_to_Nand9#9pin@964_polysilicon-1##31 NAND2_to_Nand9#9pin@964_polysilicon-1##32 9.938
R10226 NAND2_to_Nand9#9pin@964_polysilicon-1##32 NAND2_to_Nand9#9pin@964_polysilicon-1##33 9.938
R10227 NAND2_to_Nand9#9pin@964_polysilicon-1##33 NAND2_to_Nand9#9pin@964_polysilicon-1##34 9.938
R10228 NAND2_to_Nand9#9pin@964_polysilicon-1##34 NAND2_to_Nand9#9pin@964_polysilicon-1##35 9.938
R10229 NAND2_to_Nand9#9pin@964_polysilicon-1##35 NAND2_to_Nand9#9pin@964_polysilicon-1##36 9.938
R10230 NAND2_to_Nand9#9pin@964_polysilicon-1##36 NAND2_to_Nand9#9pin@964_polysilicon-1##37 9.938
R10231 NAND2_to_Nand9#9pin@964_polysilicon-1##37 NAND2_to_Nand9#9pin@964_polysilicon-1##38 9.938
R10232 NAND2_to_Nand9#9pin@964_polysilicon-1##38 NAND2_to_Nand9#9pin@964_polysilicon-1##39 9.938
R10233 NAND2_to_Nand9#9pin@964_polysilicon-1##39 NAND2_to_Nand9#9pin@964_polysilicon-1##40 9.938
R10234 NAND2_to_Nand9#9pin@964_polysilicon-1##40 NAND2_to_Nand9#9pin@964_polysilicon-1##41 9.938
R10235 NAND2_to_Nand9#9pin@964_polysilicon-1##41 NAND2_to_Nand9#9pin@964_polysilicon-1##42 9.938
R10236 NAND2_to_Nand9#9pin@964_polysilicon-1##42 NAND2_to_Nand9#9pin@964_polysilicon-1##43 9.938
R10237 NAND2_to_Nand9#9pin@964_polysilicon-1##43 NAND2_to_Nand9#9pin@964_polysilicon-1##44 9.938
R10238 NAND2_to_Nand9#9pin@964_polysilicon-1##44 NAND2_to_Nand9#9pin@964_polysilicon-1##45 9.938
R10239 NAND2_to_Nand9#9pin@964_polysilicon-1##45 NAND2_to_Nand9#9pin@964_polysilicon-1##46 9.938
R10240 NAND2_to_Nand9#9pin@964_polysilicon-1##46 NAND2_to_Nand9#9pin@964_polysilicon-1##47 9.938
R10241 NAND2_to_Nand9#9pin@964_polysilicon-1##47 NAND2_to_Nand9#9pin@964_polysilicon-1##48 9.938
R10242 NAND2_to_Nand9#9pin@964_polysilicon-1##48 NAND2_to_Nand9#9pin@964_polysilicon-1##49 9.938
R10243 NAND2_to_Nand9#9pin@964_polysilicon-1##49 NAND2_to_Nand9#11nmos@178_poly-right 9.938
R10244 NAND1_to_NAND9#14nmos@179_poly-right NAND1_to_NAND9#14nmos@179_poly-right##0 9.898
R10245 NAND1_to_NAND9#14nmos@179_poly-right##0 NAND1_to_NAND9#14nmos@179_poly-right##1 9.898
R10246 NAND1_to_NAND9#14nmos@179_poly-right##1 NAND1_to_NAND9#14nmos@179_poly-right##2 9.898
R10247 NAND1_to_NAND9#14nmos@179_poly-right##2 NAND1_to_NAND9#14nmos@179_poly-right##3 9.898
R10248 NAND1_to_NAND9#14nmos@179_poly-right##3 NAND1_to_NAND9#14nmos@179_poly-right##4 9.898
R10249 NAND1_to_NAND9#14nmos@179_poly-right##4 NAND1_to_NAND9#14nmos@179_poly-right##5 9.898
R10250 NAND1_to_NAND9#14nmos@179_poly-right##5 NAND1_to_NAND9#14nmos@179_poly-right##6 9.898
R10251 NAND1_to_NAND9#14nmos@179_poly-right##6 NAND1_to_NAND9#14nmos@179_poly-right##7 9.898
R10252 NAND1_to_NAND9#14nmos@179_poly-right##7 NAND1_to_NAND9#14nmos@179_poly-right##8 9.898
R10253 NAND1_to_NAND9#14nmos@179_poly-right##8 NAND1_to_NAND9#14nmos@179_poly-right##9 9.898
R10254 NAND1_to_NAND9#14nmos@179_poly-right##9 NAND1_to_NAND9#14nmos@179_poly-right##10 9.898
R10255 NAND1_to_NAND9#14nmos@179_poly-right##10 NAND1_to_NAND9#14nmos@179_poly-right##11 9.898
R10256 NAND1_to_NAND9#14nmos@179_poly-right##11 NAND1_to_NAND9#14nmos@179_poly-right##12 9.898
R10257 NAND1_to_NAND9#14nmos@179_poly-right##12 NAND1_to_NAND9#14nmos@179_poly-right##13 9.898
R10258 NAND1_to_NAND9#14nmos@179_poly-right##13 NAND1_to_NAND9#14nmos@179_poly-right##14 9.898
R10259 NAND1_to_NAND9#14nmos@179_poly-right##14 NAND1_to_NAND9#14nmos@179_poly-right##15 9.898
R10260 NAND1_to_NAND9#14nmos@179_poly-right##15 NAND1_to_NAND9#14nmos@179_poly-right##16 9.898
R10261 NAND1_to_NAND9#14nmos@179_poly-right##16 NAND1_to_NAND9#14nmos@179_poly-right##17 9.898
R10262 NAND1_to_NAND9#14nmos@179_poly-right##17 NAND1_to_NAND9#14nmos@179_poly-right##18 9.898
R10263 NAND1_to_NAND9#14nmos@179_poly-right##18 NAND1_to_NAND9#14nmos@179_poly-right##19 9.898
R10264 NAND1_to_NAND9#14nmos@179_poly-right##19 NAND1_to_NAND9#14nmos@179_poly-right##20 9.898
R10265 NAND1_to_NAND9#14nmos@179_poly-right##20 NAND1_to_NAND9#14nmos@179_poly-right##21 9.898
R10266 NAND1_to_NAND9#14nmos@179_poly-right##21 NAND1_to_NAND9#14nmos@179_poly-right##22 9.898
R10267 NAND1_to_NAND9#14nmos@179_poly-right##22 NAND1_to_NAND9#14nmos@179_poly-right##23 9.898
R10268 NAND1_to_NAND9#14nmos@179_poly-right##23 NAND1_to_NAND9#14nmos@179_poly-right##24 9.898
R10269 NAND1_to_NAND9#14nmos@179_poly-right##24 NAND1_to_NAND9#14nmos@179_poly-right##25 9.898
R10270 NAND1_to_NAND9#14nmos@179_poly-right##25 NAND1_to_NAND9#14nmos@179_poly-right##26 9.898
R10271 NAND1_to_NAND9#14nmos@179_poly-right##26 NAND1_to_NAND9#14nmos@179_poly-right##27 9.898
R10272 NAND1_to_NAND9#14nmos@179_poly-right##27 NAND1_to_NAND9#14nmos@179_poly-right##28 9.898
R10273 NAND1_to_NAND9#14nmos@179_poly-right##28 NAND1_to_NAND9#14nmos@179_poly-right##29 9.898
R10274 NAND1_to_NAND9#14nmos@179_poly-right##29 NAND1_to_NAND9#14nmos@179_poly-right##30 9.898
R10275 NAND1_to_NAND9#14nmos@179_poly-right##30 NAND1_to_NAND9#14nmos@179_poly-right##31 9.898
R10276 NAND1_to_NAND9#14nmos@179_poly-right##31 NAND1_to_NAND9#14nmos@179_poly-right##32 9.898
R10277 NAND1_to_NAND9#14nmos@179_poly-right##32 NAND1_to_NAND9#14nmos@179_poly-right##33 9.898
R10278 NAND1_to_NAND9#14nmos@179_poly-right##33 NAND1_to_NAND9#14nmos@179_poly-right##34 9.898
R10279 NAND1_to_NAND9#14nmos@179_poly-right##34 NAND1_to_NAND9#14nmos@179_poly-right##35 9.898
R10280 NAND1_to_NAND9#14nmos@179_poly-right##35 NAND1_to_NAND9#14nmos@179_poly-right##36 9.898
R10281 NAND1_to_NAND9#14nmos@179_poly-right##36 NAND1_to_NAND9#14nmos@179_poly-right##37 9.898
R10282 NAND1_to_NAND9#14nmos@179_poly-right##37 NAND1_to_NAND9#14nmos@179_poly-right##38 9.898
R10283 NAND1_to_NAND9#14nmos@179_poly-right##38 NAND1_to_NAND9#14nmos@179_poly-right##39 9.898
R10284 NAND1_to_NAND9#14nmos@179_poly-right##39 NAND1_to_NAND9#14nmos@179_poly-right##40 9.898
R10285 NAND1_to_NAND9#14nmos@179_poly-right##40 NAND1_to_NAND9#14nmos@179_poly-right##41 9.898
R10286 NAND1_to_NAND9#14nmos@179_poly-right##41 NAND1_to_NAND9#14nmos@179_poly-right##42 9.898
R10287 NAND1_to_NAND9#14nmos@179_poly-right##42 NAND1_to_NAND9#14nmos@179_poly-right##43 9.898
R10288 NAND1_to_NAND9#14nmos@179_poly-right##43 NAND1_to_NAND9#14nmos@179_poly-right##44 9.898
R10289 NAND1_to_NAND9#14nmos@179_poly-right##44 NAND1_to_NAND9#14nmos@179_poly-right##45 9.898
R10290 NAND1_to_NAND9#14nmos@179_poly-right##45 NAND1_to_NAND9#14nmos@179_poly-right##46 9.898
R10291 NAND1_to_NAND9#14nmos@179_poly-right##46 NAND1_to_NAND9#14nmos@179_poly-right##47 9.898
R10292 NAND1_to_NAND9#14nmos@179_poly-right##47 NAND1_to_NAND9#14nmos@179_poly-right##48 9.898
R10293 NAND1_to_NAND9#14nmos@179_poly-right##48 NAND1_to_NAND9#14nmos@179_poly-right##49 9.898
R10294 NAND1_to_NAND9#14nmos@179_poly-right##49 NAND1_to_NAND9#14nmos@179_poly-right##50 9.898
R10295 NAND1_to_NAND9#14nmos@179_poly-right##50 NAND1_to_NAND9#14nmos@179_poly-right##51 9.898
R10296 NAND1_to_NAND9#14nmos@179_poly-right##51 NAND1_to_NAND9#14nmos@179_poly-right##52 9.898
R10297 NAND1_to_NAND9#14nmos@179_poly-right##52 NAND1_to_NAND9#14nmos@179_poly-right##53 9.898
R10298 NAND1_to_NAND9#14nmos@179_poly-right##53 NAND1_to_NAND9#14nmos@179_poly-right##54 9.898
R10299 NAND1_to_NAND9#14nmos@179_poly-right##54 NAND1_to_NAND9#14nmos@179_poly-right##55 9.898
R10300 NAND1_to_NAND9#14nmos@179_poly-right##55 NAND1_to_NAND9#11pmos@179_poly-right 9.898
R10301 NAND2_to_Nand9 NAND2_to_Nand9#4nmos@177_diff-bottom 4.42
R10302 net@3235 net@3235##0 9.92
R10303 net@3235##0 net@3235##1 9.92
R10304 net@3235##1 net@3235##2 9.92
R10305 net@3235##2 net@3235##3 9.92
R10306 net@3235##3 net@3235##4 9.92
R10307 net@3235##4 net@3235##5 9.92
R10308 net@3235##5 net@3235##6 9.92
R10309 net@3235##6 net@3235##7 9.92
R10310 net@3235##7 net@3235##8 9.92
R10311 net@3235##8 net@3235##9 9.92
R10312 net@3235##9 net@3235##10 9.92
R10313 net@3235##10 net@3235##11 9.92
R10314 net@3235##11 net@3235##12 9.92
R10315 net@3235##12 net@3235##13 9.92
R10316 net@3235##13 net@3235##14 9.92
R10317 net@3235##14 net@3235##15 9.92
R10318 net@3235##15 net@3235##16 9.92
R10319 net@3235##16 net@3235##17 9.92
R10320 net@3235##17 net@3235##18 9.92
R10321 net@3235##18 net@3235#1pin@999_polysilicon-1 9.92
R10322 net@3237 net@3237##0 9.92
R10323 net@3237##0 net@3237##1 9.92
R10324 net@3237##1 net@3237##2 9.92
R10325 net@3237##2 net@3237##3 9.92
R10326 net@3237##3 net@3237##4 9.92
R10327 net@3237##4 net@3237##5 9.92
R10328 net@3237##5 net@3237##6 9.92
R10329 net@3237##6 net@3237##7 9.92
R10330 net@3237##7 net@3237##8 9.92
R10331 net@3237##8 net@3237##9 9.92
R10332 net@3237##9 net@3237##10 9.92
R10333 net@3237##10 net@3237##11 9.92
R10334 net@3237##11 net@3237##12 9.92
R10335 net@3237##12 net@3237##13 9.92
R10336 net@3237##13 net@3237##14 9.92
R10337 net@3237##14 net@3237##15 9.92
R10338 net@3237##15 net@3237##16 9.92
R10339 net@3237##16 net@3237##17 9.92
R10340 net@3237##17 net@3237##18 9.92
R10341 net@3237##18 net@3237#1pin@1024_polysilicon-1 9.92
R10342 XOR1_to_NAND8#3pin@1025_polysilicon-1 XOR1_to_NAND8#3pin@1025_polysilicon-1##0 6.2
R10343 XOR1_to_NAND8#3pin@1025_polysilicon-1##0 XOR1_to_NAND8#4pmos@192_poly-right 6.2
R10344 XOR1_to_NAND8#3pin@1025_polysilicon-1 XOR1_to_NAND8#3pin@1025_polysilicon-1##0 8.138
R10345 XOR1_to_NAND8#3pin@1025_polysilicon-1##0 XOR1_to_NAND8#3pin@1025_polysilicon-1##1 8.138
R10346 XOR1_to_NAND8#3pin@1025_polysilicon-1##1 XOR1_to_NAND8#3pin@1025_polysilicon-1##2 8.138
R10347 XOR1_to_NAND8#3pin@1025_polysilicon-1##2 XOR1_to_NAND8#1contact@1200_metal-1-metal-2 8.138
R10348 Cin_to_XOR2___NAND8#14nmos@191_poly-right Cin_to_XOR2___NAND8#14nmos@191_poly-right##0 5.425
R10349 Cin_to_XOR2___NAND8#14nmos@191_poly-right##0 Cin_to_XOR2___NAND8#15pin@1015_polysilicon-1 5.425
R10350 Cin_to_XOR2___NAND8 Cin_to_XOR2___NAND8##0 8.99
R10351 Cin_to_XOR2___NAND8##0 Cin_to_XOR2___NAND8##1 8.99
R10352 Cin_to_XOR2___NAND8##1 Cin_to_XOR2___NAND8##2 8.99
R10353 Cin_to_XOR2___NAND8##2 Cin_to_XOR2___NAND8##3 8.99
R10354 Cin_to_XOR2___NAND8##3 Cin_to_XOR2___NAND8#15pin@1015_polysilicon-1 8.99
R10355 A7#3pin@1000_polysilicon-1 A7#3pin@1000_polysilicon-1##0 6.2
R10356 A7#3pin@1000_polysilicon-1##0 A7#4pmos@185_poly-right 6.2
R10357 XOR1_to_NAND8#9pmos@187_poly-left XOR1_to_NAND8#9pmos@187_poly-left##0 8.138
R10358 XOR1_to_NAND8#9pmos@187_poly-left##0 XOR1_to_NAND8#9pmos@187_poly-left##1 8.138
R10359 XOR1_to_NAND8#9pmos@187_poly-left##1 XOR1_to_NAND8#9pmos@187_poly-left##2 8.138
R10360 XOR1_to_NAND8#9pmos@187_poly-left##2 XOR1_to_NAND8#10pin@1012_polysilicon-1 8.138
R10361 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##0 9.843
R10362 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##0 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##1 9.843
R10363 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##1 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##2 9.843
R10364 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##2 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##3 9.843
R10365 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##3 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##4 9.843
R10366 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##4 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##5 9.843
R10367 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##5 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##6 9.843
R10368 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##6 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##7 9.843
R10369 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##7 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##8 9.843
R10370 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##8 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##9 9.843
R10371 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##9 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##10 9.843
R10372 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##10 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##11 9.843
R10373 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##11 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##12 9.843
R10374 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##12 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##13 9.843
R10375 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##13 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##14 9.843
R10376 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##14 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##15 9.843
R10377 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##15 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##16 9.843
R10378 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##16 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##17 9.843
R10379 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##17 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##18 9.843
R10380 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1##18 Cin_to_XOR2___NAND8#17pin@1022_polysilicon-1 9.843
R10381 net@3247#4nmos@193_poly-right net@3247#4nmos@193_poly-right##0 9.3
R10382 net@3247#4nmos@193_poly-right##0 net@3247#4nmos@193_poly-right##1 9.3
R10383 net@3247#4nmos@193_poly-right##1 net@3247#5pin@1017_polysilicon-1 9.3
R10384 net@3247#2contact@1186_metal-1-polysilicon-1 net@3247#2contact@1186_metal-1-polysilicon-1##0 8.99
R10385 net@3247#2contact@1186_metal-1-polysilicon-1##0 net@3247#2contact@1186_metal-1-polysilicon-1##1 8.99
R10386 net@3247#2contact@1186_metal-1-polysilicon-1##1 net@3247#2contact@1186_metal-1-polysilicon-1##2 8.99
R10387 net@3247#2contact@1186_metal-1-polysilicon-1##2 net@3247#2contact@1186_metal-1-polysilicon-1##3 8.99
R10388 net@3247#2contact@1186_metal-1-polysilicon-1##3 net@3247#5pin@1017_polysilicon-1 8.99
R10389 A7#3pin@1000_polysilicon-1 A7#3pin@1000_polysilicon-1##0 8.138
R10390 A7#3pin@1000_polysilicon-1##0 A7#3pin@1000_polysilicon-1##1 8.138
R10391 A7#3pin@1000_polysilicon-1##1 A7#3pin@1000_polysilicon-1##2 8.138
R10392 A7#3pin@1000_polysilicon-1##2 A7#1pin@1039_metal-2 8.138
R10393 XOR1_to_NAND8#1contact@1200_metal-1-metal-2 XOR1_to_NAND8#1contact@1200_metal-1-metal-2##0 6.717
R10394 XOR1_to_NAND8#1contact@1200_metal-1-metal-2##0 XOR1_to_NAND8#1contact@1200_metal-1-metal-2##1 6.717
R10395 XOR1_to_NAND8#1contact@1200_metal-1-metal-2##1 XOR1_to_NAND8#12pin@1013_polysilicon-1 6.717
R10396 XOR1_to_NAND8#10pin@1012_polysilicon-1 XOR1_to_NAND8#10pin@1012_polysilicon-1##0 7.75
R10397 XOR1_to_NAND8#10pin@1012_polysilicon-1##0 XOR1_to_NAND8#10pin@1012_polysilicon-1##1 7.75
R10398 XOR1_to_NAND8#10pin@1012_polysilicon-1##1 XOR1_to_NAND8#12pin@1013_polysilicon-1 7.75
R10399 Cin_to_XOR2___NAND8#17pin@1022_polysilicon-1 Cin_to_XOR2___NAND8#17pin@1022_polysilicon-1##0 9.743
R10400 Cin_to_XOR2___NAND8#17pin@1022_polysilicon-1##0 Cin_to_XOR2___NAND8#17pin@1022_polysilicon-1##1 9.743
R10401 Cin_to_XOR2___NAND8#17pin@1022_polysilicon-1##1 Cin_to_XOR2___NAND8#17pin@1022_polysilicon-1##2 9.743
R10402 Cin_to_XOR2___NAND8#17pin@1022_polysilicon-1##2 Cin_to_XOR2___NAND8#17pin@1022_polysilicon-1##3 9.743
R10403 Cin_to_XOR2___NAND8#17pin@1022_polysilicon-1##3 Cin_to_XOR2___NAND8#17pin@1022_polysilicon-1##4 9.743
R10404 Cin_to_XOR2___NAND8#17pin@1022_polysilicon-1##4 Cin_to_XOR2___NAND8#17pin@1022_polysilicon-1##5 9.743
R10405 Cin_to_XOR2___NAND8#17pin@1022_polysilicon-1##5 Cin_to_XOR2___NAND8 9.743
R10406 net@2789#5pmos@148_poly-right net@2789#5pmos@148_poly-right##0 7.75
R10407 net@2789#5pmos@148_poly-right##0 net@2789#8pin@862_polysilicon-1 7.75
R10408 net@3237#7pmos@188_poly-left net@3237#7pmos@188_poly-left##0 7.75
R10409 net@3237#7pmos@188_poly-left##0 net@3237 7.75
R10410 Cin_to_XOR2___NAND8#18nmos@189_poly-left Cin_to_XOR2___NAND8#18nmos@189_poly-left##0 6.2
R10411 Cin_to_XOR2___NAND8#18nmos@189_poly-left##0 Cin_to_XOR2___NAND8#16pin@1005_polysilicon-1 6.2
R10412 net@3248#9nmos@190_poly-left net@3248#9nmos@190_poly-left##0 8.37
R10413 net@3248#9nmos@190_poly-left##0 net@3248#9nmos@190_poly-left##1 8.37
R10414 net@3248#9nmos@190_poly-left##1 net@3248#9nmos@190_poly-left##2 8.37
R10415 net@3248#9nmos@190_poly-left##2 net@3248#9nmos@190_poly-left##3 8.37
R10416 net@3248#9nmos@190_poly-left##3 net@3248#2contact@1161_metal-1-metal-2 8.37
R10417 XOR1_to_NAND8 XOR1_to_NAND8##0 6.717
R10418 XOR1_to_NAND8##0 XOR1_to_NAND8##1 6.717
R10419 XOR1_to_NAND8##1 XOR1_to_NAND8#14pin@1029_polysilicon-1 6.717
R10420 XOR1_to_NAND8#16pmos@194_poly-right XOR1_to_NAND8#16pmos@194_poly-right##0 6.2
R10421 XOR1_to_NAND8#16pmos@194_poly-right##0 XOR1_to_NAND8#14pin@1029_polysilicon-1 6.2
R10422 Cin_to_XOR2___NAND8#23pin@1033_polysilicon-1 Cin_to_XOR2___NAND8#23pin@1033_polysilicon-1##0 9.688
R10423 Cin_to_XOR2___NAND8#23pin@1033_polysilicon-1##0 Cin_to_XOR2___NAND8#23pin@1033_polysilicon-1##1 9.688
R10424 Cin_to_XOR2___NAND8#23pin@1033_polysilicon-1##1 Cin_to_XOR2___NAND8#23pin@1033_polysilicon-1##2 9.688
R10425 Cin_to_XOR2___NAND8#23pin@1033_polysilicon-1##2 Cin_to_XOR2___NAND8#20contact@1199_metal-1-metal-2 9.688
R10426 Cin_to_XOR2___NAND8#20contact@1199_metal-1-metal-2 Cin_to_XOR2___NAND8 4.953
R10427 A7#0contact@1208_metal-1-metal-2 A7#0contact@1208_metal-1-metal-2##0 6.717
R10428 A7#0contact@1208_metal-1-metal-2##0 A7#0contact@1208_metal-1-metal-2##1 6.717
R10429 A7#0contact@1208_metal-1-metal-2##1 A7#10pin@1036_polysilicon-1 6.717
R10430 A7#11pmos@196_poly-right A7#11pmos@196_poly-right##0 9.558
R10431 A7#11pmos@196_poly-right##0 A7#11pmos@196_poly-right##1 9.558
R10432 A7#11pmos@196_poly-right##1 A7#11pmos@196_poly-right##2 9.558
R10433 A7#11pmos@196_poly-right##2 A7#11pmos@196_poly-right##3 9.558
R10434 A7#11pmos@196_poly-right##3 A7#11pmos@196_poly-right##4 9.558
R10435 A7#11pmos@196_poly-right##4 A7#10pin@1036_polysilicon-1 9.558
R10436 XOR1_to_NAND6#18pin@864_polysilicon-1 XOR1_to_NAND6#18pin@864_polysilicon-1##0 6.2
R10437 XOR1_to_NAND6#18pin@864_polysilicon-1##0 XOR1_to_NAND6#27pmos@152_poly-right 6.2
R10438 B7#10pin@1040_polysilicon-1 B7#10pin@1040_polysilicon-1##0 8.138
R10439 B7#10pin@1040_polysilicon-1##0 B7#10pin@1040_polysilicon-1##1 8.138
R10440 B7#10pin@1040_polysilicon-1##1 B7#10pin@1040_polysilicon-1##2 8.138
R10441 B7#10pin@1040_polysilicon-1##2 B7#0contact@1209_metal-1-metal-2 8.138
R10442 B7#11nmos@184_poly-right B7#11nmos@184_poly-right##0 5.425
R10443 B7#11nmos@184_poly-right##0 B7#12pin@990_polysilicon-1 5.425
R10444 NAND2_to_Nand10 NAND2_to_Nand10##0 6.717
R10445 NAND2_to_Nand10##0 NAND2_to_Nand10##1 6.717
R10446 NAND2_to_Nand10##1 NAND2_to_Nand10#9pin@1042_polysilicon-1 6.717
R10447 NAND2_to_Nand10#10pmos@198_poly-right NAND2_to_Nand10#10pmos@198_poly-right##0 9.558
R10448 NAND2_to_Nand10#10pmos@198_poly-right##0 NAND2_to_Nand10#10pmos@198_poly-right##1 9.558
R10449 NAND2_to_Nand10#10pmos@198_poly-right##1 NAND2_to_Nand10#10pmos@198_poly-right##2 9.558
R10450 NAND2_to_Nand10#10pmos@198_poly-right##2 NAND2_to_Nand10#10pmos@198_poly-right##3 9.558
R10451 NAND2_to_Nand10#10pmos@198_poly-right##3 NAND2_to_Nand10#10pmos@198_poly-right##4 9.558
R10452 NAND2_to_Nand10#10pmos@198_poly-right##4 NAND2_to_Nand10#9pin@1042_polysilicon-1 9.558
R10453 B7#1pin@1041_metal-2 B7#1pin@1041_metal-2##0 8.99
R10454 B7#1pin@1041_metal-2##0 B7#1pin@1041_metal-2##1 8.99
R10455 B7#1pin@1041_metal-2##1 B7#1pin@1041_metal-2##2 8.99
R10456 B7#1pin@1041_metal-2##2 B7#1pin@1041_metal-2##3 8.99
R10457 B7#1pin@1041_metal-2##3 B7#12pin@990_polysilicon-1 8.99
R10458 Cin_to_XOR2___NAND6#24nmos@149_poly-right Cin_to_XOR2___NAND6#24nmos@149_poly-right##0 6.2
R10459 Cin_to_XOR2___NAND6#24nmos@149_poly-right##0 Cin_to_XOR2___NAND6#26pin@844_polysilicon-1 6.2
R10460 NAND1_to_NAND10#11pmos@199_poly-right NAND1_to_NAND10#11pmos@199_poly-right##0 5.425
R10461 NAND1_to_NAND10#11pmos@199_poly-right##0 NAND1_to_NAND10#12pin@1046_polysilicon-1 5.425
R10462 NAND1_to_NAND10#12pin@1046_polysilicon-1 NAND1_to_NAND10#12pin@1046_polysilicon-1##0 9.3
R10463 NAND1_to_NAND10#12pin@1046_polysilicon-1##0 NAND1_to_NAND10#12pin@1046_polysilicon-1##1 9.3
R10464 NAND1_to_NAND10#12pin@1046_polysilicon-1##1 NAND1_to_NAND10 9.3
R10465 Cin_to_XOR2___NAND8#25nmos@195_poly-right Cin_to_XOR2___NAND8#25nmos@195_poly-right##0 8.636
R10466 Cin_to_XOR2___NAND8#25nmos@195_poly-right##0 Cin_to_XOR2___NAND8#25nmos@195_poly-right##1 8.636
R10467 Cin_to_XOR2___NAND8#25nmos@195_poly-right##1 Cin_to_XOR2___NAND8#25nmos@195_poly-right##2 8.636
R10468 Cin_to_XOR2___NAND8#25nmos@195_poly-right##2 Cin_to_XOR2___NAND8#25nmos@195_poly-right##3 8.636
R10469 Cin_to_XOR2___NAND8#25nmos@195_poly-right##3 Cin_to_XOR2___NAND8#25nmos@195_poly-right##4 8.636
R10470 Cin_to_XOR2___NAND8#25nmos@195_poly-right##4 Cin_to_XOR2___NAND8#25nmos@195_poly-right##5 8.636
R10471 Cin_to_XOR2___NAND8#25nmos@195_poly-right##5 Cin_to_XOR2___NAND8#23pin@1033_polysilicon-1 8.636
R10472 B7#13nmos@197_poly-right B7#13nmos@197_poly-right##0 8.956
R10473 B7#13nmos@197_poly-right##0 B7#13nmos@197_poly-right##1 8.956
R10474 B7#13nmos@197_poly-right##1 B7#13nmos@197_poly-right##2 8.956
R10475 B7#13nmos@197_poly-right##2 B7#13nmos@197_poly-right##3 8.956
R10476 B7#13nmos@197_poly-right##3 B7#13nmos@197_poly-right##4 8.956
R10477 B7#13nmos@197_poly-right##4 B7#13nmos@197_poly-right##5 8.956
R10478 B7#13nmos@197_poly-right##5 B7#13nmos@197_poly-right##6 8.956
R10479 B7#13nmos@197_poly-right##6 B7#13nmos@197_poly-right##7 8.956
R10480 B7#13nmos@197_poly-right##7 B7#10pin@1040_polysilicon-1 8.956
R10481 A7#12pmos@180_poly-left A7#12pmos@180_poly-left##0 8.138
R10482 A7#12pmos@180_poly-left##0 A7#12pmos@180_poly-left##1 8.138
R10483 A7#12pmos@180_poly-left##1 A7#12pmos@180_poly-left##2 8.138
R10484 A7#12pmos@180_poly-left##2 A7#13pin@987_polysilicon-1 8.138
R10485 B7#14pin@980_polysilicon-1 B7#14pin@980_polysilicon-1##0 9.843
R10486 B7#14pin@980_polysilicon-1##0 B7#14pin@980_polysilicon-1##1 9.843
R10487 B7#14pin@980_polysilicon-1##1 B7#14pin@980_polysilicon-1##2 9.843
R10488 B7#14pin@980_polysilicon-1##2 B7#14pin@980_polysilicon-1##3 9.843
R10489 B7#14pin@980_polysilicon-1##3 B7#14pin@980_polysilicon-1##4 9.843
R10490 B7#14pin@980_polysilicon-1##4 B7#14pin@980_polysilicon-1##5 9.843
R10491 B7#14pin@980_polysilicon-1##5 B7#14pin@980_polysilicon-1##6 9.843
R10492 B7#14pin@980_polysilicon-1##6 B7#14pin@980_polysilicon-1##7 9.843
R10493 B7#14pin@980_polysilicon-1##7 B7#14pin@980_polysilicon-1##8 9.843
R10494 B7#14pin@980_polysilicon-1##8 B7#14pin@980_polysilicon-1##9 9.843
R10495 B7#14pin@980_polysilicon-1##9 B7#14pin@980_polysilicon-1##10 9.843
R10496 B7#14pin@980_polysilicon-1##10 B7#14pin@980_polysilicon-1##11 9.843
R10497 B7#14pin@980_polysilicon-1##11 B7#14pin@980_polysilicon-1##12 9.843
R10498 B7#14pin@980_polysilicon-1##12 B7#14pin@980_polysilicon-1##13 9.843
R10499 B7#14pin@980_polysilicon-1##13 B7#14pin@980_polysilicon-1##14 9.843
R10500 B7#14pin@980_polysilicon-1##14 B7#14pin@980_polysilicon-1##15 9.843
R10501 B7#14pin@980_polysilicon-1##15 B7#14pin@980_polysilicon-1##16 9.843
R10502 B7#14pin@980_polysilicon-1##16 B7#14pin@980_polysilicon-1##17 9.843
R10503 B7#14pin@980_polysilicon-1##17 B7#14pin@980_polysilicon-1##18 9.843
R10504 B7#14pin@980_polysilicon-1##18 B7#15pin@997_polysilicon-1 9.843
R10505 net@3343#4nmos@186_poly-right net@3343#4nmos@186_poly-right##0 7.233
R10506 net@3343#4nmos@186_poly-right##0 net@3343#4nmos@186_poly-right##1 7.233
R10507 net@3343#4nmos@186_poly-right##1 net@3343#5pin@992_polysilicon-1 7.233
R10508 net@3343#2contact@1147_metal-1-polysilicon-1 net@3343#2contact@1147_metal-1-polysilicon-1##0 8.99
R10509 net@3343#2contact@1147_metal-1-polysilicon-1##0 net@3343#2contact@1147_metal-1-polysilicon-1##1 8.99
R10510 net@3343#2contact@1147_metal-1-polysilicon-1##1 net@3343#2contact@1147_metal-1-polysilicon-1##2 8.99
R10511 net@3343#2contact@1147_metal-1-polysilicon-1##2 net@3343#2contact@1147_metal-1-polysilicon-1##3 8.99
R10512 net@3343#2contact@1147_metal-1-polysilicon-1##3 net@3343#5pin@992_polysilicon-1 8.99
R10513 net@2778#6nmos@150_poly-right net@2778#6nmos@150_poly-right##0 8.37
R10514 net@2778#6nmos@150_poly-right##0 net@2778#6nmos@150_poly-right##1 8.37
R10515 net@2778#6nmos@150_poly-right##1 net@2778#6nmos@150_poly-right##2 8.37
R10516 net@2778#6nmos@150_poly-right##2 net@2778#6nmos@150_poly-right##3 8.37
R10517 net@2778#6nmos@150_poly-right##3 net@2778#2contact@945_metal-1-metal-2 8.37
R10518 A7#1pin@1039_metal-2 A7#1pin@1039_metal-2##0 6.717
R10519 A7#1pin@1039_metal-2##0 A7#1pin@1039_metal-2##1 6.717
R10520 A7#1pin@1039_metal-2##1 A7#15pin@988_polysilicon-1 6.717
R10521 A7#13pin@987_polysilicon-1 A7#13pin@987_polysilicon-1##0 7.75
R10522 A7#13pin@987_polysilicon-1##0 A7#13pin@987_polysilicon-1##1 7.75
R10523 A7#13pin@987_polysilicon-1##1 A7#15pin@988_polysilicon-1 7.75
R10524 B7#15pin@997_polysilicon-1 B7#15pin@997_polysilicon-1##0 9.743
R10525 B7#15pin@997_polysilicon-1##0 B7#15pin@997_polysilicon-1##1 9.743
R10526 B7#15pin@997_polysilicon-1##1 B7#15pin@997_polysilicon-1##2 9.743
R10527 B7#15pin@997_polysilicon-1##2 B7#15pin@997_polysilicon-1##3 9.743
R10528 B7#15pin@997_polysilicon-1##3 B7#15pin@997_polysilicon-1##4 9.743
R10529 B7#15pin@997_polysilicon-1##4 B7#15pin@997_polysilicon-1##5 9.743
R10530 B7#15pin@997_polysilicon-1##5 B7#1pin@1041_metal-2 9.743
R10531 net@3235#7pmos@181_poly-left net@3235#7pmos@181_poly-left##0 7.75
R10532 net@3235#7pmos@181_poly-left##0 net@3235 7.75
R10533 B7#16nmos@182_poly-left B7#16nmos@182_poly-left##0 6.2
R10534 B7#16nmos@182_poly-left##0 B7#14pin@980_polysilicon-1 6.2
R10535 net@3351#9nmos@183_poly-left net@3351#9nmos@183_poly-left##0 8.37
R10536 net@3351#9nmos@183_poly-left##0 net@3351#9nmos@183_poly-left##1 8.37
R10537 net@3351#9nmos@183_poly-left##1 net@3351#9nmos@183_poly-left##2 8.37
R10538 net@3351#9nmos@183_poly-left##2 net@3351#9nmos@183_poly-left##3 8.37
R10539 net@3351#9nmos@183_poly-left##3 net@3351#2contact@1123_metal-1-metal-2 8.37
R10540 A7#3pin@1000_polysilicon-1 A7#3pin@1000_polysilicon-1##0 9.881
R10541 A7#3pin@1000_polysilicon-1##0 A7#3pin@1000_polysilicon-1##1 9.881
R10542 A7#3pin@1000_polysilicon-1##1 A7#3pin@1000_polysilicon-1##2 9.881
R10543 A7#3pin@1000_polysilicon-1##2 A7#3pin@1000_polysilicon-1##3 9.881
R10544 A7#3pin@1000_polysilicon-1##3 A7#3pin@1000_polysilicon-1##4 9.881
R10545 A7#3pin@1000_polysilicon-1##4 A7#3pin@1000_polysilicon-1##5 9.881
R10546 A7#3pin@1000_polysilicon-1##5 A7#3pin@1000_polysilicon-1##6 9.881
R10547 A7#3pin@1000_polysilicon-1##6 A7#3pin@1000_polysilicon-1##7 9.881
R10548 A7#3pin@1000_polysilicon-1##7 A7#3pin@1000_polysilicon-1##8 9.881
R10549 A7#3pin@1000_polysilicon-1##8 A7#3pin@1000_polysilicon-1##9 9.881
R10550 A7#3pin@1000_polysilicon-1##9 A7#3pin@1000_polysilicon-1##10 9.881
R10551 A7#3pin@1000_polysilicon-1##10 A7#3pin@1000_polysilicon-1##11 9.881
R10552 A7#3pin@1000_polysilicon-1##11 A7#3pin@1000_polysilicon-1##12 9.881
R10553 A7#3pin@1000_polysilicon-1##12 A7#3pin@1000_polysilicon-1##13 9.881
R10554 A7#3pin@1000_polysilicon-1##13 A7#3pin@1000_polysilicon-1##14 9.881
R10555 A7#3pin@1000_polysilicon-1##14 A7#3pin@1000_polysilicon-1##15 9.881
R10556 A7#3pin@1000_polysilicon-1##15 A7#3pin@1000_polysilicon-1##16 9.881
R10557 A7#3pin@1000_polysilicon-1##16 A7#3pin@1000_polysilicon-1##17 9.881
R10558 A7#3pin@1000_polysilicon-1##17 A7#3pin@1000_polysilicon-1##18 9.881
R10559 A7#3pin@1000_polysilicon-1##18 A7#3pin@1000_polysilicon-1##19 9.881
R10560 A7#3pin@1000_polysilicon-1##19 A7#3pin@1000_polysilicon-1##20 9.881
R10561 A7#3pin@1000_polysilicon-1##20 A7#3pin@1000_polysilicon-1##21 9.881
R10562 A7#3pin@1000_polysilicon-1##21 A7#3pin@1000_polysilicon-1##22 9.881
R10563 A7#3pin@1000_polysilicon-1##22 A7#3pin@1000_polysilicon-1##23 9.881
R10564 A7#3pin@1000_polysilicon-1##23 A7#3pin@1000_polysilicon-1##24 9.881
R10565 A7#3pin@1000_polysilicon-1##24 A7#3pin@1000_polysilicon-1##25 9.881
R10566 A7#3pin@1000_polysilicon-1##25 A7#3pin@1000_polysilicon-1##26 9.881
R10567 A7#3pin@1000_polysilicon-1##26 A7#3pin@1000_polysilicon-1##27 9.881
R10568 A7#3pin@1000_polysilicon-1##27 A7#3pin@1000_polysilicon-1##28 9.881
R10569 A7#3pin@1000_polysilicon-1##28 A7#3pin@1000_polysilicon-1##29 9.881
R10570 A7#3pin@1000_polysilicon-1##29 A7#3pin@1000_polysilicon-1##30 9.881
R10571 A7#3pin@1000_polysilicon-1##30 A7#3pin@1000_polysilicon-1##31 9.881
R10572 A7#3pin@1000_polysilicon-1##31 A7#3pin@1000_polysilicon-1##32 9.881
R10573 A7#3pin@1000_polysilicon-1##32 A7#3pin@1000_polysilicon-1##33 9.881
R10574 A7#3pin@1000_polysilicon-1##33 A7#3pin@1000_polysilicon-1##34 9.881
R10575 A7#3pin@1000_polysilicon-1##34 A7#3pin@1000_polysilicon-1##35 9.881
R10576 A7#3pin@1000_polysilicon-1##35 A7#3pin@1000_polysilicon-1##36 9.881
R10577 A7#3pin@1000_polysilicon-1##36 A7#3pin@1000_polysilicon-1##37 9.881
R10578 A7#3pin@1000_polysilicon-1##37 A7#3pin@1000_polysilicon-1##38 9.881
R10579 A7#3pin@1000_polysilicon-1##38 A7#3pin@1000_polysilicon-1##39 9.881
R10580 A7#3pin@1000_polysilicon-1##39 A7#3pin@1000_polysilicon-1##40 9.881
R10581 A7#3pin@1000_polysilicon-1##40 A7#3pin@1000_polysilicon-1##41 9.881
R10582 A7#3pin@1000_polysilicon-1##41 A7#3pin@1000_polysilicon-1##42 9.881
R10583 A7#3pin@1000_polysilicon-1##42 A7#3pin@1000_polysilicon-1##43 9.881
R10584 A7#3pin@1000_polysilicon-1##43 A7#3pin@1000_polysilicon-1##44 9.881
R10585 A7#3pin@1000_polysilicon-1##44 A7#3pin@1000_polysilicon-1##45 9.881
R10586 A7#3pin@1000_polysilicon-1##45 A7#3pin@1000_polysilicon-1##46 9.881
R10587 A7#3pin@1000_polysilicon-1##46 A7#3pin@1000_polysilicon-1##47 9.881
R10588 A7#3pin@1000_polysilicon-1##47 A7#3pin@1000_polysilicon-1##48 9.881
R10589 A7#3pin@1000_polysilicon-1##48 A7#3pin@1000_polysilicon-1##49 9.881
R10590 A7#3pin@1000_polysilicon-1##49 A7#3pin@1000_polysilicon-1##50 9.881
R10591 A7#3pin@1000_polysilicon-1##50 A7#3pin@1000_polysilicon-1##51 9.881
R10592 A7#3pin@1000_polysilicon-1##51 A7#3pin@1000_polysilicon-1##52 9.881
R10593 A7#3pin@1000_polysilicon-1##52 A7#3pin@1000_polysilicon-1##53 9.881
R10594 A7#3pin@1000_polysilicon-1##53 A7#3pin@1000_polysilicon-1##54 9.881
R10595 A7#3pin@1000_polysilicon-1##54 A7#16nmos@185_poly-right 9.881
R10596 net@3235#5pmos@185_diff-top net@3235#2pin@989_metal-1 4.81
R10597 net@3235#1pin@999_polysilicon-1 net@3235#1pin@999_polysilicon-1##0 9.85
R10598 net@3235#1pin@999_polysilicon-1##0 net@3235#1pin@999_polysilicon-1##1 9.85
R10599 net@3235#1pin@999_polysilicon-1##1 net@3235#1pin@999_polysilicon-1##2 9.85
R10600 net@3235#1pin@999_polysilicon-1##2 net@3235#1pin@999_polysilicon-1##3 9.85
R10601 net@3235#1pin@999_polysilicon-1##3 net@3235#1pin@999_polysilicon-1##4 9.85
R10602 net@3235#1pin@999_polysilicon-1##4 net@3235#1pin@999_polysilicon-1##5 9.85
R10603 net@3235#1pin@999_polysilicon-1##5 net@3235#1pin@999_polysilicon-1##6 9.85
R10604 net@3235#1pin@999_polysilicon-1##6 net@3235#1pin@999_polysilicon-1##7 9.85
R10605 net@3235#1pin@999_polysilicon-1##7 net@3235#1pin@999_polysilicon-1##8 9.85
R10606 net@3235#1pin@999_polysilicon-1##8 net@3235#1pin@999_polysilicon-1##9 9.85
R10607 net@3235#1pin@999_polysilicon-1##9 net@3235#1pin@999_polysilicon-1##10 9.85
R10608 net@3235#1pin@999_polysilicon-1##10 net@3235#1pin@999_polysilicon-1##11 9.85
R10609 net@3235#1pin@999_polysilicon-1##11 net@3235#1pin@999_polysilicon-1##12 9.85
R10610 net@3235#1pin@999_polysilicon-1##12 net@3235#1pin@999_polysilicon-1##13 9.85
R10611 net@3235#1pin@999_polysilicon-1##13 net@3235#1pin@999_polysilicon-1##14 9.85
R10612 net@3235#1pin@999_polysilicon-1##14 net@3235#1pin@999_polysilicon-1##15 9.85
R10613 net@3235#1pin@999_polysilicon-1##15 net@3235#1pin@999_polysilicon-1##16 9.85
R10614 net@3235#1pin@999_polysilicon-1##16 net@3235#1pin@999_polysilicon-1##17 9.85
R10615 net@3235#1pin@999_polysilicon-1##17 net@3235#1pin@999_polysilicon-1##18 9.85
R10616 net@3235#1pin@999_polysilicon-1##18 net@3235#1pin@999_polysilicon-1##19 9.85
R10617 net@3235#1pin@999_polysilicon-1##19 net@3235#1pin@999_polysilicon-1##20 9.85
R10618 net@3235#1pin@999_polysilicon-1##20 net@3235#1pin@999_polysilicon-1##21 9.85
R10619 net@3235#1pin@999_polysilicon-1##21 net@3235#1pin@999_polysilicon-1##22 9.85
R10620 net@3235#1pin@999_polysilicon-1##22 net@3235#1pin@999_polysilicon-1##23 9.85
R10621 net@3235#1pin@999_polysilicon-1##23 net@3235#1pin@999_polysilicon-1##24 9.85
R10622 net@3235#1pin@999_polysilicon-1##24 net@3235#1pin@999_polysilicon-1##25 9.85
R10623 net@3235#1pin@999_polysilicon-1##25 net@3235#1pin@999_polysilicon-1##26 9.85
R10624 net@3235#1pin@999_polysilicon-1##26 net@3235#1pin@999_polysilicon-1##27 9.85
R10625 net@3235#1pin@999_polysilicon-1##27 net@3235#1pin@999_polysilicon-1##28 9.85
R10626 net@3235#1pin@999_polysilicon-1##28 net@3235#1pin@999_polysilicon-1##29 9.85
R10627 net@3235#1pin@999_polysilicon-1##29 net@3235#1pin@999_polysilicon-1##30 9.85
R10628 net@3235#1pin@999_polysilicon-1##30 net@3235#1pin@999_polysilicon-1##31 9.85
R10629 net@3235#1pin@999_polysilicon-1##31 net@3235#1pin@999_polysilicon-1##32 9.85
R10630 net@3235#1pin@999_polysilicon-1##32 net@3235#1pin@999_polysilicon-1##33 9.85
R10631 net@3235#1pin@999_polysilicon-1##33 net@3235#1pin@999_polysilicon-1##34 9.85
R10632 net@3235#1pin@999_polysilicon-1##34 net@3235#1pin@999_polysilicon-1##35 9.85
R10633 net@3235#1pin@999_polysilicon-1##35 net@3235#1pin@999_polysilicon-1##36 9.85
R10634 net@3235#1pin@999_polysilicon-1##36 net@3235#1pin@999_polysilicon-1##37 9.85
R10635 net@3235#1pin@999_polysilicon-1##37 net@3235#1pin@999_polysilicon-1##38 9.85
R10636 net@3235#1pin@999_polysilicon-1##38 net@3235#1pin@999_polysilicon-1##39 9.85
R10637 net@3235#1pin@999_polysilicon-1##39 net@3235#1pin@999_polysilicon-1##40 9.85
R10638 net@3235#1pin@999_polysilicon-1##40 net@3235#1pin@999_polysilicon-1##41 9.85
R10639 net@3235#1pin@999_polysilicon-1##41 net@3235#1pin@999_polysilicon-1##42 9.85
R10640 net@3235#1pin@999_polysilicon-1##42 net@3235#1pin@999_polysilicon-1##43 9.85
R10641 net@3235#1pin@999_polysilicon-1##43 net@3235#1pin@999_polysilicon-1##44 9.85
R10642 net@3235#1pin@999_polysilicon-1##44 net@3235#1pin@999_polysilicon-1##45 9.85
R10643 net@3235#1pin@999_polysilicon-1##45 net@3235#1pin@999_polysilicon-1##46 9.85
R10644 net@3235#1pin@999_polysilicon-1##46 net@3235#1pin@999_polysilicon-1##47 9.85
R10645 net@3235#1pin@999_polysilicon-1##47 net@3235#1pin@999_polysilicon-1##48 9.85
R10646 net@3235#1pin@999_polysilicon-1##48 net@3235#1pin@999_polysilicon-1##49 9.85
R10647 net@3235#1pin@999_polysilicon-1##49 net@3235#1pin@999_polysilicon-1##50 9.85
R10648 net@3235#1pin@999_polysilicon-1##50 net@3235#1pin@999_polysilicon-1##51 9.85
R10649 net@3235#1pin@999_polysilicon-1##51 net@3235#1pin@999_polysilicon-1##52 9.85
R10650 net@3235#1pin@999_polysilicon-1##52 net@3235#1pin@999_polysilicon-1##53 9.85
R10651 net@3235#1pin@999_polysilicon-1##53 net@3235#1pin@999_polysilicon-1##54 9.85
R10652 net@3235#1pin@999_polysilicon-1##54 net@3235#1pin@999_polysilicon-1##55 9.85
R10653 net@3235#1pin@999_polysilicon-1##55 net@3235#1pin@999_polysilicon-1##56 9.85
R10654 net@3235#1pin@999_polysilicon-1##56 net@3235#1pin@999_polysilicon-1##57 9.85
R10655 net@3235#1pin@999_polysilicon-1##57 net@3235#1pin@999_polysilicon-1##58 9.85
R10656 net@3235#1pin@999_polysilicon-1##58 net@3235#1pin@999_polysilicon-1##59 9.85
R10657 net@3235#1pin@999_polysilicon-1##59 net@3235#1pin@999_polysilicon-1##60 9.85
R10658 net@3235#1pin@999_polysilicon-1##60 net@3235#2pin@989_metal-1 9.85
R10659 B7#17pmos@184_poly-right B7#17pmos@184_poly-right##0 9.854
R10660 B7#17pmos@184_poly-right##0 B7#17pmos@184_poly-right##1 9.854
R10661 B7#17pmos@184_poly-right##1 B7#17pmos@184_poly-right##2 9.854
R10662 B7#17pmos@184_poly-right##2 B7#17pmos@184_poly-right##3 9.854
R10663 B7#17pmos@184_poly-right##3 B7#17pmos@184_poly-right##4 9.854
R10664 B7#17pmos@184_poly-right##4 B7#17pmos@184_poly-right##5 9.854
R10665 B7#17pmos@184_poly-right##5 B7#17pmos@184_poly-right##6 9.854
R10666 B7#17pmos@184_poly-right##6 B7#17pmos@184_poly-right##7 9.854
R10667 B7#17pmos@184_poly-right##7 B7#17pmos@184_poly-right##8 9.854
R10668 B7#17pmos@184_poly-right##8 B7#17pmos@184_poly-right##9 9.854
R10669 B7#17pmos@184_poly-right##9 B7#17pmos@184_poly-right##10 9.854
R10670 B7#17pmos@184_poly-right##10 B7#17pmos@184_poly-right##11 9.854
R10671 B7#17pmos@184_poly-right##11 B7#17pmos@184_poly-right##12 9.854
R10672 B7#17pmos@184_poly-right##12 B7#17pmos@184_poly-right##13 9.854
R10673 B7#17pmos@184_poly-right##13 B7#17pmos@184_poly-right##14 9.854
R10674 B7#17pmos@184_poly-right##14 B7#17pmos@184_poly-right##15 9.854
R10675 B7#17pmos@184_poly-right##15 B7#17pmos@184_poly-right##16 9.854
R10676 B7#17pmos@184_poly-right##16 B7#17pmos@184_poly-right##17 9.854
R10677 B7#17pmos@184_poly-right##17 B7#17pmos@184_poly-right##18 9.854
R10678 B7#17pmos@184_poly-right##18 B7#17pmos@184_poly-right##19 9.854
R10679 B7#17pmos@184_poly-right##19 B7#17pmos@184_poly-right##20 9.854
R10680 B7#17pmos@184_poly-right##20 B7#17pmos@184_poly-right##21 9.854
R10681 B7#17pmos@184_poly-right##21 B7#17pmos@184_poly-right##22 9.854
R10682 B7#17pmos@184_poly-right##22 B7#17pmos@184_poly-right##23 9.854
R10683 B7#17pmos@184_poly-right##23 B7#17pmos@184_poly-right##24 9.854
R10684 B7#17pmos@184_poly-right##24 B7#17pmos@184_poly-right##25 9.854
R10685 B7#17pmos@184_poly-right##25 B7#17pmos@184_poly-right##26 9.854
R10686 B7#17pmos@184_poly-right##26 B7#17pmos@184_poly-right##27 9.854
R10687 B7#17pmos@184_poly-right##27 B7#17pmos@184_poly-right##28 9.854
R10688 B7#17pmos@184_poly-right##28 B7#17pmos@184_poly-right##29 9.854
R10689 B7#17pmos@184_poly-right##29 B7#17pmos@184_poly-right##30 9.854
R10690 B7#17pmos@184_poly-right##30 B7#17pmos@184_poly-right##31 9.854
R10691 B7#17pmos@184_poly-right##31 B7#17pmos@184_poly-right##32 9.854
R10692 B7#17pmos@184_poly-right##32 B7#17pmos@184_poly-right##33 9.854
R10693 B7#17pmos@184_poly-right##33 B7#17pmos@184_poly-right##34 9.854
R10694 B7#17pmos@184_poly-right##34 B7#17pmos@184_poly-right##35 9.854
R10695 B7#17pmos@184_poly-right##35 B7#17pmos@184_poly-right##36 9.854
R10696 B7#17pmos@184_poly-right##36 B7#17pmos@184_poly-right##37 9.854
R10697 B7#17pmos@184_poly-right##37 B7#17pmos@184_poly-right##38 9.854
R10698 B7#17pmos@184_poly-right##38 B7#17pmos@184_poly-right##39 9.854
R10699 B7#17pmos@184_poly-right##39 B7#17pmos@184_poly-right##40 9.854
R10700 B7#17pmos@184_poly-right##40 B7#17pmos@184_poly-right##41 9.854
R10701 B7#17pmos@184_poly-right##41 B7#17pmos@184_poly-right##42 9.854
R10702 B7#17pmos@184_poly-right##42 B7#17pmos@184_poly-right##43 9.854
R10703 B7#17pmos@184_poly-right##43 B7#17pmos@184_poly-right##44 9.854
R10704 B7#17pmos@184_poly-right##44 B7#17pmos@184_poly-right##45 9.854
R10705 B7#17pmos@184_poly-right##45 B7#17pmos@184_poly-right##46 9.854
R10706 B7#17pmos@184_poly-right##46 B7#17pmos@184_poly-right##47 9.854
R10707 B7#17pmos@184_poly-right##47 B7#17pmos@184_poly-right##48 9.854
R10708 B7#17pmos@184_poly-right##48 B7#17pmos@184_poly-right##49 9.854
R10709 B7#17pmos@184_poly-right##49 B7#17pmos@184_poly-right##50 9.854
R10710 B7#17pmos@184_poly-right##50 B7#17pmos@184_poly-right##51 9.854
R10711 B7#17pmos@184_poly-right##51 B7#17pmos@184_poly-right##52 9.854
R10712 B7#17pmos@184_poly-right##52 B7#17pmos@184_poly-right##53 9.854
R10713 B7#17pmos@184_poly-right##53 B7#17pmos@184_poly-right##54 9.854
R10714 B7#17pmos@184_poly-right##54 B7#12pin@990_polysilicon-1 9.854
R10715 net@3351 net@3351#2contact@1123_metal-1-metal-2 4.797
R10716 A7#17nmos@180_poly-right A7#17nmos@180_poly-right##0 9.871
R10717 A7#17nmos@180_poly-right##0 A7#17nmos@180_poly-right##1 9.871
R10718 A7#17nmos@180_poly-right##1 A7#17nmos@180_poly-right##2 9.871
R10719 A7#17nmos@180_poly-right##2 A7#17nmos@180_poly-right##3 9.871
R10720 A7#17nmos@180_poly-right##3 A7#17nmos@180_poly-right##4 9.871
R10721 A7#17nmos@180_poly-right##4 A7#17nmos@180_poly-right##5 9.871
R10722 A7#17nmos@180_poly-right##5 A7#17nmos@180_poly-right##6 9.871
R10723 A7#17nmos@180_poly-right##6 A7#17nmos@180_poly-right##7 9.871
R10724 A7#17nmos@180_poly-right##7 A7#17nmos@180_poly-right##8 9.871
R10725 A7#17nmos@180_poly-right##8 A7#17nmos@180_poly-right##9 9.871
R10726 A7#17nmos@180_poly-right##9 A7#17nmos@180_poly-right##10 9.871
R10727 A7#17nmos@180_poly-right##10 A7#17nmos@180_poly-right##11 9.871
R10728 A7#17nmos@180_poly-right##11 A7#17nmos@180_poly-right##12 9.871
R10729 A7#17nmos@180_poly-right##12 A7#17nmos@180_poly-right##13 9.871
R10730 A7#17nmos@180_poly-right##13 A7#17nmos@180_poly-right##14 9.871
R10731 A7#17nmos@180_poly-right##14 A7#17nmos@180_poly-right##15 9.871
R10732 A7#17nmos@180_poly-right##15 A7#17nmos@180_poly-right##16 9.871
R10733 A7#17nmos@180_poly-right##16 A7#17nmos@180_poly-right##17 9.871
R10734 A7#17nmos@180_poly-right##17 A7#17nmos@180_poly-right##18 9.871
R10735 A7#17nmos@180_poly-right##18 A7#17nmos@180_poly-right##19 9.871
R10736 A7#17nmos@180_poly-right##19 A7#17nmos@180_poly-right##20 9.871
R10737 A7#17nmos@180_poly-right##20 A7#17nmos@180_poly-right##21 9.871
R10738 A7#17nmos@180_poly-right##21 A7#17nmos@180_poly-right##22 9.871
R10739 A7#17nmos@180_poly-right##22 A7#17nmos@180_poly-right##23 9.871
R10740 A7#17nmos@180_poly-right##23 A7#17nmos@180_poly-right##24 9.871
R10741 A7#17nmos@180_poly-right##24 A7#17nmos@180_poly-right##25 9.871
R10742 A7#17nmos@180_poly-right##25 A7#17nmos@180_poly-right##26 9.871
R10743 A7#17nmos@180_poly-right##26 A7#17nmos@180_poly-right##27 9.871
R10744 A7#17nmos@180_poly-right##27 A7#17nmos@180_poly-right##28 9.871
R10745 A7#17nmos@180_poly-right##28 A7#17nmos@180_poly-right##29 9.871
R10746 A7#17nmos@180_poly-right##29 A7#17nmos@180_poly-right##30 9.871
R10747 A7#17nmos@180_poly-right##30 A7#17nmos@180_poly-right##31 9.871
R10748 A7#17nmos@180_poly-right##31 A7#17nmos@180_poly-right##32 9.871
R10749 A7#17nmos@180_poly-right##32 A7#17nmos@180_poly-right##33 9.871
R10750 A7#17nmos@180_poly-right##33 A7#17nmos@180_poly-right##34 9.871
R10751 A7#17nmos@180_poly-right##34 A7#17nmos@180_poly-right##35 9.871
R10752 A7#17nmos@180_poly-right##35 A7#17nmos@180_poly-right##36 9.871
R10753 A7#17nmos@180_poly-right##36 A7#17nmos@180_poly-right##37 9.871
R10754 A7#17nmos@180_poly-right##37 A7#17nmos@180_poly-right##38 9.871
R10755 A7#17nmos@180_poly-right##38 A7#17nmos@180_poly-right##39 9.871
R10756 A7#17nmos@180_poly-right##39 A7#17nmos@180_poly-right##40 9.871
R10757 A7#17nmos@180_poly-right##40 A7#17nmos@180_poly-right##41 9.871
R10758 A7#17nmos@180_poly-right##41 A7#17nmos@180_poly-right##42 9.871
R10759 A7#17nmos@180_poly-right##42 A7#17nmos@180_poly-right##43 9.871
R10760 A7#17nmos@180_poly-right##43 A7#17nmos@180_poly-right##44 9.871
R10761 A7#17nmos@180_poly-right##44 A7#17nmos@180_poly-right##45 9.871
R10762 A7#17nmos@180_poly-right##45 A7#17nmos@180_poly-right##46 9.871
R10763 A7#17nmos@180_poly-right##46 A7#17nmos@180_poly-right##47 9.871
R10764 A7#17nmos@180_poly-right##47 A7#17nmos@180_poly-right##48 9.871
R10765 A7#17nmos@180_poly-right##48 A7#17nmos@180_poly-right##49 9.871
R10766 A7#17nmos@180_poly-right##49 A7#17nmos@180_poly-right##50 9.871
R10767 A7#17nmos@180_poly-right##50 A7#17nmos@180_poly-right##51 9.871
R10768 A7#17nmos@180_poly-right##51 A7#17nmos@180_poly-right##52 9.871
R10769 A7#17nmos@180_poly-right##52 A7#17nmos@180_poly-right##53 9.871
R10770 A7#17nmos@180_poly-right##53 A7#17nmos@180_poly-right##54 9.871
R10771 A7#17nmos@180_poly-right##54 A7#17nmos@180_poly-right##55 9.871
R10772 A7#17nmos@180_poly-right##55 A7#12pmos@180_poly-left 9.871
R10773 net@3235#7pmos@181_poly-left net@3235#7pmos@181_poly-left##0 9.871
R10774 net@3235#7pmos@181_poly-left##0 net@3235#7pmos@181_poly-left##1 9.871
R10775 net@3235#7pmos@181_poly-left##1 net@3235#7pmos@181_poly-left##2 9.871
R10776 net@3235#7pmos@181_poly-left##2 net@3235#7pmos@181_poly-left##3 9.871
R10777 net@3235#7pmos@181_poly-left##3 net@3235#7pmos@181_poly-left##4 9.871
R10778 net@3235#7pmos@181_poly-left##4 net@3235#7pmos@181_poly-left##5 9.871
R10779 net@3235#7pmos@181_poly-left##5 net@3235#7pmos@181_poly-left##6 9.871
R10780 net@3235#7pmos@181_poly-left##6 net@3235#7pmos@181_poly-left##7 9.871
R10781 net@3235#7pmos@181_poly-left##7 net@3235#7pmos@181_poly-left##8 9.871
R10782 net@3235#7pmos@181_poly-left##8 net@3235#7pmos@181_poly-left##9 9.871
R10783 net@3235#7pmos@181_poly-left##9 net@3235#7pmos@181_poly-left##10 9.871
R10784 net@3235#7pmos@181_poly-left##10 net@3235#7pmos@181_poly-left##11 9.871
R10785 net@3235#7pmos@181_poly-left##11 net@3235#7pmos@181_poly-left##12 9.871
R10786 net@3235#7pmos@181_poly-left##12 net@3235#7pmos@181_poly-left##13 9.871
R10787 net@3235#7pmos@181_poly-left##13 net@3235#7pmos@181_poly-left##14 9.871
R10788 net@3235#7pmos@181_poly-left##14 net@3235#7pmos@181_poly-left##15 9.871
R10789 net@3235#7pmos@181_poly-left##15 net@3235#7pmos@181_poly-left##16 9.871
R10790 net@3235#7pmos@181_poly-left##16 net@3235#7pmos@181_poly-left##17 9.871
R10791 net@3235#7pmos@181_poly-left##17 net@3235#7pmos@181_poly-left##18 9.871
R10792 net@3235#7pmos@181_poly-left##18 net@3235#7pmos@181_poly-left##19 9.871
R10793 net@3235#7pmos@181_poly-left##19 net@3235#7pmos@181_poly-left##20 9.871
R10794 net@3235#7pmos@181_poly-left##20 net@3235#7pmos@181_poly-left##21 9.871
R10795 net@3235#7pmos@181_poly-left##21 net@3235#7pmos@181_poly-left##22 9.871
R10796 net@3235#7pmos@181_poly-left##22 net@3235#7pmos@181_poly-left##23 9.871
R10797 net@3235#7pmos@181_poly-left##23 net@3235#7pmos@181_poly-left##24 9.871
R10798 net@3235#7pmos@181_poly-left##24 net@3235#7pmos@181_poly-left##25 9.871
R10799 net@3235#7pmos@181_poly-left##25 net@3235#7pmos@181_poly-left##26 9.871
R10800 net@3235#7pmos@181_poly-left##26 net@3235#7pmos@181_poly-left##27 9.871
R10801 net@3235#7pmos@181_poly-left##27 net@3235#7pmos@181_poly-left##28 9.871
R10802 net@3235#7pmos@181_poly-left##28 net@3235#7pmos@181_poly-left##29 9.871
R10803 net@3235#7pmos@181_poly-left##29 net@3235#7pmos@181_poly-left##30 9.871
R10804 net@3235#7pmos@181_poly-left##30 net@3235#7pmos@181_poly-left##31 9.871
R10805 net@3235#7pmos@181_poly-left##31 net@3235#7pmos@181_poly-left##32 9.871
R10806 net@3235#7pmos@181_poly-left##32 net@3235#7pmos@181_poly-left##33 9.871
R10807 net@3235#7pmos@181_poly-left##33 net@3235#7pmos@181_poly-left##34 9.871
R10808 net@3235#7pmos@181_poly-left##34 net@3235#7pmos@181_poly-left##35 9.871
R10809 net@3235#7pmos@181_poly-left##35 net@3235#7pmos@181_poly-left##36 9.871
R10810 net@3235#7pmos@181_poly-left##36 net@3235#7pmos@181_poly-left##37 9.871
R10811 net@3235#7pmos@181_poly-left##37 net@3235#7pmos@181_poly-left##38 9.871
R10812 net@3235#7pmos@181_poly-left##38 net@3235#7pmos@181_poly-left##39 9.871
R10813 net@3235#7pmos@181_poly-left##39 net@3235#7pmos@181_poly-left##40 9.871
R10814 net@3235#7pmos@181_poly-left##40 net@3235#7pmos@181_poly-left##41 9.871
R10815 net@3235#7pmos@181_poly-left##41 net@3235#7pmos@181_poly-left##42 9.871
R10816 net@3235#7pmos@181_poly-left##42 net@3235#7pmos@181_poly-left##43 9.871
R10817 net@3235#7pmos@181_poly-left##43 net@3235#7pmos@181_poly-left##44 9.871
R10818 net@3235#7pmos@181_poly-left##44 net@3235#7pmos@181_poly-left##45 9.871
R10819 net@3235#7pmos@181_poly-left##45 net@3235#7pmos@181_poly-left##46 9.871
R10820 net@3235#7pmos@181_poly-left##46 net@3235#7pmos@181_poly-left##47 9.871
R10821 net@3235#7pmos@181_poly-left##47 net@3235#7pmos@181_poly-left##48 9.871
R10822 net@3235#7pmos@181_poly-left##48 net@3235#7pmos@181_poly-left##49 9.871
R10823 net@3235#7pmos@181_poly-left##49 net@3235#7pmos@181_poly-left##50 9.871
R10824 net@3235#7pmos@181_poly-left##50 net@3235#7pmos@181_poly-left##51 9.871
R10825 net@3235#7pmos@181_poly-left##51 net@3235#7pmos@181_poly-left##52 9.871
R10826 net@3235#7pmos@181_poly-left##52 net@3235#7pmos@181_poly-left##53 9.871
R10827 net@3235#7pmos@181_poly-left##53 net@3235#7pmos@181_poly-left##54 9.871
R10828 net@3235#7pmos@181_poly-left##54 net@3235#7pmos@181_poly-left##55 9.871
R10829 net@3235#7pmos@181_poly-left##55 net@3235#11nmos@181_poly-right 9.871
R10830 B7#18pmos@182_poly-right B7#18pmos@182_poly-right##0 9.871
R10831 B7#18pmos@182_poly-right##0 B7#18pmos@182_poly-right##1 9.871
R10832 B7#18pmos@182_poly-right##1 B7#18pmos@182_poly-right##2 9.871
R10833 B7#18pmos@182_poly-right##2 B7#18pmos@182_poly-right##3 9.871
R10834 B7#18pmos@182_poly-right##3 B7#18pmos@182_poly-right##4 9.871
R10835 B7#18pmos@182_poly-right##4 B7#18pmos@182_poly-right##5 9.871
R10836 B7#18pmos@182_poly-right##5 B7#18pmos@182_poly-right##6 9.871
R10837 B7#18pmos@182_poly-right##6 B7#18pmos@182_poly-right##7 9.871
R10838 B7#18pmos@182_poly-right##7 B7#18pmos@182_poly-right##8 9.871
R10839 B7#18pmos@182_poly-right##8 B7#18pmos@182_poly-right##9 9.871
R10840 B7#18pmos@182_poly-right##9 B7#18pmos@182_poly-right##10 9.871
R10841 B7#18pmos@182_poly-right##10 B7#18pmos@182_poly-right##11 9.871
R10842 B7#18pmos@182_poly-right##11 B7#18pmos@182_poly-right##12 9.871
R10843 B7#18pmos@182_poly-right##12 B7#18pmos@182_poly-right##13 9.871
R10844 B7#18pmos@182_poly-right##13 B7#18pmos@182_poly-right##14 9.871
R10845 B7#18pmos@182_poly-right##14 B7#18pmos@182_poly-right##15 9.871
R10846 B7#18pmos@182_poly-right##15 B7#18pmos@182_poly-right##16 9.871
R10847 B7#18pmos@182_poly-right##16 B7#18pmos@182_poly-right##17 9.871
R10848 B7#18pmos@182_poly-right##17 B7#18pmos@182_poly-right##18 9.871
R10849 B7#18pmos@182_poly-right##18 B7#18pmos@182_poly-right##19 9.871
R10850 B7#18pmos@182_poly-right##19 B7#18pmos@182_poly-right##20 9.871
R10851 B7#18pmos@182_poly-right##20 B7#18pmos@182_poly-right##21 9.871
R10852 B7#18pmos@182_poly-right##21 B7#18pmos@182_poly-right##22 9.871
R10853 B7#18pmos@182_poly-right##22 B7#18pmos@182_poly-right##23 9.871
R10854 B7#18pmos@182_poly-right##23 B7#18pmos@182_poly-right##24 9.871
R10855 B7#18pmos@182_poly-right##24 B7#18pmos@182_poly-right##25 9.871
R10856 B7#18pmos@182_poly-right##25 B7#18pmos@182_poly-right##26 9.871
R10857 B7#18pmos@182_poly-right##26 B7#18pmos@182_poly-right##27 9.871
R10858 B7#18pmos@182_poly-right##27 B7#18pmos@182_poly-right##28 9.871
R10859 B7#18pmos@182_poly-right##28 B7#18pmos@182_poly-right##29 9.871
R10860 B7#18pmos@182_poly-right##29 B7#18pmos@182_poly-right##30 9.871
R10861 B7#18pmos@182_poly-right##30 B7#18pmos@182_poly-right##31 9.871
R10862 B7#18pmos@182_poly-right##31 B7#18pmos@182_poly-right##32 9.871
R10863 B7#18pmos@182_poly-right##32 B7#18pmos@182_poly-right##33 9.871
R10864 B7#18pmos@182_poly-right##33 B7#18pmos@182_poly-right##34 9.871
R10865 B7#18pmos@182_poly-right##34 B7#18pmos@182_poly-right##35 9.871
R10866 B7#18pmos@182_poly-right##35 B7#18pmos@182_poly-right##36 9.871
R10867 B7#18pmos@182_poly-right##36 B7#18pmos@182_poly-right##37 9.871
R10868 B7#18pmos@182_poly-right##37 B7#18pmos@182_poly-right##38 9.871
R10869 B7#18pmos@182_poly-right##38 B7#18pmos@182_poly-right##39 9.871
R10870 B7#18pmos@182_poly-right##39 B7#18pmos@182_poly-right##40 9.871
R10871 B7#18pmos@182_poly-right##40 B7#18pmos@182_poly-right##41 9.871
R10872 B7#18pmos@182_poly-right##41 B7#18pmos@182_poly-right##42 9.871
R10873 B7#18pmos@182_poly-right##42 B7#18pmos@182_poly-right##43 9.871
R10874 B7#18pmos@182_poly-right##43 B7#18pmos@182_poly-right##44 9.871
R10875 B7#18pmos@182_poly-right##44 B7#18pmos@182_poly-right##45 9.871
R10876 B7#18pmos@182_poly-right##45 B7#18pmos@182_poly-right##46 9.871
R10877 B7#18pmos@182_poly-right##46 B7#18pmos@182_poly-right##47 9.871
R10878 B7#18pmos@182_poly-right##47 B7#18pmos@182_poly-right##48 9.871
R10879 B7#18pmos@182_poly-right##48 B7#18pmos@182_poly-right##49 9.871
R10880 B7#18pmos@182_poly-right##49 B7#18pmos@182_poly-right##50 9.871
R10881 B7#18pmos@182_poly-right##50 B7#18pmos@182_poly-right##51 9.871
R10882 B7#18pmos@182_poly-right##51 B7#18pmos@182_poly-right##52 9.871
R10883 B7#18pmos@182_poly-right##52 B7#18pmos@182_poly-right##53 9.871
R10884 B7#18pmos@182_poly-right##53 B7#18pmos@182_poly-right##54 9.871
R10885 B7#18pmos@182_poly-right##54 B7#18pmos@182_poly-right##55 9.871
R10886 B7#18pmos@182_poly-right##55 B7#16nmos@182_poly-left 9.871
R10887 net@3351#14pmos@183_poly-right net@3351#14pmos@183_poly-right##0 9.871
R10888 net@3351#14pmos@183_poly-right##0 net@3351#14pmos@183_poly-right##1 9.871
R10889 net@3351#14pmos@183_poly-right##1 net@3351#14pmos@183_poly-right##2 9.871
R10890 net@3351#14pmos@183_poly-right##2 net@3351#14pmos@183_poly-right##3 9.871
R10891 net@3351#14pmos@183_poly-right##3 net@3351#14pmos@183_poly-right##4 9.871
R10892 net@3351#14pmos@183_poly-right##4 net@3351#14pmos@183_poly-right##5 9.871
R10893 net@3351#14pmos@183_poly-right##5 net@3351#14pmos@183_poly-right##6 9.871
R10894 net@3351#14pmos@183_poly-right##6 net@3351#14pmos@183_poly-right##7 9.871
R10895 net@3351#14pmos@183_poly-right##7 net@3351#14pmos@183_poly-right##8 9.871
R10896 net@3351#14pmos@183_poly-right##8 net@3351#14pmos@183_poly-right##9 9.871
R10897 net@3351#14pmos@183_poly-right##9 net@3351#14pmos@183_poly-right##10 9.871
R10898 net@3351#14pmos@183_poly-right##10 net@3351#14pmos@183_poly-right##11 9.871
R10899 net@3351#14pmos@183_poly-right##11 net@3351#14pmos@183_poly-right##12 9.871
R10900 net@3351#14pmos@183_poly-right##12 net@3351#14pmos@183_poly-right##13 9.871
R10901 net@3351#14pmos@183_poly-right##13 net@3351#14pmos@183_poly-right##14 9.871
R10902 net@3351#14pmos@183_poly-right##14 net@3351#14pmos@183_poly-right##15 9.871
R10903 net@3351#14pmos@183_poly-right##15 net@3351#14pmos@183_poly-right##16 9.871
R10904 net@3351#14pmos@183_poly-right##16 net@3351#14pmos@183_poly-right##17 9.871
R10905 net@3351#14pmos@183_poly-right##17 net@3351#14pmos@183_poly-right##18 9.871
R10906 net@3351#14pmos@183_poly-right##18 net@3351#14pmos@183_poly-right##19 9.871
R10907 net@3351#14pmos@183_poly-right##19 net@3351#14pmos@183_poly-right##20 9.871
R10908 net@3351#14pmos@183_poly-right##20 net@3351#14pmos@183_poly-right##21 9.871
R10909 net@3351#14pmos@183_poly-right##21 net@3351#14pmos@183_poly-right##22 9.871
R10910 net@3351#14pmos@183_poly-right##22 net@3351#14pmos@183_poly-right##23 9.871
R10911 net@3351#14pmos@183_poly-right##23 net@3351#14pmos@183_poly-right##24 9.871
R10912 net@3351#14pmos@183_poly-right##24 net@3351#14pmos@183_poly-right##25 9.871
R10913 net@3351#14pmos@183_poly-right##25 net@3351#14pmos@183_poly-right##26 9.871
R10914 net@3351#14pmos@183_poly-right##26 net@3351#14pmos@183_poly-right##27 9.871
R10915 net@3351#14pmos@183_poly-right##27 net@3351#14pmos@183_poly-right##28 9.871
R10916 net@3351#14pmos@183_poly-right##28 net@3351#14pmos@183_poly-right##29 9.871
R10917 net@3351#14pmos@183_poly-right##29 net@3351#14pmos@183_poly-right##30 9.871
R10918 net@3351#14pmos@183_poly-right##30 net@3351#14pmos@183_poly-right##31 9.871
R10919 net@3351#14pmos@183_poly-right##31 net@3351#14pmos@183_poly-right##32 9.871
R10920 net@3351#14pmos@183_poly-right##32 net@3351#14pmos@183_poly-right##33 9.871
R10921 net@3351#14pmos@183_poly-right##33 net@3351#14pmos@183_poly-right##34 9.871
R10922 net@3351#14pmos@183_poly-right##34 net@3351#14pmos@183_poly-right##35 9.871
R10923 net@3351#14pmos@183_poly-right##35 net@3351#14pmos@183_poly-right##36 9.871
R10924 net@3351#14pmos@183_poly-right##36 net@3351#14pmos@183_poly-right##37 9.871
R10925 net@3351#14pmos@183_poly-right##37 net@3351#14pmos@183_poly-right##38 9.871
R10926 net@3351#14pmos@183_poly-right##38 net@3351#14pmos@183_poly-right##39 9.871
R10927 net@3351#14pmos@183_poly-right##39 net@3351#14pmos@183_poly-right##40 9.871
R10928 net@3351#14pmos@183_poly-right##40 net@3351#14pmos@183_poly-right##41 9.871
R10929 net@3351#14pmos@183_poly-right##41 net@3351#14pmos@183_poly-right##42 9.871
R10930 net@3351#14pmos@183_poly-right##42 net@3351#14pmos@183_poly-right##43 9.871
R10931 net@3351#14pmos@183_poly-right##43 net@3351#14pmos@183_poly-right##44 9.871
R10932 net@3351#14pmos@183_poly-right##44 net@3351#14pmos@183_poly-right##45 9.871
R10933 net@3351#14pmos@183_poly-right##45 net@3351#14pmos@183_poly-right##46 9.871
R10934 net@3351#14pmos@183_poly-right##46 net@3351#14pmos@183_poly-right##47 9.871
R10935 net@3351#14pmos@183_poly-right##47 net@3351#14pmos@183_poly-right##48 9.871
R10936 net@3351#14pmos@183_poly-right##48 net@3351#14pmos@183_poly-right##49 9.871
R10937 net@3351#14pmos@183_poly-right##49 net@3351#14pmos@183_poly-right##50 9.871
R10938 net@3351#14pmos@183_poly-right##50 net@3351#14pmos@183_poly-right##51 9.871
R10939 net@3351#14pmos@183_poly-right##51 net@3351#14pmos@183_poly-right##52 9.871
R10940 net@3351#14pmos@183_poly-right##52 net@3351#14pmos@183_poly-right##53 9.871
R10941 net@3351#14pmos@183_poly-right##53 net@3351#14pmos@183_poly-right##54 9.871
R10942 net@3351#14pmos@183_poly-right##54 net@3351#14pmos@183_poly-right##55 9.871
R10943 net@3351#14pmos@183_poly-right##55 net@3351#9nmos@183_poly-left 9.871
R10944 XOR1_to_NAND6#18pin@864_polysilicon-1 XOR1_to_NAND6#18pin@864_polysilicon-1##0 8.138
R10945 XOR1_to_NAND6#18pin@864_polysilicon-1##0 XOR1_to_NAND6#18pin@864_polysilicon-1##1 8.138
R10946 XOR1_to_NAND6#18pin@864_polysilicon-1##1 XOR1_to_NAND6#18pin@864_polysilicon-1##2 8.138
R10947 XOR1_to_NAND6#18pin@864_polysilicon-1##2 XOR1_to_NAND6#1contact@984_metal-1-metal-2 8.138
R10948 net@3343#2contact@1147_metal-1-polysilicon-1 net@3343 4.706
R10949 net@3343#12pmos@186_poly-right net@3343#12pmos@186_poly-right##0 9.864
R10950 net@3343#12pmos@186_poly-right##0 net@3343#12pmos@186_poly-right##1 9.864
R10951 net@3343#12pmos@186_poly-right##1 net@3343#12pmos@186_poly-right##2 9.864
R10952 net@3343#12pmos@186_poly-right##2 net@3343#12pmos@186_poly-right##3 9.864
R10953 net@3343#12pmos@186_poly-right##3 net@3343#12pmos@186_poly-right##4 9.864
R10954 net@3343#12pmos@186_poly-right##4 net@3343#12pmos@186_poly-right##5 9.864
R10955 net@3343#12pmos@186_poly-right##5 net@3343#12pmos@186_poly-right##6 9.864
R10956 net@3343#12pmos@186_poly-right##6 net@3343#12pmos@186_poly-right##7 9.864
R10957 net@3343#12pmos@186_poly-right##7 net@3343#12pmos@186_poly-right##8 9.864
R10958 net@3343#12pmos@186_poly-right##8 net@3343#12pmos@186_poly-right##9 9.864
R10959 net@3343#12pmos@186_poly-right##9 net@3343#12pmos@186_poly-right##10 9.864
R10960 net@3343#12pmos@186_poly-right##10 net@3343#12pmos@186_poly-right##11 9.864
R10961 net@3343#12pmos@186_poly-right##11 net@3343#12pmos@186_poly-right##12 9.864
R10962 net@3343#12pmos@186_poly-right##12 net@3343#12pmos@186_poly-right##13 9.864
R10963 net@3343#12pmos@186_poly-right##13 net@3343#12pmos@186_poly-right##14 9.864
R10964 net@3343#12pmos@186_poly-right##14 net@3343#12pmos@186_poly-right##15 9.864
R10965 net@3343#12pmos@186_poly-right##15 net@3343#12pmos@186_poly-right##16 9.864
R10966 net@3343#12pmos@186_poly-right##16 net@3343#12pmos@186_poly-right##17 9.864
R10967 net@3343#12pmos@186_poly-right##17 net@3343#12pmos@186_poly-right##18 9.864
R10968 net@3343#12pmos@186_poly-right##18 net@3343#12pmos@186_poly-right##19 9.864
R10969 net@3343#12pmos@186_poly-right##19 net@3343#12pmos@186_poly-right##20 9.864
R10970 net@3343#12pmos@186_poly-right##20 net@3343#12pmos@186_poly-right##21 9.864
R10971 net@3343#12pmos@186_poly-right##21 net@3343#12pmos@186_poly-right##22 9.864
R10972 net@3343#12pmos@186_poly-right##22 net@3343#12pmos@186_poly-right##23 9.864
R10973 net@3343#12pmos@186_poly-right##23 net@3343#12pmos@186_poly-right##24 9.864
R10974 net@3343#12pmos@186_poly-right##24 net@3343#12pmos@186_poly-right##25 9.864
R10975 net@3343#12pmos@186_poly-right##25 net@3343#12pmos@186_poly-right##26 9.864
R10976 net@3343#12pmos@186_poly-right##26 net@3343#12pmos@186_poly-right##27 9.864
R10977 net@3343#12pmos@186_poly-right##27 net@3343#12pmos@186_poly-right##28 9.864
R10978 net@3343#12pmos@186_poly-right##28 net@3343#12pmos@186_poly-right##29 9.864
R10979 net@3343#12pmos@186_poly-right##29 net@3343#12pmos@186_poly-right##30 9.864
R10980 net@3343#12pmos@186_poly-right##30 net@3343#12pmos@186_poly-right##31 9.864
R10981 net@3343#12pmos@186_poly-right##31 net@3343#12pmos@186_poly-right##32 9.864
R10982 net@3343#12pmos@186_poly-right##32 net@3343#12pmos@186_poly-right##33 9.864
R10983 net@3343#12pmos@186_poly-right##33 net@3343#12pmos@186_poly-right##34 9.864
R10984 net@3343#12pmos@186_poly-right##34 net@3343#12pmos@186_poly-right##35 9.864
R10985 net@3343#12pmos@186_poly-right##35 net@3343#12pmos@186_poly-right##36 9.864
R10986 net@3343#12pmos@186_poly-right##36 net@3343#12pmos@186_poly-right##37 9.864
R10987 net@3343#12pmos@186_poly-right##37 net@3343#12pmos@186_poly-right##38 9.864
R10988 net@3343#12pmos@186_poly-right##38 net@3343#12pmos@186_poly-right##39 9.864
R10989 net@3343#12pmos@186_poly-right##39 net@3343#12pmos@186_poly-right##40 9.864
R10990 net@3343#12pmos@186_poly-right##40 net@3343#12pmos@186_poly-right##41 9.864
R10991 net@3343#12pmos@186_poly-right##41 net@3343#12pmos@186_poly-right##42 9.864
R10992 net@3343#12pmos@186_poly-right##42 net@3343#12pmos@186_poly-right##43 9.864
R10993 net@3343#12pmos@186_poly-right##43 net@3343#12pmos@186_poly-right##44 9.864
R10994 net@3343#12pmos@186_poly-right##44 net@3343#12pmos@186_poly-right##45 9.864
R10995 net@3343#12pmos@186_poly-right##45 net@3343#12pmos@186_poly-right##46 9.864
R10996 net@3343#12pmos@186_poly-right##46 net@3343#12pmos@186_poly-right##47 9.864
R10997 net@3343#12pmos@186_poly-right##47 net@3343#12pmos@186_poly-right##48 9.864
R10998 net@3343#12pmos@186_poly-right##48 net@3343#12pmos@186_poly-right##49 9.864
R10999 net@3343#12pmos@186_poly-right##49 net@3343#12pmos@186_poly-right##50 9.864
R11000 net@3343#12pmos@186_poly-right##50 net@3343#12pmos@186_poly-right##51 9.864
R11001 net@3343#12pmos@186_poly-right##51 net@3343#12pmos@186_poly-right##52 9.864
R11002 net@3343#12pmos@186_poly-right##52 net@3343#12pmos@186_poly-right##53 9.864
R11003 net@3343#12pmos@186_poly-right##53 net@3343#5pin@992_polysilicon-1 9.864
R11004 XOR1_to_NAND8#22pmos@186_diff-top XOR1_to_NAND8#1contact@1200_metal-1-metal-2 4.862
R11005 XOR1_to_NAND8#3pin@1025_polysilicon-1 XOR1_to_NAND8#3pin@1025_polysilicon-1##0 9.881
R11006 XOR1_to_NAND8#3pin@1025_polysilicon-1##0 XOR1_to_NAND8#3pin@1025_polysilicon-1##1 9.881
R11007 XOR1_to_NAND8#3pin@1025_polysilicon-1##1 XOR1_to_NAND8#3pin@1025_polysilicon-1##2 9.881
R11008 XOR1_to_NAND8#3pin@1025_polysilicon-1##2 XOR1_to_NAND8#3pin@1025_polysilicon-1##3 9.881
R11009 XOR1_to_NAND8#3pin@1025_polysilicon-1##3 XOR1_to_NAND8#3pin@1025_polysilicon-1##4 9.881
R11010 XOR1_to_NAND8#3pin@1025_polysilicon-1##4 XOR1_to_NAND8#3pin@1025_polysilicon-1##5 9.881
R11011 XOR1_to_NAND8#3pin@1025_polysilicon-1##5 XOR1_to_NAND8#3pin@1025_polysilicon-1##6 9.881
R11012 XOR1_to_NAND8#3pin@1025_polysilicon-1##6 XOR1_to_NAND8#3pin@1025_polysilicon-1##7 9.881
R11013 XOR1_to_NAND8#3pin@1025_polysilicon-1##7 XOR1_to_NAND8#3pin@1025_polysilicon-1##8 9.881
R11014 XOR1_to_NAND8#3pin@1025_polysilicon-1##8 XOR1_to_NAND8#3pin@1025_polysilicon-1##9 9.881
R11015 XOR1_to_NAND8#3pin@1025_polysilicon-1##9 XOR1_to_NAND8#3pin@1025_polysilicon-1##10 9.881
R11016 XOR1_to_NAND8#3pin@1025_polysilicon-1##10 XOR1_to_NAND8#3pin@1025_polysilicon-1##11 9.881
R11017 XOR1_to_NAND8#3pin@1025_polysilicon-1##11 XOR1_to_NAND8#3pin@1025_polysilicon-1##12 9.881
R11018 XOR1_to_NAND8#3pin@1025_polysilicon-1##12 XOR1_to_NAND8#3pin@1025_polysilicon-1##13 9.881
R11019 XOR1_to_NAND8#3pin@1025_polysilicon-1##13 XOR1_to_NAND8#3pin@1025_polysilicon-1##14 9.881
R11020 XOR1_to_NAND8#3pin@1025_polysilicon-1##14 XOR1_to_NAND8#3pin@1025_polysilicon-1##15 9.881
R11021 XOR1_to_NAND8#3pin@1025_polysilicon-1##15 XOR1_to_NAND8#3pin@1025_polysilicon-1##16 9.881
R11022 XOR1_to_NAND8#3pin@1025_polysilicon-1##16 XOR1_to_NAND8#3pin@1025_polysilicon-1##17 9.881
R11023 XOR1_to_NAND8#3pin@1025_polysilicon-1##17 XOR1_to_NAND8#3pin@1025_polysilicon-1##18 9.881
R11024 XOR1_to_NAND8#3pin@1025_polysilicon-1##18 XOR1_to_NAND8#3pin@1025_polysilicon-1##19 9.881
R11025 XOR1_to_NAND8#3pin@1025_polysilicon-1##19 XOR1_to_NAND8#3pin@1025_polysilicon-1##20 9.881
R11026 XOR1_to_NAND8#3pin@1025_polysilicon-1##20 XOR1_to_NAND8#3pin@1025_polysilicon-1##21 9.881
R11027 XOR1_to_NAND8#3pin@1025_polysilicon-1##21 XOR1_to_NAND8#3pin@1025_polysilicon-1##22 9.881
R11028 XOR1_to_NAND8#3pin@1025_polysilicon-1##22 XOR1_to_NAND8#3pin@1025_polysilicon-1##23 9.881
R11029 XOR1_to_NAND8#3pin@1025_polysilicon-1##23 XOR1_to_NAND8#3pin@1025_polysilicon-1##24 9.881
R11030 XOR1_to_NAND8#3pin@1025_polysilicon-1##24 XOR1_to_NAND8#3pin@1025_polysilicon-1##25 9.881
R11031 XOR1_to_NAND8#3pin@1025_polysilicon-1##25 XOR1_to_NAND8#3pin@1025_polysilicon-1##26 9.881
R11032 XOR1_to_NAND8#3pin@1025_polysilicon-1##26 XOR1_to_NAND8#3pin@1025_polysilicon-1##27 9.881
R11033 XOR1_to_NAND8#3pin@1025_polysilicon-1##27 XOR1_to_NAND8#3pin@1025_polysilicon-1##28 9.881
R11034 XOR1_to_NAND8#3pin@1025_polysilicon-1##28 XOR1_to_NAND8#3pin@1025_polysilicon-1##29 9.881
R11035 XOR1_to_NAND8#3pin@1025_polysilicon-1##29 XOR1_to_NAND8#3pin@1025_polysilicon-1##30 9.881
R11036 XOR1_to_NAND8#3pin@1025_polysilicon-1##30 XOR1_to_NAND8#3pin@1025_polysilicon-1##31 9.881
R11037 XOR1_to_NAND8#3pin@1025_polysilicon-1##31 XOR1_to_NAND8#3pin@1025_polysilicon-1##32 9.881
R11038 XOR1_to_NAND8#3pin@1025_polysilicon-1##32 XOR1_to_NAND8#3pin@1025_polysilicon-1##33 9.881
R11039 XOR1_to_NAND8#3pin@1025_polysilicon-1##33 XOR1_to_NAND8#3pin@1025_polysilicon-1##34 9.881
R11040 XOR1_to_NAND8#3pin@1025_polysilicon-1##34 XOR1_to_NAND8#3pin@1025_polysilicon-1##35 9.881
R11041 XOR1_to_NAND8#3pin@1025_polysilicon-1##35 XOR1_to_NAND8#3pin@1025_polysilicon-1##36 9.881
R11042 XOR1_to_NAND8#3pin@1025_polysilicon-1##36 XOR1_to_NAND8#3pin@1025_polysilicon-1##37 9.881
R11043 XOR1_to_NAND8#3pin@1025_polysilicon-1##37 XOR1_to_NAND8#3pin@1025_polysilicon-1##38 9.881
R11044 XOR1_to_NAND8#3pin@1025_polysilicon-1##38 XOR1_to_NAND8#3pin@1025_polysilicon-1##39 9.881
R11045 XOR1_to_NAND8#3pin@1025_polysilicon-1##39 XOR1_to_NAND8#3pin@1025_polysilicon-1##40 9.881
R11046 XOR1_to_NAND8#3pin@1025_polysilicon-1##40 XOR1_to_NAND8#3pin@1025_polysilicon-1##41 9.881
R11047 XOR1_to_NAND8#3pin@1025_polysilicon-1##41 XOR1_to_NAND8#3pin@1025_polysilicon-1##42 9.881
R11048 XOR1_to_NAND8#3pin@1025_polysilicon-1##42 XOR1_to_NAND8#3pin@1025_polysilicon-1##43 9.881
R11049 XOR1_to_NAND8#3pin@1025_polysilicon-1##43 XOR1_to_NAND8#3pin@1025_polysilicon-1##44 9.881
R11050 XOR1_to_NAND8#3pin@1025_polysilicon-1##44 XOR1_to_NAND8#3pin@1025_polysilicon-1##45 9.881
R11051 XOR1_to_NAND8#3pin@1025_polysilicon-1##45 XOR1_to_NAND8#3pin@1025_polysilicon-1##46 9.881
R11052 XOR1_to_NAND8#3pin@1025_polysilicon-1##46 XOR1_to_NAND8#3pin@1025_polysilicon-1##47 9.881
R11053 XOR1_to_NAND8#3pin@1025_polysilicon-1##47 XOR1_to_NAND8#3pin@1025_polysilicon-1##48 9.881
R11054 XOR1_to_NAND8#3pin@1025_polysilicon-1##48 XOR1_to_NAND8#3pin@1025_polysilicon-1##49 9.881
R11055 XOR1_to_NAND8#3pin@1025_polysilicon-1##49 XOR1_to_NAND8#3pin@1025_polysilicon-1##50 9.881
R11056 XOR1_to_NAND8#3pin@1025_polysilicon-1##50 XOR1_to_NAND8#3pin@1025_polysilicon-1##51 9.881
R11057 XOR1_to_NAND8#3pin@1025_polysilicon-1##51 XOR1_to_NAND8#3pin@1025_polysilicon-1##52 9.881
R11058 XOR1_to_NAND8#3pin@1025_polysilicon-1##52 XOR1_to_NAND8#3pin@1025_polysilicon-1##53 9.881
R11059 XOR1_to_NAND8#3pin@1025_polysilicon-1##53 XOR1_to_NAND8#3pin@1025_polysilicon-1##54 9.881
R11060 XOR1_to_NAND8#3pin@1025_polysilicon-1##54 XOR1_to_NAND8#24nmos@192_poly-right 9.881
R11061 net@3237#5pmos@192_diff-top net@3237#2pin@1014_metal-1 4.81
R11062 net@3237#1pin@1024_polysilicon-1 net@3237#1pin@1024_polysilicon-1##0 9.85
R11063 net@3237#1pin@1024_polysilicon-1##0 net@3237#1pin@1024_polysilicon-1##1 9.85
R11064 net@3237#1pin@1024_polysilicon-1##1 net@3237#1pin@1024_polysilicon-1##2 9.85
R11065 net@3237#1pin@1024_polysilicon-1##2 net@3237#1pin@1024_polysilicon-1##3 9.85
R11066 net@3237#1pin@1024_polysilicon-1##3 net@3237#1pin@1024_polysilicon-1##4 9.85
R11067 net@3237#1pin@1024_polysilicon-1##4 net@3237#1pin@1024_polysilicon-1##5 9.85
R11068 net@3237#1pin@1024_polysilicon-1##5 net@3237#1pin@1024_polysilicon-1##6 9.85
R11069 net@3237#1pin@1024_polysilicon-1##6 net@3237#1pin@1024_polysilicon-1##7 9.85
R11070 net@3237#1pin@1024_polysilicon-1##7 net@3237#1pin@1024_polysilicon-1##8 9.85
R11071 net@3237#1pin@1024_polysilicon-1##8 net@3237#1pin@1024_polysilicon-1##9 9.85
R11072 net@3237#1pin@1024_polysilicon-1##9 net@3237#1pin@1024_polysilicon-1##10 9.85
R11073 net@3237#1pin@1024_polysilicon-1##10 net@3237#1pin@1024_polysilicon-1##11 9.85
R11074 net@3237#1pin@1024_polysilicon-1##11 net@3237#1pin@1024_polysilicon-1##12 9.85
R11075 net@3237#1pin@1024_polysilicon-1##12 net@3237#1pin@1024_polysilicon-1##13 9.85
R11076 net@3237#1pin@1024_polysilicon-1##13 net@3237#1pin@1024_polysilicon-1##14 9.85
R11077 net@3237#1pin@1024_polysilicon-1##14 net@3237#1pin@1024_polysilicon-1##15 9.85
R11078 net@3237#1pin@1024_polysilicon-1##15 net@3237#1pin@1024_polysilicon-1##16 9.85
R11079 net@3237#1pin@1024_polysilicon-1##16 net@3237#1pin@1024_polysilicon-1##17 9.85
R11080 net@3237#1pin@1024_polysilicon-1##17 net@3237#1pin@1024_polysilicon-1##18 9.85
R11081 net@3237#1pin@1024_polysilicon-1##18 net@3237#1pin@1024_polysilicon-1##19 9.85
R11082 net@3237#1pin@1024_polysilicon-1##19 net@3237#1pin@1024_polysilicon-1##20 9.85
R11083 net@3237#1pin@1024_polysilicon-1##20 net@3237#1pin@1024_polysilicon-1##21 9.85
R11084 net@3237#1pin@1024_polysilicon-1##21 net@3237#1pin@1024_polysilicon-1##22 9.85
R11085 net@3237#1pin@1024_polysilicon-1##22 net@3237#1pin@1024_polysilicon-1##23 9.85
R11086 net@3237#1pin@1024_polysilicon-1##23 net@3237#1pin@1024_polysilicon-1##24 9.85
R11087 net@3237#1pin@1024_polysilicon-1##24 net@3237#1pin@1024_polysilicon-1##25 9.85
R11088 net@3237#1pin@1024_polysilicon-1##25 net@3237#1pin@1024_polysilicon-1##26 9.85
R11089 net@3237#1pin@1024_polysilicon-1##26 net@3237#1pin@1024_polysilicon-1##27 9.85
R11090 net@3237#1pin@1024_polysilicon-1##27 net@3237#1pin@1024_polysilicon-1##28 9.85
R11091 net@3237#1pin@1024_polysilicon-1##28 net@3237#1pin@1024_polysilicon-1##29 9.85
R11092 net@3237#1pin@1024_polysilicon-1##29 net@3237#1pin@1024_polysilicon-1##30 9.85
R11093 net@3237#1pin@1024_polysilicon-1##30 net@3237#1pin@1024_polysilicon-1##31 9.85
R11094 net@3237#1pin@1024_polysilicon-1##31 net@3237#1pin@1024_polysilicon-1##32 9.85
R11095 net@3237#1pin@1024_polysilicon-1##32 net@3237#1pin@1024_polysilicon-1##33 9.85
R11096 net@3237#1pin@1024_polysilicon-1##33 net@3237#1pin@1024_polysilicon-1##34 9.85
R11097 net@3237#1pin@1024_polysilicon-1##34 net@3237#1pin@1024_polysilicon-1##35 9.85
R11098 net@3237#1pin@1024_polysilicon-1##35 net@3237#1pin@1024_polysilicon-1##36 9.85
R11099 net@3237#1pin@1024_polysilicon-1##36 net@3237#1pin@1024_polysilicon-1##37 9.85
R11100 net@3237#1pin@1024_polysilicon-1##37 net@3237#1pin@1024_polysilicon-1##38 9.85
R11101 net@3237#1pin@1024_polysilicon-1##38 net@3237#1pin@1024_polysilicon-1##39 9.85
R11102 net@3237#1pin@1024_polysilicon-1##39 net@3237#1pin@1024_polysilicon-1##40 9.85
R11103 net@3237#1pin@1024_polysilicon-1##40 net@3237#1pin@1024_polysilicon-1##41 9.85
R11104 net@3237#1pin@1024_polysilicon-1##41 net@3237#1pin@1024_polysilicon-1##42 9.85
R11105 net@3237#1pin@1024_polysilicon-1##42 net@3237#1pin@1024_polysilicon-1##43 9.85
R11106 net@3237#1pin@1024_polysilicon-1##43 net@3237#1pin@1024_polysilicon-1##44 9.85
R11107 net@3237#1pin@1024_polysilicon-1##44 net@3237#1pin@1024_polysilicon-1##45 9.85
R11108 net@3237#1pin@1024_polysilicon-1##45 net@3237#1pin@1024_polysilicon-1##46 9.85
R11109 net@3237#1pin@1024_polysilicon-1##46 net@3237#1pin@1024_polysilicon-1##47 9.85
R11110 net@3237#1pin@1024_polysilicon-1##47 net@3237#1pin@1024_polysilicon-1##48 9.85
R11111 net@3237#1pin@1024_polysilicon-1##48 net@3237#1pin@1024_polysilicon-1##49 9.85
R11112 net@3237#1pin@1024_polysilicon-1##49 net@3237#1pin@1024_polysilicon-1##50 9.85
R11113 net@3237#1pin@1024_polysilicon-1##50 net@3237#1pin@1024_polysilicon-1##51 9.85
R11114 net@3237#1pin@1024_polysilicon-1##51 net@3237#1pin@1024_polysilicon-1##52 9.85
R11115 net@3237#1pin@1024_polysilicon-1##52 net@3237#1pin@1024_polysilicon-1##53 9.85
R11116 net@3237#1pin@1024_polysilicon-1##53 net@3237#1pin@1024_polysilicon-1##54 9.85
R11117 net@3237#1pin@1024_polysilicon-1##54 net@3237#1pin@1024_polysilicon-1##55 9.85
R11118 net@3237#1pin@1024_polysilicon-1##55 net@3237#1pin@1024_polysilicon-1##56 9.85
R11119 net@3237#1pin@1024_polysilicon-1##56 net@3237#1pin@1024_polysilicon-1##57 9.85
R11120 net@3237#1pin@1024_polysilicon-1##57 net@3237#1pin@1024_polysilicon-1##58 9.85
R11121 net@3237#1pin@1024_polysilicon-1##58 net@3237#1pin@1024_polysilicon-1##59 9.85
R11122 net@3237#1pin@1024_polysilicon-1##59 net@3237#1pin@1024_polysilicon-1##60 9.85
R11123 net@3237#1pin@1024_polysilicon-1##60 net@3237#2pin@1014_metal-1 9.85
R11124 Cin_to_XOR2___NAND8#26pmos@191_poly-right Cin_to_XOR2___NAND8#26pmos@191_poly-right##0 9.854
R11125 Cin_to_XOR2___NAND8#26pmos@191_poly-right##0 Cin_to_XOR2___NAND8#26pmos@191_poly-right##1 9.854
R11126 Cin_to_XOR2___NAND8#26pmos@191_poly-right##1 Cin_to_XOR2___NAND8#26pmos@191_poly-right##2 9.854
R11127 Cin_to_XOR2___NAND8#26pmos@191_poly-right##2 Cin_to_XOR2___NAND8#26pmos@191_poly-right##3 9.854
R11128 Cin_to_XOR2___NAND8#26pmos@191_poly-right##3 Cin_to_XOR2___NAND8#26pmos@191_poly-right##4 9.854
R11129 Cin_to_XOR2___NAND8#26pmos@191_poly-right##4 Cin_to_XOR2___NAND8#26pmos@191_poly-right##5 9.854
R11130 Cin_to_XOR2___NAND8#26pmos@191_poly-right##5 Cin_to_XOR2___NAND8#26pmos@191_poly-right##6 9.854
R11131 Cin_to_XOR2___NAND8#26pmos@191_poly-right##6 Cin_to_XOR2___NAND8#26pmos@191_poly-right##7 9.854
R11132 Cin_to_XOR2___NAND8#26pmos@191_poly-right##7 Cin_to_XOR2___NAND8#26pmos@191_poly-right##8 9.854
R11133 Cin_to_XOR2___NAND8#26pmos@191_poly-right##8 Cin_to_XOR2___NAND8#26pmos@191_poly-right##9 9.854
R11134 Cin_to_XOR2___NAND8#26pmos@191_poly-right##9 Cin_to_XOR2___NAND8#26pmos@191_poly-right##10 9.854
R11135 Cin_to_XOR2___NAND8#26pmos@191_poly-right##10 Cin_to_XOR2___NAND8#26pmos@191_poly-right##11 9.854
R11136 Cin_to_XOR2___NAND8#26pmos@191_poly-right##11 Cin_to_XOR2___NAND8#26pmos@191_poly-right##12 9.854
R11137 Cin_to_XOR2___NAND8#26pmos@191_poly-right##12 Cin_to_XOR2___NAND8#26pmos@191_poly-right##13 9.854
R11138 Cin_to_XOR2___NAND8#26pmos@191_poly-right##13 Cin_to_XOR2___NAND8#26pmos@191_poly-right##14 9.854
R11139 Cin_to_XOR2___NAND8#26pmos@191_poly-right##14 Cin_to_XOR2___NAND8#26pmos@191_poly-right##15 9.854
R11140 Cin_to_XOR2___NAND8#26pmos@191_poly-right##15 Cin_to_XOR2___NAND8#26pmos@191_poly-right##16 9.854
R11141 Cin_to_XOR2___NAND8#26pmos@191_poly-right##16 Cin_to_XOR2___NAND8#26pmos@191_poly-right##17 9.854
R11142 Cin_to_XOR2___NAND8#26pmos@191_poly-right##17 Cin_to_XOR2___NAND8#26pmos@191_poly-right##18 9.854
R11143 Cin_to_XOR2___NAND8#26pmos@191_poly-right##18 Cin_to_XOR2___NAND8#26pmos@191_poly-right##19 9.854
R11144 Cin_to_XOR2___NAND8#26pmos@191_poly-right##19 Cin_to_XOR2___NAND8#26pmos@191_poly-right##20 9.854
R11145 Cin_to_XOR2___NAND8#26pmos@191_poly-right##20 Cin_to_XOR2___NAND8#26pmos@191_poly-right##21 9.854
R11146 Cin_to_XOR2___NAND8#26pmos@191_poly-right##21 Cin_to_XOR2___NAND8#26pmos@191_poly-right##22 9.854
R11147 Cin_to_XOR2___NAND8#26pmos@191_poly-right##22 Cin_to_XOR2___NAND8#26pmos@191_poly-right##23 9.854
R11148 Cin_to_XOR2___NAND8#26pmos@191_poly-right##23 Cin_to_XOR2___NAND8#26pmos@191_poly-right##24 9.854
R11149 Cin_to_XOR2___NAND8#26pmos@191_poly-right##24 Cin_to_XOR2___NAND8#26pmos@191_poly-right##25 9.854
R11150 Cin_to_XOR2___NAND8#26pmos@191_poly-right##25 Cin_to_XOR2___NAND8#26pmos@191_poly-right##26 9.854
R11151 Cin_to_XOR2___NAND8#26pmos@191_poly-right##26 Cin_to_XOR2___NAND8#26pmos@191_poly-right##27 9.854
R11152 Cin_to_XOR2___NAND8#26pmos@191_poly-right##27 Cin_to_XOR2___NAND8#26pmos@191_poly-right##28 9.854
R11153 Cin_to_XOR2___NAND8#26pmos@191_poly-right##28 Cin_to_XOR2___NAND8#26pmos@191_poly-right##29 9.854
R11154 Cin_to_XOR2___NAND8#26pmos@191_poly-right##29 Cin_to_XOR2___NAND8#26pmos@191_poly-right##30 9.854
R11155 Cin_to_XOR2___NAND8#26pmos@191_poly-right##30 Cin_to_XOR2___NAND8#26pmos@191_poly-right##31 9.854
R11156 Cin_to_XOR2___NAND8#26pmos@191_poly-right##31 Cin_to_XOR2___NAND8#26pmos@191_poly-right##32 9.854
R11157 Cin_to_XOR2___NAND8#26pmos@191_poly-right##32 Cin_to_XOR2___NAND8#26pmos@191_poly-right##33 9.854
R11158 Cin_to_XOR2___NAND8#26pmos@191_poly-right##33 Cin_to_XOR2___NAND8#26pmos@191_poly-right##34 9.854
R11159 Cin_to_XOR2___NAND8#26pmos@191_poly-right##34 Cin_to_XOR2___NAND8#26pmos@191_poly-right##35 9.854
R11160 Cin_to_XOR2___NAND8#26pmos@191_poly-right##35 Cin_to_XOR2___NAND8#26pmos@191_poly-right##36 9.854
R11161 Cin_to_XOR2___NAND8#26pmos@191_poly-right##36 Cin_to_XOR2___NAND8#26pmos@191_poly-right##37 9.854
R11162 Cin_to_XOR2___NAND8#26pmos@191_poly-right##37 Cin_to_XOR2___NAND8#26pmos@191_poly-right##38 9.854
R11163 Cin_to_XOR2___NAND8#26pmos@191_poly-right##38 Cin_to_XOR2___NAND8#26pmos@191_poly-right##39 9.854
R11164 Cin_to_XOR2___NAND8#26pmos@191_poly-right##39 Cin_to_XOR2___NAND8#26pmos@191_poly-right##40 9.854
R11165 Cin_to_XOR2___NAND8#26pmos@191_poly-right##40 Cin_to_XOR2___NAND8#26pmos@191_poly-right##41 9.854
R11166 Cin_to_XOR2___NAND8#26pmos@191_poly-right##41 Cin_to_XOR2___NAND8#26pmos@191_poly-right##42 9.854
R11167 Cin_to_XOR2___NAND8#26pmos@191_poly-right##42 Cin_to_XOR2___NAND8#26pmos@191_poly-right##43 9.854
R11168 Cin_to_XOR2___NAND8#26pmos@191_poly-right##43 Cin_to_XOR2___NAND8#26pmos@191_poly-right##44 9.854
R11169 Cin_to_XOR2___NAND8#26pmos@191_poly-right##44 Cin_to_XOR2___NAND8#26pmos@191_poly-right##45 9.854
R11170 Cin_to_XOR2___NAND8#26pmos@191_poly-right##45 Cin_to_XOR2___NAND8#26pmos@191_poly-right##46 9.854
R11171 Cin_to_XOR2___NAND8#26pmos@191_poly-right##46 Cin_to_XOR2___NAND8#26pmos@191_poly-right##47 9.854
R11172 Cin_to_XOR2___NAND8#26pmos@191_poly-right##47 Cin_to_XOR2___NAND8#26pmos@191_poly-right##48 9.854
R11173 Cin_to_XOR2___NAND8#26pmos@191_poly-right##48 Cin_to_XOR2___NAND8#26pmos@191_poly-right##49 9.854
R11174 Cin_to_XOR2___NAND8#26pmos@191_poly-right##49 Cin_to_XOR2___NAND8#26pmos@191_poly-right##50 9.854
R11175 Cin_to_XOR2___NAND8#26pmos@191_poly-right##50 Cin_to_XOR2___NAND8#26pmos@191_poly-right##51 9.854
R11176 Cin_to_XOR2___NAND8#26pmos@191_poly-right##51 Cin_to_XOR2___NAND8#26pmos@191_poly-right##52 9.854
R11177 Cin_to_XOR2___NAND8#26pmos@191_poly-right##52 Cin_to_XOR2___NAND8#26pmos@191_poly-right##53 9.854
R11178 Cin_to_XOR2___NAND8#26pmos@191_poly-right##53 Cin_to_XOR2___NAND8#26pmos@191_poly-right##54 9.854
R11179 Cin_to_XOR2___NAND8#26pmos@191_poly-right##54 Cin_to_XOR2___NAND8#15pin@1015_polysilicon-1 9.854
R11180 net@3248 net@3248#2contact@1161_metal-1-metal-2 4.797
R11181 XOR1_to_NAND8#9pmos@187_poly-left XOR1_to_NAND8#9pmos@187_poly-left##0 9.871
R11182 XOR1_to_NAND8#9pmos@187_poly-left##0 XOR1_to_NAND8#9pmos@187_poly-left##1 9.871
R11183 XOR1_to_NAND8#9pmos@187_poly-left##1 XOR1_to_NAND8#9pmos@187_poly-left##2 9.871
R11184 XOR1_to_NAND8#9pmos@187_poly-left##2 XOR1_to_NAND8#9pmos@187_poly-left##3 9.871
R11185 XOR1_to_NAND8#9pmos@187_poly-left##3 XOR1_to_NAND8#9pmos@187_poly-left##4 9.871
R11186 XOR1_to_NAND8#9pmos@187_poly-left##4 XOR1_to_NAND8#9pmos@187_poly-left##5 9.871
R11187 XOR1_to_NAND8#9pmos@187_poly-left##5 XOR1_to_NAND8#9pmos@187_poly-left##6 9.871
R11188 XOR1_to_NAND8#9pmos@187_poly-left##6 XOR1_to_NAND8#9pmos@187_poly-left##7 9.871
R11189 XOR1_to_NAND8#9pmos@187_poly-left##7 XOR1_to_NAND8#9pmos@187_poly-left##8 9.871
R11190 XOR1_to_NAND8#9pmos@187_poly-left##8 XOR1_to_NAND8#9pmos@187_poly-left##9 9.871
R11191 XOR1_to_NAND8#9pmos@187_poly-left##9 XOR1_to_NAND8#9pmos@187_poly-left##10 9.871
R11192 XOR1_to_NAND8#9pmos@187_poly-left##10 XOR1_to_NAND8#9pmos@187_poly-left##11 9.871
R11193 XOR1_to_NAND8#9pmos@187_poly-left##11 XOR1_to_NAND8#9pmos@187_poly-left##12 9.871
R11194 XOR1_to_NAND8#9pmos@187_poly-left##12 XOR1_to_NAND8#9pmos@187_poly-left##13 9.871
R11195 XOR1_to_NAND8#9pmos@187_poly-left##13 XOR1_to_NAND8#9pmos@187_poly-left##14 9.871
R11196 XOR1_to_NAND8#9pmos@187_poly-left##14 XOR1_to_NAND8#9pmos@187_poly-left##15 9.871
R11197 XOR1_to_NAND8#9pmos@187_poly-left##15 XOR1_to_NAND8#9pmos@187_poly-left##16 9.871
R11198 XOR1_to_NAND8#9pmos@187_poly-left##16 XOR1_to_NAND8#9pmos@187_poly-left##17 9.871
R11199 XOR1_to_NAND8#9pmos@187_poly-left##17 XOR1_to_NAND8#9pmos@187_poly-left##18 9.871
R11200 XOR1_to_NAND8#9pmos@187_poly-left##18 XOR1_to_NAND8#9pmos@187_poly-left##19 9.871
R11201 XOR1_to_NAND8#9pmos@187_poly-left##19 XOR1_to_NAND8#9pmos@187_poly-left##20 9.871
R11202 XOR1_to_NAND8#9pmos@187_poly-left##20 XOR1_to_NAND8#9pmos@187_poly-left##21 9.871
R11203 XOR1_to_NAND8#9pmos@187_poly-left##21 XOR1_to_NAND8#9pmos@187_poly-left##22 9.871
R11204 XOR1_to_NAND8#9pmos@187_poly-left##22 XOR1_to_NAND8#9pmos@187_poly-left##23 9.871
R11205 XOR1_to_NAND8#9pmos@187_poly-left##23 XOR1_to_NAND8#9pmos@187_poly-left##24 9.871
R11206 XOR1_to_NAND8#9pmos@187_poly-left##24 XOR1_to_NAND8#9pmos@187_poly-left##25 9.871
R11207 XOR1_to_NAND8#9pmos@187_poly-left##25 XOR1_to_NAND8#9pmos@187_poly-left##26 9.871
R11208 XOR1_to_NAND8#9pmos@187_poly-left##26 XOR1_to_NAND8#9pmos@187_poly-left##27 9.871
R11209 XOR1_to_NAND8#9pmos@187_poly-left##27 XOR1_to_NAND8#9pmos@187_poly-left##28 9.871
R11210 XOR1_to_NAND8#9pmos@187_poly-left##28 XOR1_to_NAND8#9pmos@187_poly-left##29 9.871
R11211 XOR1_to_NAND8#9pmos@187_poly-left##29 XOR1_to_NAND8#9pmos@187_poly-left##30 9.871
R11212 XOR1_to_NAND8#9pmos@187_poly-left##30 XOR1_to_NAND8#9pmos@187_poly-left##31 9.871
R11213 XOR1_to_NAND8#9pmos@187_poly-left##31 XOR1_to_NAND8#9pmos@187_poly-left##32 9.871
R11214 XOR1_to_NAND8#9pmos@187_poly-left##32 XOR1_to_NAND8#9pmos@187_poly-left##33 9.871
R11215 XOR1_to_NAND8#9pmos@187_poly-left##33 XOR1_to_NAND8#9pmos@187_poly-left##34 9.871
R11216 XOR1_to_NAND8#9pmos@187_poly-left##34 XOR1_to_NAND8#9pmos@187_poly-left##35 9.871
R11217 XOR1_to_NAND8#9pmos@187_poly-left##35 XOR1_to_NAND8#9pmos@187_poly-left##36 9.871
R11218 XOR1_to_NAND8#9pmos@187_poly-left##36 XOR1_to_NAND8#9pmos@187_poly-left##37 9.871
R11219 XOR1_to_NAND8#9pmos@187_poly-left##37 XOR1_to_NAND8#9pmos@187_poly-left##38 9.871
R11220 XOR1_to_NAND8#9pmos@187_poly-left##38 XOR1_to_NAND8#9pmos@187_poly-left##39 9.871
R11221 XOR1_to_NAND8#9pmos@187_poly-left##39 XOR1_to_NAND8#9pmos@187_poly-left##40 9.871
R11222 XOR1_to_NAND8#9pmos@187_poly-left##40 XOR1_to_NAND8#9pmos@187_poly-left##41 9.871
R11223 XOR1_to_NAND8#9pmos@187_poly-left##41 XOR1_to_NAND8#9pmos@187_poly-left##42 9.871
R11224 XOR1_to_NAND8#9pmos@187_poly-left##42 XOR1_to_NAND8#9pmos@187_poly-left##43 9.871
R11225 XOR1_to_NAND8#9pmos@187_poly-left##43 XOR1_to_NAND8#9pmos@187_poly-left##44 9.871
R11226 XOR1_to_NAND8#9pmos@187_poly-left##44 XOR1_to_NAND8#9pmos@187_poly-left##45 9.871
R11227 XOR1_to_NAND8#9pmos@187_poly-left##45 XOR1_to_NAND8#9pmos@187_poly-left##46 9.871
R11228 XOR1_to_NAND8#9pmos@187_poly-left##46 XOR1_to_NAND8#9pmos@187_poly-left##47 9.871
R11229 XOR1_to_NAND8#9pmos@187_poly-left##47 XOR1_to_NAND8#9pmos@187_poly-left##48 9.871
R11230 XOR1_to_NAND8#9pmos@187_poly-left##48 XOR1_to_NAND8#9pmos@187_poly-left##49 9.871
R11231 XOR1_to_NAND8#9pmos@187_poly-left##49 XOR1_to_NAND8#9pmos@187_poly-left##50 9.871
R11232 XOR1_to_NAND8#9pmos@187_poly-left##50 XOR1_to_NAND8#9pmos@187_poly-left##51 9.871
R11233 XOR1_to_NAND8#9pmos@187_poly-left##51 XOR1_to_NAND8#9pmos@187_poly-left##52 9.871
R11234 XOR1_to_NAND8#9pmos@187_poly-left##52 XOR1_to_NAND8#9pmos@187_poly-left##53 9.871
R11235 XOR1_to_NAND8#9pmos@187_poly-left##53 XOR1_to_NAND8#9pmos@187_poly-left##54 9.871
R11236 XOR1_to_NAND8#9pmos@187_poly-left##54 XOR1_to_NAND8#9pmos@187_poly-left##55 9.871
R11237 XOR1_to_NAND8#9pmos@187_poly-left##55 XOR1_to_NAND8#26nmos@187_poly-right 9.871
R11238 net@3237#7pmos@188_poly-left net@3237#7pmos@188_poly-left##0 9.871
R11239 net@3237#7pmos@188_poly-left##0 net@3237#7pmos@188_poly-left##1 9.871
R11240 net@3237#7pmos@188_poly-left##1 net@3237#7pmos@188_poly-left##2 9.871
R11241 net@3237#7pmos@188_poly-left##2 net@3237#7pmos@188_poly-left##3 9.871
R11242 net@3237#7pmos@188_poly-left##3 net@3237#7pmos@188_poly-left##4 9.871
R11243 net@3237#7pmos@188_poly-left##4 net@3237#7pmos@188_poly-left##5 9.871
R11244 net@3237#7pmos@188_poly-left##5 net@3237#7pmos@188_poly-left##6 9.871
R11245 net@3237#7pmos@188_poly-left##6 net@3237#7pmos@188_poly-left##7 9.871
R11246 net@3237#7pmos@188_poly-left##7 net@3237#7pmos@188_poly-left##8 9.871
R11247 net@3237#7pmos@188_poly-left##8 net@3237#7pmos@188_poly-left##9 9.871
R11248 net@3237#7pmos@188_poly-left##9 net@3237#7pmos@188_poly-left##10 9.871
R11249 net@3237#7pmos@188_poly-left##10 net@3237#7pmos@188_poly-left##11 9.871
R11250 net@3237#7pmos@188_poly-left##11 net@3237#7pmos@188_poly-left##12 9.871
R11251 net@3237#7pmos@188_poly-left##12 net@3237#7pmos@188_poly-left##13 9.871
R11252 net@3237#7pmos@188_poly-left##13 net@3237#7pmos@188_poly-left##14 9.871
R11253 net@3237#7pmos@188_poly-left##14 net@3237#7pmos@188_poly-left##15 9.871
R11254 net@3237#7pmos@188_poly-left##15 net@3237#7pmos@188_poly-left##16 9.871
R11255 net@3237#7pmos@188_poly-left##16 net@3237#7pmos@188_poly-left##17 9.871
R11256 net@3237#7pmos@188_poly-left##17 net@3237#7pmos@188_poly-left##18 9.871
R11257 net@3237#7pmos@188_poly-left##18 net@3237#7pmos@188_poly-left##19 9.871
R11258 net@3237#7pmos@188_poly-left##19 net@3237#7pmos@188_poly-left##20 9.871
R11259 net@3237#7pmos@188_poly-left##20 net@3237#7pmos@188_poly-left##21 9.871
R11260 net@3237#7pmos@188_poly-left##21 net@3237#7pmos@188_poly-left##22 9.871
R11261 net@3237#7pmos@188_poly-left##22 net@3237#7pmos@188_poly-left##23 9.871
R11262 net@3237#7pmos@188_poly-left##23 net@3237#7pmos@188_poly-left##24 9.871
R11263 net@3237#7pmos@188_poly-left##24 net@3237#7pmos@188_poly-left##25 9.871
R11264 net@3237#7pmos@188_poly-left##25 net@3237#7pmos@188_poly-left##26 9.871
R11265 net@3237#7pmos@188_poly-left##26 net@3237#7pmos@188_poly-left##27 9.871
R11266 net@3237#7pmos@188_poly-left##27 net@3237#7pmos@188_poly-left##28 9.871
R11267 net@3237#7pmos@188_poly-left##28 net@3237#7pmos@188_poly-left##29 9.871
R11268 net@3237#7pmos@188_poly-left##29 net@3237#7pmos@188_poly-left##30 9.871
R11269 net@3237#7pmos@188_poly-left##30 net@3237#7pmos@188_poly-left##31 9.871
R11270 net@3237#7pmos@188_poly-left##31 net@3237#7pmos@188_poly-left##32 9.871
R11271 net@3237#7pmos@188_poly-left##32 net@3237#7pmos@188_poly-left##33 9.871
R11272 net@3237#7pmos@188_poly-left##33 net@3237#7pmos@188_poly-left##34 9.871
R11273 net@3237#7pmos@188_poly-left##34 net@3237#7pmos@188_poly-left##35 9.871
R11274 net@3237#7pmos@188_poly-left##35 net@3237#7pmos@188_poly-left##36 9.871
R11275 net@3237#7pmos@188_poly-left##36 net@3237#7pmos@188_poly-left##37 9.871
R11276 net@3237#7pmos@188_poly-left##37 net@3237#7pmos@188_poly-left##38 9.871
R11277 net@3237#7pmos@188_poly-left##38 net@3237#7pmos@188_poly-left##39 9.871
R11278 net@3237#7pmos@188_poly-left##39 net@3237#7pmos@188_poly-left##40 9.871
R11279 net@3237#7pmos@188_poly-left##40 net@3237#7pmos@188_poly-left##41 9.871
R11280 net@3237#7pmos@188_poly-left##41 net@3237#7pmos@188_poly-left##42 9.871
R11281 net@3237#7pmos@188_poly-left##42 net@3237#7pmos@188_poly-left##43 9.871
R11282 net@3237#7pmos@188_poly-left##43 net@3237#7pmos@188_poly-left##44 9.871
R11283 net@3237#7pmos@188_poly-left##44 net@3237#7pmos@188_poly-left##45 9.871
R11284 net@3237#7pmos@188_poly-left##45 net@3237#7pmos@188_poly-left##46 9.871
R11285 net@3237#7pmos@188_poly-left##46 net@3237#7pmos@188_poly-left##47 9.871
R11286 net@3237#7pmos@188_poly-left##47 net@3237#7pmos@188_poly-left##48 9.871
R11287 net@3237#7pmos@188_poly-left##48 net@3237#7pmos@188_poly-left##49 9.871
R11288 net@3237#7pmos@188_poly-left##49 net@3237#7pmos@188_poly-left##50 9.871
R11289 net@3237#7pmos@188_poly-left##50 net@3237#7pmos@188_poly-left##51 9.871
R11290 net@3237#7pmos@188_poly-left##51 net@3237#7pmos@188_poly-left##52 9.871
R11291 net@3237#7pmos@188_poly-left##52 net@3237#7pmos@188_poly-left##53 9.871
R11292 net@3237#7pmos@188_poly-left##53 net@3237#7pmos@188_poly-left##54 9.871
R11293 net@3237#7pmos@188_poly-left##54 net@3237#7pmos@188_poly-left##55 9.871
R11294 net@3237#7pmos@188_poly-left##55 net@3237#11nmos@188_poly-right 9.871
R11295 Cin_to_XOR2___NAND8#27pmos@189_poly-right Cin_to_XOR2___NAND8#27pmos@189_poly-right##0 9.871
R11296 Cin_to_XOR2___NAND8#27pmos@189_poly-right##0 Cin_to_XOR2___NAND8#27pmos@189_poly-right##1 9.871
R11297 Cin_to_XOR2___NAND8#27pmos@189_poly-right##1 Cin_to_XOR2___NAND8#27pmos@189_poly-right##2 9.871
R11298 Cin_to_XOR2___NAND8#27pmos@189_poly-right##2 Cin_to_XOR2___NAND8#27pmos@189_poly-right##3 9.871
R11299 Cin_to_XOR2___NAND8#27pmos@189_poly-right##3 Cin_to_XOR2___NAND8#27pmos@189_poly-right##4 9.871
R11300 Cin_to_XOR2___NAND8#27pmos@189_poly-right##4 Cin_to_XOR2___NAND8#27pmos@189_poly-right##5 9.871
R11301 Cin_to_XOR2___NAND8#27pmos@189_poly-right##5 Cin_to_XOR2___NAND8#27pmos@189_poly-right##6 9.871
R11302 Cin_to_XOR2___NAND8#27pmos@189_poly-right##6 Cin_to_XOR2___NAND8#27pmos@189_poly-right##7 9.871
R11303 Cin_to_XOR2___NAND8#27pmos@189_poly-right##7 Cin_to_XOR2___NAND8#27pmos@189_poly-right##8 9.871
R11304 Cin_to_XOR2___NAND8#27pmos@189_poly-right##8 Cin_to_XOR2___NAND8#27pmos@189_poly-right##9 9.871
R11305 Cin_to_XOR2___NAND8#27pmos@189_poly-right##9 Cin_to_XOR2___NAND8#27pmos@189_poly-right##10 9.871
R11306 Cin_to_XOR2___NAND8#27pmos@189_poly-right##10 Cin_to_XOR2___NAND8#27pmos@189_poly-right##11 9.871
R11307 Cin_to_XOR2___NAND8#27pmos@189_poly-right##11 Cin_to_XOR2___NAND8#27pmos@189_poly-right##12 9.871
R11308 Cin_to_XOR2___NAND8#27pmos@189_poly-right##12 Cin_to_XOR2___NAND8#27pmos@189_poly-right##13 9.871
R11309 Cin_to_XOR2___NAND8#27pmos@189_poly-right##13 Cin_to_XOR2___NAND8#27pmos@189_poly-right##14 9.871
R11310 Cin_to_XOR2___NAND8#27pmos@189_poly-right##14 Cin_to_XOR2___NAND8#27pmos@189_poly-right##15 9.871
R11311 Cin_to_XOR2___NAND8#27pmos@189_poly-right##15 Cin_to_XOR2___NAND8#27pmos@189_poly-right##16 9.871
R11312 Cin_to_XOR2___NAND8#27pmos@189_poly-right##16 Cin_to_XOR2___NAND8#27pmos@189_poly-right##17 9.871
R11313 Cin_to_XOR2___NAND8#27pmos@189_poly-right##17 Cin_to_XOR2___NAND8#27pmos@189_poly-right##18 9.871
R11314 Cin_to_XOR2___NAND8#27pmos@189_poly-right##18 Cin_to_XOR2___NAND8#27pmos@189_poly-right##19 9.871
R11315 Cin_to_XOR2___NAND8#27pmos@189_poly-right##19 Cin_to_XOR2___NAND8#27pmos@189_poly-right##20 9.871
R11316 Cin_to_XOR2___NAND8#27pmos@189_poly-right##20 Cin_to_XOR2___NAND8#27pmos@189_poly-right##21 9.871
R11317 Cin_to_XOR2___NAND8#27pmos@189_poly-right##21 Cin_to_XOR2___NAND8#27pmos@189_poly-right##22 9.871
R11318 Cin_to_XOR2___NAND8#27pmos@189_poly-right##22 Cin_to_XOR2___NAND8#27pmos@189_poly-right##23 9.871
R11319 Cin_to_XOR2___NAND8#27pmos@189_poly-right##23 Cin_to_XOR2___NAND8#27pmos@189_poly-right##24 9.871
R11320 Cin_to_XOR2___NAND8#27pmos@189_poly-right##24 Cin_to_XOR2___NAND8#27pmos@189_poly-right##25 9.871
R11321 Cin_to_XOR2___NAND8#27pmos@189_poly-right##25 Cin_to_XOR2___NAND8#27pmos@189_poly-right##26 9.871
R11322 Cin_to_XOR2___NAND8#27pmos@189_poly-right##26 Cin_to_XOR2___NAND8#27pmos@189_poly-right##27 9.871
R11323 Cin_to_XOR2___NAND8#27pmos@189_poly-right##27 Cin_to_XOR2___NAND8#27pmos@189_poly-right##28 9.871
R11324 Cin_to_XOR2___NAND8#27pmos@189_poly-right##28 Cin_to_XOR2___NAND8#27pmos@189_poly-right##29 9.871
R11325 Cin_to_XOR2___NAND8#27pmos@189_poly-right##29 Cin_to_XOR2___NAND8#27pmos@189_poly-right##30 9.871
R11326 Cin_to_XOR2___NAND8#27pmos@189_poly-right##30 Cin_to_XOR2___NAND8#27pmos@189_poly-right##31 9.871
R11327 Cin_to_XOR2___NAND8#27pmos@189_poly-right##31 Cin_to_XOR2___NAND8#27pmos@189_poly-right##32 9.871
R11328 Cin_to_XOR2___NAND8#27pmos@189_poly-right##32 Cin_to_XOR2___NAND8#27pmos@189_poly-right##33 9.871
R11329 Cin_to_XOR2___NAND8#27pmos@189_poly-right##33 Cin_to_XOR2___NAND8#27pmos@189_poly-right##34 9.871
R11330 Cin_to_XOR2___NAND8#27pmos@189_poly-right##34 Cin_to_XOR2___NAND8#27pmos@189_poly-right##35 9.871
R11331 Cin_to_XOR2___NAND8#27pmos@189_poly-right##35 Cin_to_XOR2___NAND8#27pmos@189_poly-right##36 9.871
R11332 Cin_to_XOR2___NAND8#27pmos@189_poly-right##36 Cin_to_XOR2___NAND8#27pmos@189_poly-right##37 9.871
R11333 Cin_to_XOR2___NAND8#27pmos@189_poly-right##37 Cin_to_XOR2___NAND8#27pmos@189_poly-right##38 9.871
R11334 Cin_to_XOR2___NAND8#27pmos@189_poly-right##38 Cin_to_XOR2___NAND8#27pmos@189_poly-right##39 9.871
R11335 Cin_to_XOR2___NAND8#27pmos@189_poly-right##39 Cin_to_XOR2___NAND8#27pmos@189_poly-right##40 9.871
R11336 Cin_to_XOR2___NAND8#27pmos@189_poly-right##40 Cin_to_XOR2___NAND8#27pmos@189_poly-right##41 9.871
R11337 Cin_to_XOR2___NAND8#27pmos@189_poly-right##41 Cin_to_XOR2___NAND8#27pmos@189_poly-right##42 9.871
R11338 Cin_to_XOR2___NAND8#27pmos@189_poly-right##42 Cin_to_XOR2___NAND8#27pmos@189_poly-right##43 9.871
R11339 Cin_to_XOR2___NAND8#27pmos@189_poly-right##43 Cin_to_XOR2___NAND8#27pmos@189_poly-right##44 9.871
R11340 Cin_to_XOR2___NAND8#27pmos@189_poly-right##44 Cin_to_XOR2___NAND8#27pmos@189_poly-right##45 9.871
R11341 Cin_to_XOR2___NAND8#27pmos@189_poly-right##45 Cin_to_XOR2___NAND8#27pmos@189_poly-right##46 9.871
R11342 Cin_to_XOR2___NAND8#27pmos@189_poly-right##46 Cin_to_XOR2___NAND8#27pmos@189_poly-right##47 9.871
R11343 Cin_to_XOR2___NAND8#27pmos@189_poly-right##47 Cin_to_XOR2___NAND8#27pmos@189_poly-right##48 9.871
R11344 Cin_to_XOR2___NAND8#27pmos@189_poly-right##48 Cin_to_XOR2___NAND8#27pmos@189_poly-right##49 9.871
R11345 Cin_to_XOR2___NAND8#27pmos@189_poly-right##49 Cin_to_XOR2___NAND8#27pmos@189_poly-right##50 9.871
R11346 Cin_to_XOR2___NAND8#27pmos@189_poly-right##50 Cin_to_XOR2___NAND8#27pmos@189_poly-right##51 9.871
R11347 Cin_to_XOR2___NAND8#27pmos@189_poly-right##51 Cin_to_XOR2___NAND8#27pmos@189_poly-right##52 9.871
R11348 Cin_to_XOR2___NAND8#27pmos@189_poly-right##52 Cin_to_XOR2___NAND8#27pmos@189_poly-right##53 9.871
R11349 Cin_to_XOR2___NAND8#27pmos@189_poly-right##53 Cin_to_XOR2___NAND8#27pmos@189_poly-right##54 9.871
R11350 Cin_to_XOR2___NAND8#27pmos@189_poly-right##54 Cin_to_XOR2___NAND8#27pmos@189_poly-right##55 9.871
R11351 Cin_to_XOR2___NAND8#27pmos@189_poly-right##55 Cin_to_XOR2___NAND8#18nmos@189_poly-left 9.871
R11352 net@3248#14pmos@190_poly-right net@3248#14pmos@190_poly-right##0 9.871
R11353 net@3248#14pmos@190_poly-right##0 net@3248#14pmos@190_poly-right##1 9.871
R11354 net@3248#14pmos@190_poly-right##1 net@3248#14pmos@190_poly-right##2 9.871
R11355 net@3248#14pmos@190_poly-right##2 net@3248#14pmos@190_poly-right##3 9.871
R11356 net@3248#14pmos@190_poly-right##3 net@3248#14pmos@190_poly-right##4 9.871
R11357 net@3248#14pmos@190_poly-right##4 net@3248#14pmos@190_poly-right##5 9.871
R11358 net@3248#14pmos@190_poly-right##5 net@3248#14pmos@190_poly-right##6 9.871
R11359 net@3248#14pmos@190_poly-right##6 net@3248#14pmos@190_poly-right##7 9.871
R11360 net@3248#14pmos@190_poly-right##7 net@3248#14pmos@190_poly-right##8 9.871
R11361 net@3248#14pmos@190_poly-right##8 net@3248#14pmos@190_poly-right##9 9.871
R11362 net@3248#14pmos@190_poly-right##9 net@3248#14pmos@190_poly-right##10 9.871
R11363 net@3248#14pmos@190_poly-right##10 net@3248#14pmos@190_poly-right##11 9.871
R11364 net@3248#14pmos@190_poly-right##11 net@3248#14pmos@190_poly-right##12 9.871
R11365 net@3248#14pmos@190_poly-right##12 net@3248#14pmos@190_poly-right##13 9.871
R11366 net@3248#14pmos@190_poly-right##13 net@3248#14pmos@190_poly-right##14 9.871
R11367 net@3248#14pmos@190_poly-right##14 net@3248#14pmos@190_poly-right##15 9.871
R11368 net@3248#14pmos@190_poly-right##15 net@3248#14pmos@190_poly-right##16 9.871
R11369 net@3248#14pmos@190_poly-right##16 net@3248#14pmos@190_poly-right##17 9.871
R11370 net@3248#14pmos@190_poly-right##17 net@3248#14pmos@190_poly-right##18 9.871
R11371 net@3248#14pmos@190_poly-right##18 net@3248#14pmos@190_poly-right##19 9.871
R11372 net@3248#14pmos@190_poly-right##19 net@3248#14pmos@190_poly-right##20 9.871
R11373 net@3248#14pmos@190_poly-right##20 net@3248#14pmos@190_poly-right##21 9.871
R11374 net@3248#14pmos@190_poly-right##21 net@3248#14pmos@190_poly-right##22 9.871
R11375 net@3248#14pmos@190_poly-right##22 net@3248#14pmos@190_poly-right##23 9.871
R11376 net@3248#14pmos@190_poly-right##23 net@3248#14pmos@190_poly-right##24 9.871
R11377 net@3248#14pmos@190_poly-right##24 net@3248#14pmos@190_poly-right##25 9.871
R11378 net@3248#14pmos@190_poly-right##25 net@3248#14pmos@190_poly-right##26 9.871
R11379 net@3248#14pmos@190_poly-right##26 net@3248#14pmos@190_poly-right##27 9.871
R11380 net@3248#14pmos@190_poly-right##27 net@3248#14pmos@190_poly-right##28 9.871
R11381 net@3248#14pmos@190_poly-right##28 net@3248#14pmos@190_poly-right##29 9.871
R11382 net@3248#14pmos@190_poly-right##29 net@3248#14pmos@190_poly-right##30 9.871
R11383 net@3248#14pmos@190_poly-right##30 net@3248#14pmos@190_poly-right##31 9.871
R11384 net@3248#14pmos@190_poly-right##31 net@3248#14pmos@190_poly-right##32 9.871
R11385 net@3248#14pmos@190_poly-right##32 net@3248#14pmos@190_poly-right##33 9.871
R11386 net@3248#14pmos@190_poly-right##33 net@3248#14pmos@190_poly-right##34 9.871
R11387 net@3248#14pmos@190_poly-right##34 net@3248#14pmos@190_poly-right##35 9.871
R11388 net@3248#14pmos@190_poly-right##35 net@3248#14pmos@190_poly-right##36 9.871
R11389 net@3248#14pmos@190_poly-right##36 net@3248#14pmos@190_poly-right##37 9.871
R11390 net@3248#14pmos@190_poly-right##37 net@3248#14pmos@190_poly-right##38 9.871
R11391 net@3248#14pmos@190_poly-right##38 net@3248#14pmos@190_poly-right##39 9.871
R11392 net@3248#14pmos@190_poly-right##39 net@3248#14pmos@190_poly-right##40 9.871
R11393 net@3248#14pmos@190_poly-right##40 net@3248#14pmos@190_poly-right##41 9.871
R11394 net@3248#14pmos@190_poly-right##41 net@3248#14pmos@190_poly-right##42 9.871
R11395 net@3248#14pmos@190_poly-right##42 net@3248#14pmos@190_poly-right##43 9.871
R11396 net@3248#14pmos@190_poly-right##43 net@3248#14pmos@190_poly-right##44 9.871
R11397 net@3248#14pmos@190_poly-right##44 net@3248#14pmos@190_poly-right##45 9.871
R11398 net@3248#14pmos@190_poly-right##45 net@3248#14pmos@190_poly-right##46 9.871
R11399 net@3248#14pmos@190_poly-right##46 net@3248#14pmos@190_poly-right##47 9.871
R11400 net@3248#14pmos@190_poly-right##47 net@3248#14pmos@190_poly-right##48 9.871
R11401 net@3248#14pmos@190_poly-right##48 net@3248#14pmos@190_poly-right##49 9.871
R11402 net@3248#14pmos@190_poly-right##49 net@3248#14pmos@190_poly-right##50 9.871
R11403 net@3248#14pmos@190_poly-right##50 net@3248#14pmos@190_poly-right##51 9.871
R11404 net@3248#14pmos@190_poly-right##51 net@3248#14pmos@190_poly-right##52 9.871
R11405 net@3248#14pmos@190_poly-right##52 net@3248#14pmos@190_poly-right##53 9.871
R11406 net@3248#14pmos@190_poly-right##53 net@3248#14pmos@190_poly-right##54 9.871
R11407 net@3248#14pmos@190_poly-right##54 net@3248#14pmos@190_poly-right##55 9.871
R11408 net@3248#14pmos@190_poly-right##55 net@3248#9nmos@190_poly-left 9.871
R11409 net@3247#2contact@1186_metal-1-polysilicon-1 net@3247 4.654
R11410 net@3247#12pmos@193_poly-right net@3247#12pmos@193_poly-right##0 9.931
R11411 net@3247#12pmos@193_poly-right##0 net@3247#12pmos@193_poly-right##1 9.931
R11412 net@3247#12pmos@193_poly-right##1 net@3247#12pmos@193_poly-right##2 9.931
R11413 net@3247#12pmos@193_poly-right##2 net@3247#12pmos@193_poly-right##3 9.931
R11414 net@3247#12pmos@193_poly-right##3 net@3247#12pmos@193_poly-right##4 9.931
R11415 net@3247#12pmos@193_poly-right##4 net@3247#12pmos@193_poly-right##5 9.931
R11416 net@3247#12pmos@193_poly-right##5 net@3247#12pmos@193_poly-right##6 9.931
R11417 net@3247#12pmos@193_poly-right##6 net@3247#12pmos@193_poly-right##7 9.931
R11418 net@3247#12pmos@193_poly-right##7 net@3247#12pmos@193_poly-right##8 9.931
R11419 net@3247#12pmos@193_poly-right##8 net@3247#12pmos@193_poly-right##9 9.931
R11420 net@3247#12pmos@193_poly-right##9 net@3247#12pmos@193_poly-right##10 9.931
R11421 net@3247#12pmos@193_poly-right##10 net@3247#12pmos@193_poly-right##11 9.931
R11422 net@3247#12pmos@193_poly-right##11 net@3247#12pmos@193_poly-right##12 9.931
R11423 net@3247#12pmos@193_poly-right##12 net@3247#12pmos@193_poly-right##13 9.931
R11424 net@3247#12pmos@193_poly-right##13 net@3247#12pmos@193_poly-right##14 9.931
R11425 net@3247#12pmos@193_poly-right##14 net@3247#12pmos@193_poly-right##15 9.931
R11426 net@3247#12pmos@193_poly-right##15 net@3247#12pmos@193_poly-right##16 9.931
R11427 net@3247#12pmos@193_poly-right##16 net@3247#12pmos@193_poly-right##17 9.931
R11428 net@3247#12pmos@193_poly-right##17 net@3247#12pmos@193_poly-right##18 9.931
R11429 net@3247#12pmos@193_poly-right##18 net@3247#12pmos@193_poly-right##19 9.931
R11430 net@3247#12pmos@193_poly-right##19 net@3247#12pmos@193_poly-right##20 9.931
R11431 net@3247#12pmos@193_poly-right##20 net@3247#12pmos@193_poly-right##21 9.931
R11432 net@3247#12pmos@193_poly-right##21 net@3247#12pmos@193_poly-right##22 9.931
R11433 net@3247#12pmos@193_poly-right##22 net@3247#12pmos@193_poly-right##23 9.931
R11434 net@3247#12pmos@193_poly-right##23 net@3247#12pmos@193_poly-right##24 9.931
R11435 net@3247#12pmos@193_poly-right##24 net@3247#12pmos@193_poly-right##25 9.931
R11436 net@3247#12pmos@193_poly-right##25 net@3247#12pmos@193_poly-right##26 9.931
R11437 net@3247#12pmos@193_poly-right##26 net@3247#12pmos@193_poly-right##27 9.931
R11438 net@3247#12pmos@193_poly-right##27 net@3247#12pmos@193_poly-right##28 9.931
R11439 net@3247#12pmos@193_poly-right##28 net@3247#12pmos@193_poly-right##29 9.931
R11440 net@3247#12pmos@193_poly-right##29 net@3247#12pmos@193_poly-right##30 9.931
R11441 net@3247#12pmos@193_poly-right##30 net@3247#12pmos@193_poly-right##31 9.931
R11442 net@3247#12pmos@193_poly-right##31 net@3247#12pmos@193_poly-right##32 9.931
R11443 net@3247#12pmos@193_poly-right##32 net@3247#12pmos@193_poly-right##33 9.931
R11444 net@3247#12pmos@193_poly-right##33 net@3247#12pmos@193_poly-right##34 9.931
R11445 net@3247#12pmos@193_poly-right##34 net@3247#12pmos@193_poly-right##35 9.931
R11446 net@3247#12pmos@193_poly-right##35 net@3247#12pmos@193_poly-right##36 9.931
R11447 net@3247#12pmos@193_poly-right##36 net@3247#12pmos@193_poly-right##37 9.931
R11448 net@3247#12pmos@193_poly-right##37 net@3247#12pmos@193_poly-right##38 9.931
R11449 net@3247#12pmos@193_poly-right##38 net@3247#12pmos@193_poly-right##39 9.931
R11450 net@3247#12pmos@193_poly-right##39 net@3247#12pmos@193_poly-right##40 9.931
R11451 net@3247#12pmos@193_poly-right##40 net@3247#12pmos@193_poly-right##41 9.931
R11452 net@3247#12pmos@193_poly-right##41 net@3247#12pmos@193_poly-right##42 9.931
R11453 net@3247#12pmos@193_poly-right##42 net@3247#12pmos@193_poly-right##43 9.931
R11454 net@3247#12pmos@193_poly-right##43 net@3247#12pmos@193_poly-right##44 9.931
R11455 net@3247#12pmos@193_poly-right##44 net@3247#12pmos@193_poly-right##45 9.931
R11456 net@3247#12pmos@193_poly-right##45 net@3247#12pmos@193_poly-right##46 9.931
R11457 net@3247#12pmos@193_poly-right##46 net@3247#12pmos@193_poly-right##47 9.931
R11458 net@3247#12pmos@193_poly-right##47 net@3247#12pmos@193_poly-right##48 9.931
R11459 net@3247#12pmos@193_poly-right##48 net@3247#12pmos@193_poly-right##49 9.931
R11460 net@3247#12pmos@193_poly-right##49 net@3247#12pmos@193_poly-right##50 9.931
R11461 net@3247#12pmos@193_poly-right##50 net@3247#12pmos@193_poly-right##51 9.931
R11462 net@3247#12pmos@193_poly-right##51 net@3247#12pmos@193_poly-right##52 9.931
R11463 net@3247#12pmos@193_poly-right##52 net@3247#5pin@1017_polysilicon-1 9.931
R11464 Sum7#4pmos@193_diff-top Sum7 4.823
R11465 XOR1_to_NAND8#14pin@1029_polysilicon-1 XOR1_to_NAND8#14pin@1029_polysilicon-1##0 9.854
R11466 XOR1_to_NAND8#14pin@1029_polysilicon-1##0 XOR1_to_NAND8#14pin@1029_polysilicon-1##1 9.854
R11467 XOR1_to_NAND8#14pin@1029_polysilicon-1##1 XOR1_to_NAND8#14pin@1029_polysilicon-1##2 9.854
R11468 XOR1_to_NAND8#14pin@1029_polysilicon-1##2 XOR1_to_NAND8#14pin@1029_polysilicon-1##3 9.854
R11469 XOR1_to_NAND8#14pin@1029_polysilicon-1##3 XOR1_to_NAND8#14pin@1029_polysilicon-1##4 9.854
R11470 XOR1_to_NAND8#14pin@1029_polysilicon-1##4 XOR1_to_NAND8#14pin@1029_polysilicon-1##5 9.854
R11471 XOR1_to_NAND8#14pin@1029_polysilicon-1##5 XOR1_to_NAND8#14pin@1029_polysilicon-1##6 9.854
R11472 XOR1_to_NAND8#14pin@1029_polysilicon-1##6 XOR1_to_NAND8#14pin@1029_polysilicon-1##7 9.854
R11473 XOR1_to_NAND8#14pin@1029_polysilicon-1##7 XOR1_to_NAND8#14pin@1029_polysilicon-1##8 9.854
R11474 XOR1_to_NAND8#14pin@1029_polysilicon-1##8 XOR1_to_NAND8#14pin@1029_polysilicon-1##9 9.854
R11475 XOR1_to_NAND8#14pin@1029_polysilicon-1##9 XOR1_to_NAND8#14pin@1029_polysilicon-1##10 9.854
R11476 XOR1_to_NAND8#14pin@1029_polysilicon-1##10 XOR1_to_NAND8#14pin@1029_polysilicon-1##11 9.854
R11477 XOR1_to_NAND8#14pin@1029_polysilicon-1##11 XOR1_to_NAND8#14pin@1029_polysilicon-1##12 9.854
R11478 XOR1_to_NAND8#14pin@1029_polysilicon-1##12 XOR1_to_NAND8#14pin@1029_polysilicon-1##13 9.854
R11479 XOR1_to_NAND8#14pin@1029_polysilicon-1##13 XOR1_to_NAND8#14pin@1029_polysilicon-1##14 9.854
R11480 XOR1_to_NAND8#14pin@1029_polysilicon-1##14 XOR1_to_NAND8#14pin@1029_polysilicon-1##15 9.854
R11481 XOR1_to_NAND8#14pin@1029_polysilicon-1##15 XOR1_to_NAND8#14pin@1029_polysilicon-1##16 9.854
R11482 XOR1_to_NAND8#14pin@1029_polysilicon-1##16 XOR1_to_NAND8#14pin@1029_polysilicon-1##17 9.854
R11483 XOR1_to_NAND8#14pin@1029_polysilicon-1##17 XOR1_to_NAND8#14pin@1029_polysilicon-1##18 9.854
R11484 XOR1_to_NAND8#14pin@1029_polysilicon-1##18 XOR1_to_NAND8#14pin@1029_polysilicon-1##19 9.854
R11485 XOR1_to_NAND8#14pin@1029_polysilicon-1##19 XOR1_to_NAND8#14pin@1029_polysilicon-1##20 9.854
R11486 XOR1_to_NAND8#14pin@1029_polysilicon-1##20 XOR1_to_NAND8#14pin@1029_polysilicon-1##21 9.854
R11487 XOR1_to_NAND8#14pin@1029_polysilicon-1##21 XOR1_to_NAND8#14pin@1029_polysilicon-1##22 9.854
R11488 XOR1_to_NAND8#14pin@1029_polysilicon-1##22 XOR1_to_NAND8#14pin@1029_polysilicon-1##23 9.854
R11489 XOR1_to_NAND8#14pin@1029_polysilicon-1##23 XOR1_to_NAND8#14pin@1029_polysilicon-1##24 9.854
R11490 XOR1_to_NAND8#14pin@1029_polysilicon-1##24 XOR1_to_NAND8#14pin@1029_polysilicon-1##25 9.854
R11491 XOR1_to_NAND8#14pin@1029_polysilicon-1##25 XOR1_to_NAND8#14pin@1029_polysilicon-1##26 9.854
R11492 XOR1_to_NAND8#14pin@1029_polysilicon-1##26 XOR1_to_NAND8#14pin@1029_polysilicon-1##27 9.854
R11493 XOR1_to_NAND8#14pin@1029_polysilicon-1##27 XOR1_to_NAND8#14pin@1029_polysilicon-1##28 9.854
R11494 XOR1_to_NAND8#14pin@1029_polysilicon-1##28 XOR1_to_NAND8#14pin@1029_polysilicon-1##29 9.854
R11495 XOR1_to_NAND8#14pin@1029_polysilicon-1##29 XOR1_to_NAND8#14pin@1029_polysilicon-1##30 9.854
R11496 XOR1_to_NAND8#14pin@1029_polysilicon-1##30 XOR1_to_NAND8#14pin@1029_polysilicon-1##31 9.854
R11497 XOR1_to_NAND8#14pin@1029_polysilicon-1##31 XOR1_to_NAND8#14pin@1029_polysilicon-1##32 9.854
R11498 XOR1_to_NAND8#14pin@1029_polysilicon-1##32 XOR1_to_NAND8#14pin@1029_polysilicon-1##33 9.854
R11499 XOR1_to_NAND8#14pin@1029_polysilicon-1##33 XOR1_to_NAND8#14pin@1029_polysilicon-1##34 9.854
R11500 XOR1_to_NAND8#14pin@1029_polysilicon-1##34 XOR1_to_NAND8#14pin@1029_polysilicon-1##35 9.854
R11501 XOR1_to_NAND8#14pin@1029_polysilicon-1##35 XOR1_to_NAND8#14pin@1029_polysilicon-1##36 9.854
R11502 XOR1_to_NAND8#14pin@1029_polysilicon-1##36 XOR1_to_NAND8#14pin@1029_polysilicon-1##37 9.854
R11503 XOR1_to_NAND8#14pin@1029_polysilicon-1##37 XOR1_to_NAND8#14pin@1029_polysilicon-1##38 9.854
R11504 XOR1_to_NAND8#14pin@1029_polysilicon-1##38 XOR1_to_NAND8#14pin@1029_polysilicon-1##39 9.854
R11505 XOR1_to_NAND8#14pin@1029_polysilicon-1##39 XOR1_to_NAND8#14pin@1029_polysilicon-1##40 9.854
R11506 XOR1_to_NAND8#14pin@1029_polysilicon-1##40 XOR1_to_NAND8#14pin@1029_polysilicon-1##41 9.854
R11507 XOR1_to_NAND8#14pin@1029_polysilicon-1##41 XOR1_to_NAND8#14pin@1029_polysilicon-1##42 9.854
R11508 XOR1_to_NAND8#14pin@1029_polysilicon-1##42 XOR1_to_NAND8#14pin@1029_polysilicon-1##43 9.854
R11509 XOR1_to_NAND8#14pin@1029_polysilicon-1##43 XOR1_to_NAND8#14pin@1029_polysilicon-1##44 9.854
R11510 XOR1_to_NAND8#14pin@1029_polysilicon-1##44 XOR1_to_NAND8#14pin@1029_polysilicon-1##45 9.854
R11511 XOR1_to_NAND8#14pin@1029_polysilicon-1##45 XOR1_to_NAND8#14pin@1029_polysilicon-1##46 9.854
R11512 XOR1_to_NAND8#14pin@1029_polysilicon-1##46 XOR1_to_NAND8#14pin@1029_polysilicon-1##47 9.854
R11513 XOR1_to_NAND8#14pin@1029_polysilicon-1##47 XOR1_to_NAND8#14pin@1029_polysilicon-1##48 9.854
R11514 XOR1_to_NAND8#14pin@1029_polysilicon-1##48 XOR1_to_NAND8#14pin@1029_polysilicon-1##49 9.854
R11515 XOR1_to_NAND8#14pin@1029_polysilicon-1##49 XOR1_to_NAND8#14pin@1029_polysilicon-1##50 9.854
R11516 XOR1_to_NAND8#14pin@1029_polysilicon-1##50 XOR1_to_NAND8#14pin@1029_polysilicon-1##51 9.854
R11517 XOR1_to_NAND8#14pin@1029_polysilicon-1##51 XOR1_to_NAND8#14pin@1029_polysilicon-1##52 9.854
R11518 XOR1_to_NAND8#14pin@1029_polysilicon-1##52 XOR1_to_NAND8#14pin@1029_polysilicon-1##53 9.854
R11519 XOR1_to_NAND8#14pin@1029_polysilicon-1##53 XOR1_to_NAND8#14pin@1029_polysilicon-1##54 9.854
R11520 XOR1_to_NAND8#14pin@1029_polysilicon-1##54 XOR1_to_NAND8#27nmos@194_poly-right 9.854
R11521 Cin_to_XOR2___NAND8#29pmos@195_poly-right Cin_to_XOR2___NAND8#29pmos@195_poly-right##0 9.877
R11522 Cin_to_XOR2___NAND8#29pmos@195_poly-right##0 Cin_to_XOR2___NAND8#29pmos@195_poly-right##1 9.877
R11523 Cin_to_XOR2___NAND8#29pmos@195_poly-right##1 Cin_to_XOR2___NAND8#29pmos@195_poly-right##2 9.877
R11524 Cin_to_XOR2___NAND8#29pmos@195_poly-right##2 Cin_to_XOR2___NAND8#29pmos@195_poly-right##3 9.877
R11525 Cin_to_XOR2___NAND8#29pmos@195_poly-right##3 Cin_to_XOR2___NAND8#29pmos@195_poly-right##4 9.877
R11526 Cin_to_XOR2___NAND8#29pmos@195_poly-right##4 Cin_to_XOR2___NAND8#29pmos@195_poly-right##5 9.877
R11527 Cin_to_XOR2___NAND8#29pmos@195_poly-right##5 Cin_to_XOR2___NAND8#29pmos@195_poly-right##6 9.877
R11528 Cin_to_XOR2___NAND8#29pmos@195_poly-right##6 Cin_to_XOR2___NAND8#29pmos@195_poly-right##7 9.877
R11529 Cin_to_XOR2___NAND8#29pmos@195_poly-right##7 Cin_to_XOR2___NAND8#29pmos@195_poly-right##8 9.877
R11530 Cin_to_XOR2___NAND8#29pmos@195_poly-right##8 Cin_to_XOR2___NAND8#29pmos@195_poly-right##9 9.877
R11531 Cin_to_XOR2___NAND8#29pmos@195_poly-right##9 Cin_to_XOR2___NAND8#29pmos@195_poly-right##10 9.877
R11532 Cin_to_XOR2___NAND8#29pmos@195_poly-right##10 Cin_to_XOR2___NAND8#29pmos@195_poly-right##11 9.877
R11533 Cin_to_XOR2___NAND8#29pmos@195_poly-right##11 Cin_to_XOR2___NAND8#29pmos@195_poly-right##12 9.877
R11534 Cin_to_XOR2___NAND8#29pmos@195_poly-right##12 Cin_to_XOR2___NAND8#29pmos@195_poly-right##13 9.877
R11535 Cin_to_XOR2___NAND8#29pmos@195_poly-right##13 Cin_to_XOR2___NAND8#29pmos@195_poly-right##14 9.877
R11536 Cin_to_XOR2___NAND8#29pmos@195_poly-right##14 Cin_to_XOR2___NAND8#29pmos@195_poly-right##15 9.877
R11537 Cin_to_XOR2___NAND8#29pmos@195_poly-right##15 Cin_to_XOR2___NAND8#29pmos@195_poly-right##16 9.877
R11538 Cin_to_XOR2___NAND8#29pmos@195_poly-right##16 Cin_to_XOR2___NAND8#29pmos@195_poly-right##17 9.877
R11539 Cin_to_XOR2___NAND8#29pmos@195_poly-right##17 Cin_to_XOR2___NAND8#29pmos@195_poly-right##18 9.877
R11540 Cin_to_XOR2___NAND8#29pmos@195_poly-right##18 Cin_to_XOR2___NAND8#29pmos@195_poly-right##19 9.877
R11541 Cin_to_XOR2___NAND8#29pmos@195_poly-right##19 Cin_to_XOR2___NAND8#29pmos@195_poly-right##20 9.877
R11542 Cin_to_XOR2___NAND8#29pmos@195_poly-right##20 Cin_to_XOR2___NAND8#29pmos@195_poly-right##21 9.877
R11543 Cin_to_XOR2___NAND8#29pmos@195_poly-right##21 Cin_to_XOR2___NAND8#29pmos@195_poly-right##22 9.877
R11544 Cin_to_XOR2___NAND8#29pmos@195_poly-right##22 Cin_to_XOR2___NAND8#29pmos@195_poly-right##23 9.877
R11545 Cin_to_XOR2___NAND8#29pmos@195_poly-right##23 Cin_to_XOR2___NAND8#29pmos@195_poly-right##24 9.877
R11546 Cin_to_XOR2___NAND8#29pmos@195_poly-right##24 Cin_to_XOR2___NAND8#29pmos@195_poly-right##25 9.877
R11547 Cin_to_XOR2___NAND8#29pmos@195_poly-right##25 Cin_to_XOR2___NAND8#29pmos@195_poly-right##26 9.877
R11548 Cin_to_XOR2___NAND8#29pmos@195_poly-right##26 Cin_to_XOR2___NAND8#29pmos@195_poly-right##27 9.877
R11549 Cin_to_XOR2___NAND8#29pmos@195_poly-right##27 Cin_to_XOR2___NAND8#29pmos@195_poly-right##28 9.877
R11550 Cin_to_XOR2___NAND8#29pmos@195_poly-right##28 Cin_to_XOR2___NAND8#29pmos@195_poly-right##29 9.877
R11551 Cin_to_XOR2___NAND8#29pmos@195_poly-right##29 Cin_to_XOR2___NAND8#29pmos@195_poly-right##30 9.877
R11552 Cin_to_XOR2___NAND8#29pmos@195_poly-right##30 Cin_to_XOR2___NAND8#29pmos@195_poly-right##31 9.877
R11553 Cin_to_XOR2___NAND8#29pmos@195_poly-right##31 Cin_to_XOR2___NAND8#29pmos@195_poly-right##32 9.877
R11554 Cin_to_XOR2___NAND8#29pmos@195_poly-right##32 Cin_to_XOR2___NAND8#29pmos@195_poly-right##33 9.877
R11555 Cin_to_XOR2___NAND8#29pmos@195_poly-right##33 Cin_to_XOR2___NAND8#29pmos@195_poly-right##34 9.877
R11556 Cin_to_XOR2___NAND8#29pmos@195_poly-right##34 Cin_to_XOR2___NAND8#29pmos@195_poly-right##35 9.877
R11557 Cin_to_XOR2___NAND8#29pmos@195_poly-right##35 Cin_to_XOR2___NAND8#29pmos@195_poly-right##36 9.877
R11558 Cin_to_XOR2___NAND8#29pmos@195_poly-right##36 Cin_to_XOR2___NAND8#29pmos@195_poly-right##37 9.877
R11559 Cin_to_XOR2___NAND8#29pmos@195_poly-right##37 Cin_to_XOR2___NAND8#29pmos@195_poly-right##38 9.877
R11560 Cin_to_XOR2___NAND8#29pmos@195_poly-right##38 Cin_to_XOR2___NAND8#29pmos@195_poly-right##39 9.877
R11561 Cin_to_XOR2___NAND8#29pmos@195_poly-right##39 Cin_to_XOR2___NAND8#29pmos@195_poly-right##40 9.877
R11562 Cin_to_XOR2___NAND8#29pmos@195_poly-right##40 Cin_to_XOR2___NAND8#29pmos@195_poly-right##41 9.877
R11563 Cin_to_XOR2___NAND8#29pmos@195_poly-right##41 Cin_to_XOR2___NAND8#29pmos@195_poly-right##42 9.877
R11564 Cin_to_XOR2___NAND8#29pmos@195_poly-right##42 Cin_to_XOR2___NAND8#29pmos@195_poly-right##43 9.877
R11565 Cin_to_XOR2___NAND8#29pmos@195_poly-right##43 Cin_to_XOR2___NAND8#29pmos@195_poly-right##44 9.877
R11566 Cin_to_XOR2___NAND8#29pmos@195_poly-right##44 Cin_to_XOR2___NAND8#29pmos@195_poly-right##45 9.877
R11567 Cin_to_XOR2___NAND8#29pmos@195_poly-right##45 Cin_to_XOR2___NAND8#29pmos@195_poly-right##46 9.877
R11568 Cin_to_XOR2___NAND8#29pmos@195_poly-right##46 Cin_to_XOR2___NAND8#29pmos@195_poly-right##47 9.877
R11569 Cin_to_XOR2___NAND8#29pmos@195_poly-right##47 Cin_to_XOR2___NAND8#29pmos@195_poly-right##48 9.877
R11570 Cin_to_XOR2___NAND8#29pmos@195_poly-right##48 Cin_to_XOR2___NAND8#29pmos@195_poly-right##49 9.877
R11571 Cin_to_XOR2___NAND8#29pmos@195_poly-right##49 Cin_to_XOR2___NAND8#23pin@1033_polysilicon-1 9.877
R11572 NAND1_to_NAND10 NAND1_to_NAND10#4nmos@195_diff-bottom 4.823
R11573 A7#10pin@1036_polysilicon-1 A7#10pin@1036_polysilicon-1##0 9.938
R11574 A7#10pin@1036_polysilicon-1##0 A7#10pin@1036_polysilicon-1##1 9.938
R11575 A7#10pin@1036_polysilicon-1##1 A7#10pin@1036_polysilicon-1##2 9.938
R11576 A7#10pin@1036_polysilicon-1##2 A7#10pin@1036_polysilicon-1##3 9.938
R11577 A7#10pin@1036_polysilicon-1##3 A7#10pin@1036_polysilicon-1##4 9.938
R11578 A7#10pin@1036_polysilicon-1##4 A7#10pin@1036_polysilicon-1##5 9.938
R11579 A7#10pin@1036_polysilicon-1##5 A7#10pin@1036_polysilicon-1##6 9.938
R11580 A7#10pin@1036_polysilicon-1##6 A7#10pin@1036_polysilicon-1##7 9.938
R11581 A7#10pin@1036_polysilicon-1##7 A7#10pin@1036_polysilicon-1##8 9.938
R11582 A7#10pin@1036_polysilicon-1##8 A7#10pin@1036_polysilicon-1##9 9.938
R11583 A7#10pin@1036_polysilicon-1##9 A7#10pin@1036_polysilicon-1##10 9.938
R11584 A7#10pin@1036_polysilicon-1##10 A7#10pin@1036_polysilicon-1##11 9.938
R11585 A7#10pin@1036_polysilicon-1##11 A7#10pin@1036_polysilicon-1##12 9.938
R11586 A7#10pin@1036_polysilicon-1##12 A7#10pin@1036_polysilicon-1##13 9.938
R11587 A7#10pin@1036_polysilicon-1##13 A7#10pin@1036_polysilicon-1##14 9.938
R11588 A7#10pin@1036_polysilicon-1##14 A7#10pin@1036_polysilicon-1##15 9.938
R11589 A7#10pin@1036_polysilicon-1##15 A7#10pin@1036_polysilicon-1##16 9.938
R11590 A7#10pin@1036_polysilicon-1##16 A7#10pin@1036_polysilicon-1##17 9.938
R11591 A7#10pin@1036_polysilicon-1##17 A7#10pin@1036_polysilicon-1##18 9.938
R11592 A7#10pin@1036_polysilicon-1##18 A7#10pin@1036_polysilicon-1##19 9.938
R11593 A7#10pin@1036_polysilicon-1##19 A7#10pin@1036_polysilicon-1##20 9.938
R11594 A7#10pin@1036_polysilicon-1##20 A7#10pin@1036_polysilicon-1##21 9.938
R11595 A7#10pin@1036_polysilicon-1##21 A7#10pin@1036_polysilicon-1##22 9.938
R11596 A7#10pin@1036_polysilicon-1##22 A7#10pin@1036_polysilicon-1##23 9.938
R11597 A7#10pin@1036_polysilicon-1##23 A7#10pin@1036_polysilicon-1##24 9.938
R11598 A7#10pin@1036_polysilicon-1##24 A7#10pin@1036_polysilicon-1##25 9.938
R11599 A7#10pin@1036_polysilicon-1##25 A7#10pin@1036_polysilicon-1##26 9.938
R11600 A7#10pin@1036_polysilicon-1##26 A7#10pin@1036_polysilicon-1##27 9.938
R11601 A7#10pin@1036_polysilicon-1##27 A7#10pin@1036_polysilicon-1##28 9.938
R11602 A7#10pin@1036_polysilicon-1##28 A7#10pin@1036_polysilicon-1##29 9.938
R11603 A7#10pin@1036_polysilicon-1##29 A7#10pin@1036_polysilicon-1##30 9.938
R11604 A7#10pin@1036_polysilicon-1##30 A7#10pin@1036_polysilicon-1##31 9.938
R11605 A7#10pin@1036_polysilicon-1##31 A7#10pin@1036_polysilicon-1##32 9.938
R11606 A7#10pin@1036_polysilicon-1##32 A7#10pin@1036_polysilicon-1##33 9.938
R11607 A7#10pin@1036_polysilicon-1##33 A7#10pin@1036_polysilicon-1##34 9.938
R11608 A7#10pin@1036_polysilicon-1##34 A7#10pin@1036_polysilicon-1##35 9.938
R11609 A7#10pin@1036_polysilicon-1##35 A7#10pin@1036_polysilicon-1##36 9.938
R11610 A7#10pin@1036_polysilicon-1##36 A7#10pin@1036_polysilicon-1##37 9.938
R11611 A7#10pin@1036_polysilicon-1##37 A7#10pin@1036_polysilicon-1##38 9.938
R11612 A7#10pin@1036_polysilicon-1##38 A7#10pin@1036_polysilicon-1##39 9.938
R11613 A7#10pin@1036_polysilicon-1##39 A7#10pin@1036_polysilicon-1##40 9.938
R11614 A7#10pin@1036_polysilicon-1##40 A7#10pin@1036_polysilicon-1##41 9.938
R11615 A7#10pin@1036_polysilicon-1##41 A7#10pin@1036_polysilicon-1##42 9.938
R11616 A7#10pin@1036_polysilicon-1##42 A7#10pin@1036_polysilicon-1##43 9.938
R11617 A7#10pin@1036_polysilicon-1##43 A7#10pin@1036_polysilicon-1##44 9.938
R11618 A7#10pin@1036_polysilicon-1##44 A7#10pin@1036_polysilicon-1##45 9.938
R11619 A7#10pin@1036_polysilicon-1##45 A7#10pin@1036_polysilicon-1##46 9.938
R11620 A7#10pin@1036_polysilicon-1##46 A7#10pin@1036_polysilicon-1##47 9.938
R11621 A7#10pin@1036_polysilicon-1##47 A7#10pin@1036_polysilicon-1##48 9.938
R11622 A7#10pin@1036_polysilicon-1##48 A7#10pin@1036_polysilicon-1##49 9.938
R11623 A7#10pin@1036_polysilicon-1##49 A7#19nmos@196_poly-right 9.938
R11624 B7#20pmos@197_poly-right B7#20pmos@197_poly-right##0 9.869
R11625 B7#20pmos@197_poly-right##0 B7#20pmos@197_poly-right##1 9.869
R11626 B7#20pmos@197_poly-right##1 B7#20pmos@197_poly-right##2 9.869
R11627 B7#20pmos@197_poly-right##2 B7#20pmos@197_poly-right##3 9.869
R11628 B7#20pmos@197_poly-right##3 B7#20pmos@197_poly-right##4 9.869
R11629 B7#20pmos@197_poly-right##4 B7#20pmos@197_poly-right##5 9.869
R11630 B7#20pmos@197_poly-right##5 B7#20pmos@197_poly-right##6 9.869
R11631 B7#20pmos@197_poly-right##6 B7#20pmos@197_poly-right##7 9.869
R11632 B7#20pmos@197_poly-right##7 B7#20pmos@197_poly-right##8 9.869
R11633 B7#20pmos@197_poly-right##8 B7#20pmos@197_poly-right##9 9.869
R11634 B7#20pmos@197_poly-right##9 B7#20pmos@197_poly-right##10 9.869
R11635 B7#20pmos@197_poly-right##10 B7#20pmos@197_poly-right##11 9.869
R11636 B7#20pmos@197_poly-right##11 B7#20pmos@197_poly-right##12 9.869
R11637 B7#20pmos@197_poly-right##12 B7#20pmos@197_poly-right##13 9.869
R11638 B7#20pmos@197_poly-right##13 B7#20pmos@197_poly-right##14 9.869
R11639 B7#20pmos@197_poly-right##14 B7#20pmos@197_poly-right##15 9.869
R11640 B7#20pmos@197_poly-right##15 B7#20pmos@197_poly-right##16 9.869
R11641 B7#20pmos@197_poly-right##16 B7#20pmos@197_poly-right##17 9.869
R11642 B7#20pmos@197_poly-right##17 B7#20pmos@197_poly-right##18 9.869
R11643 B7#20pmos@197_poly-right##18 B7#20pmos@197_poly-right##19 9.869
R11644 B7#20pmos@197_poly-right##19 B7#20pmos@197_poly-right##20 9.869
R11645 B7#20pmos@197_poly-right##20 B7#20pmos@197_poly-right##21 9.869
R11646 B7#20pmos@197_poly-right##21 B7#20pmos@197_poly-right##22 9.869
R11647 B7#20pmos@197_poly-right##22 B7#20pmos@197_poly-right##23 9.869
R11648 B7#20pmos@197_poly-right##23 B7#20pmos@197_poly-right##24 9.869
R11649 B7#20pmos@197_poly-right##24 B7#20pmos@197_poly-right##25 9.869
R11650 B7#20pmos@197_poly-right##25 B7#20pmos@197_poly-right##26 9.869
R11651 B7#20pmos@197_poly-right##26 B7#20pmos@197_poly-right##27 9.869
R11652 B7#20pmos@197_poly-right##27 B7#20pmos@197_poly-right##28 9.869
R11653 B7#20pmos@197_poly-right##28 B7#20pmos@197_poly-right##29 9.869
R11654 B7#20pmos@197_poly-right##29 B7#20pmos@197_poly-right##30 9.869
R11655 B7#20pmos@197_poly-right##30 B7#20pmos@197_poly-right##31 9.869
R11656 B7#20pmos@197_poly-right##31 B7#20pmos@197_poly-right##32 9.869
R11657 B7#20pmos@197_poly-right##32 B7#20pmos@197_poly-right##33 9.869
R11658 B7#20pmos@197_poly-right##33 B7#20pmos@197_poly-right##34 9.869
R11659 B7#20pmos@197_poly-right##34 B7#20pmos@197_poly-right##35 9.869
R11660 B7#20pmos@197_poly-right##35 B7#20pmos@197_poly-right##36 9.869
R11661 B7#20pmos@197_poly-right##36 B7#20pmos@197_poly-right##37 9.869
R11662 B7#20pmos@197_poly-right##37 B7#20pmos@197_poly-right##38 9.869
R11663 B7#20pmos@197_poly-right##38 B7#20pmos@197_poly-right##39 9.869
R11664 B7#20pmos@197_poly-right##39 B7#20pmos@197_poly-right##40 9.869
R11665 B7#20pmos@197_poly-right##40 B7#20pmos@197_poly-right##41 9.869
R11666 B7#20pmos@197_poly-right##41 B7#20pmos@197_poly-right##42 9.869
R11667 B7#20pmos@197_poly-right##42 B7#20pmos@197_poly-right##43 9.869
R11668 B7#20pmos@197_poly-right##43 B7#20pmos@197_poly-right##44 9.869
R11669 B7#20pmos@197_poly-right##44 B7#20pmos@197_poly-right##45 9.869
R11670 B7#20pmos@197_poly-right##45 B7#20pmos@197_poly-right##46 9.869
R11671 B7#20pmos@197_poly-right##46 B7#20pmos@197_poly-right##47 9.869
R11672 B7#20pmos@197_poly-right##47 B7#10pin@1040_polysilicon-1 9.869
R11673 NAND2_to_Nand10#9pin@1042_polysilicon-1 NAND2_to_Nand10#9pin@1042_polysilicon-1##0 9.938
R11674 NAND2_to_Nand10#9pin@1042_polysilicon-1##0 NAND2_to_Nand10#9pin@1042_polysilicon-1##1 9.938
R11675 NAND2_to_Nand10#9pin@1042_polysilicon-1##1 NAND2_to_Nand10#9pin@1042_polysilicon-1##2 9.938
R11676 NAND2_to_Nand10#9pin@1042_polysilicon-1##2 NAND2_to_Nand10#9pin@1042_polysilicon-1##3 9.938
R11677 NAND2_to_Nand10#9pin@1042_polysilicon-1##3 NAND2_to_Nand10#9pin@1042_polysilicon-1##4 9.938
R11678 NAND2_to_Nand10#9pin@1042_polysilicon-1##4 NAND2_to_Nand10#9pin@1042_polysilicon-1##5 9.938
R11679 NAND2_to_Nand10#9pin@1042_polysilicon-1##5 NAND2_to_Nand10#9pin@1042_polysilicon-1##6 9.938
R11680 NAND2_to_Nand10#9pin@1042_polysilicon-1##6 NAND2_to_Nand10#9pin@1042_polysilicon-1##7 9.938
R11681 NAND2_to_Nand10#9pin@1042_polysilicon-1##7 NAND2_to_Nand10#9pin@1042_polysilicon-1##8 9.938
R11682 NAND2_to_Nand10#9pin@1042_polysilicon-1##8 NAND2_to_Nand10#9pin@1042_polysilicon-1##9 9.938
R11683 NAND2_to_Nand10#9pin@1042_polysilicon-1##9 NAND2_to_Nand10#9pin@1042_polysilicon-1##10 9.938
R11684 NAND2_to_Nand10#9pin@1042_polysilicon-1##10 NAND2_to_Nand10#9pin@1042_polysilicon-1##11 9.938
R11685 NAND2_to_Nand10#9pin@1042_polysilicon-1##11 NAND2_to_Nand10#9pin@1042_polysilicon-1##12 9.938
R11686 NAND2_to_Nand10#9pin@1042_polysilicon-1##12 NAND2_to_Nand10#9pin@1042_polysilicon-1##13 9.938
R11687 NAND2_to_Nand10#9pin@1042_polysilicon-1##13 NAND2_to_Nand10#9pin@1042_polysilicon-1##14 9.938
R11688 NAND2_to_Nand10#9pin@1042_polysilicon-1##14 NAND2_to_Nand10#9pin@1042_polysilicon-1##15 9.938
R11689 NAND2_to_Nand10#9pin@1042_polysilicon-1##15 NAND2_to_Nand10#9pin@1042_polysilicon-1##16 9.938
R11690 NAND2_to_Nand10#9pin@1042_polysilicon-1##16 NAND2_to_Nand10#9pin@1042_polysilicon-1##17 9.938
R11691 NAND2_to_Nand10#9pin@1042_polysilicon-1##17 NAND2_to_Nand10#9pin@1042_polysilicon-1##18 9.938
R11692 NAND2_to_Nand10#9pin@1042_polysilicon-1##18 NAND2_to_Nand10#9pin@1042_polysilicon-1##19 9.938
R11693 NAND2_to_Nand10#9pin@1042_polysilicon-1##19 NAND2_to_Nand10#9pin@1042_polysilicon-1##20 9.938
R11694 NAND2_to_Nand10#9pin@1042_polysilicon-1##20 NAND2_to_Nand10#9pin@1042_polysilicon-1##21 9.938
R11695 NAND2_to_Nand10#9pin@1042_polysilicon-1##21 NAND2_to_Nand10#9pin@1042_polysilicon-1##22 9.938
R11696 NAND2_to_Nand10#9pin@1042_polysilicon-1##22 NAND2_to_Nand10#9pin@1042_polysilicon-1##23 9.938
R11697 NAND2_to_Nand10#9pin@1042_polysilicon-1##23 NAND2_to_Nand10#9pin@1042_polysilicon-1##24 9.938
R11698 NAND2_to_Nand10#9pin@1042_polysilicon-1##24 NAND2_to_Nand10#9pin@1042_polysilicon-1##25 9.938
R11699 NAND2_to_Nand10#9pin@1042_polysilicon-1##25 NAND2_to_Nand10#9pin@1042_polysilicon-1##26 9.938
R11700 NAND2_to_Nand10#9pin@1042_polysilicon-1##26 NAND2_to_Nand10#9pin@1042_polysilicon-1##27 9.938
R11701 NAND2_to_Nand10#9pin@1042_polysilicon-1##27 NAND2_to_Nand10#9pin@1042_polysilicon-1##28 9.938
R11702 NAND2_to_Nand10#9pin@1042_polysilicon-1##28 NAND2_to_Nand10#9pin@1042_polysilicon-1##29 9.938
R11703 NAND2_to_Nand10#9pin@1042_polysilicon-1##29 NAND2_to_Nand10#9pin@1042_polysilicon-1##30 9.938
R11704 NAND2_to_Nand10#9pin@1042_polysilicon-1##30 NAND2_to_Nand10#9pin@1042_polysilicon-1##31 9.938
R11705 NAND2_to_Nand10#9pin@1042_polysilicon-1##31 NAND2_to_Nand10#9pin@1042_polysilicon-1##32 9.938
R11706 NAND2_to_Nand10#9pin@1042_polysilicon-1##32 NAND2_to_Nand10#9pin@1042_polysilicon-1##33 9.938
R11707 NAND2_to_Nand10#9pin@1042_polysilicon-1##33 NAND2_to_Nand10#9pin@1042_polysilicon-1##34 9.938
R11708 NAND2_to_Nand10#9pin@1042_polysilicon-1##34 NAND2_to_Nand10#9pin@1042_polysilicon-1##35 9.938
R11709 NAND2_to_Nand10#9pin@1042_polysilicon-1##35 NAND2_to_Nand10#9pin@1042_polysilicon-1##36 9.938
R11710 NAND2_to_Nand10#9pin@1042_polysilicon-1##36 NAND2_to_Nand10#9pin@1042_polysilicon-1##37 9.938
R11711 NAND2_to_Nand10#9pin@1042_polysilicon-1##37 NAND2_to_Nand10#9pin@1042_polysilicon-1##38 9.938
R11712 NAND2_to_Nand10#9pin@1042_polysilicon-1##38 NAND2_to_Nand10#9pin@1042_polysilicon-1##39 9.938
R11713 NAND2_to_Nand10#9pin@1042_polysilicon-1##39 NAND2_to_Nand10#9pin@1042_polysilicon-1##40 9.938
R11714 NAND2_to_Nand10#9pin@1042_polysilicon-1##40 NAND2_to_Nand10#9pin@1042_polysilicon-1##41 9.938
R11715 NAND2_to_Nand10#9pin@1042_polysilicon-1##41 NAND2_to_Nand10#9pin@1042_polysilicon-1##42 9.938
R11716 NAND2_to_Nand10#9pin@1042_polysilicon-1##42 NAND2_to_Nand10#9pin@1042_polysilicon-1##43 9.938
R11717 NAND2_to_Nand10#9pin@1042_polysilicon-1##43 NAND2_to_Nand10#9pin@1042_polysilicon-1##44 9.938
R11718 NAND2_to_Nand10#9pin@1042_polysilicon-1##44 NAND2_to_Nand10#9pin@1042_polysilicon-1##45 9.938
R11719 NAND2_to_Nand10#9pin@1042_polysilicon-1##45 NAND2_to_Nand10#9pin@1042_polysilicon-1##46 9.938
R11720 NAND2_to_Nand10#9pin@1042_polysilicon-1##46 NAND2_to_Nand10#9pin@1042_polysilicon-1##47 9.938
R11721 NAND2_to_Nand10#9pin@1042_polysilicon-1##47 NAND2_to_Nand10#9pin@1042_polysilicon-1##48 9.938
R11722 NAND2_to_Nand10#9pin@1042_polysilicon-1##48 NAND2_to_Nand10#9pin@1042_polysilicon-1##49 9.938
R11723 NAND2_to_Nand10#9pin@1042_polysilicon-1##49 NAND2_to_Nand10#11nmos@198_poly-right 9.938
R11724 NAND1_to_NAND10#14nmos@199_poly-right NAND1_to_NAND10#14nmos@199_poly-right##0 9.898
R11725 NAND1_to_NAND10#14nmos@199_poly-right##0 NAND1_to_NAND10#14nmos@199_poly-right##1 9.898
R11726 NAND1_to_NAND10#14nmos@199_poly-right##1 NAND1_to_NAND10#14nmos@199_poly-right##2 9.898
R11727 NAND1_to_NAND10#14nmos@199_poly-right##2 NAND1_to_NAND10#14nmos@199_poly-right##3 9.898
R11728 NAND1_to_NAND10#14nmos@199_poly-right##3 NAND1_to_NAND10#14nmos@199_poly-right##4 9.898
R11729 NAND1_to_NAND10#14nmos@199_poly-right##4 NAND1_to_NAND10#14nmos@199_poly-right##5 9.898
R11730 NAND1_to_NAND10#14nmos@199_poly-right##5 NAND1_to_NAND10#14nmos@199_poly-right##6 9.898
R11731 NAND1_to_NAND10#14nmos@199_poly-right##6 NAND1_to_NAND10#14nmos@199_poly-right##7 9.898
R11732 NAND1_to_NAND10#14nmos@199_poly-right##7 NAND1_to_NAND10#14nmos@199_poly-right##8 9.898
R11733 NAND1_to_NAND10#14nmos@199_poly-right##8 NAND1_to_NAND10#14nmos@199_poly-right##9 9.898
R11734 NAND1_to_NAND10#14nmos@199_poly-right##9 NAND1_to_NAND10#14nmos@199_poly-right##10 9.898
R11735 NAND1_to_NAND10#14nmos@199_poly-right##10 NAND1_to_NAND10#14nmos@199_poly-right##11 9.898
R11736 NAND1_to_NAND10#14nmos@199_poly-right##11 NAND1_to_NAND10#14nmos@199_poly-right##12 9.898
R11737 NAND1_to_NAND10#14nmos@199_poly-right##12 NAND1_to_NAND10#14nmos@199_poly-right##13 9.898
R11738 NAND1_to_NAND10#14nmos@199_poly-right##13 NAND1_to_NAND10#14nmos@199_poly-right##14 9.898
R11739 NAND1_to_NAND10#14nmos@199_poly-right##14 NAND1_to_NAND10#14nmos@199_poly-right##15 9.898
R11740 NAND1_to_NAND10#14nmos@199_poly-right##15 NAND1_to_NAND10#14nmos@199_poly-right##16 9.898
R11741 NAND1_to_NAND10#14nmos@199_poly-right##16 NAND1_to_NAND10#14nmos@199_poly-right##17 9.898
R11742 NAND1_to_NAND10#14nmos@199_poly-right##17 NAND1_to_NAND10#14nmos@199_poly-right##18 9.898
R11743 NAND1_to_NAND10#14nmos@199_poly-right##18 NAND1_to_NAND10#14nmos@199_poly-right##19 9.898
R11744 NAND1_to_NAND10#14nmos@199_poly-right##19 NAND1_to_NAND10#14nmos@199_poly-right##20 9.898
R11745 NAND1_to_NAND10#14nmos@199_poly-right##20 NAND1_to_NAND10#14nmos@199_poly-right##21 9.898
R11746 NAND1_to_NAND10#14nmos@199_poly-right##21 NAND1_to_NAND10#14nmos@199_poly-right##22 9.898
R11747 NAND1_to_NAND10#14nmos@199_poly-right##22 NAND1_to_NAND10#14nmos@199_poly-right##23 9.898
R11748 NAND1_to_NAND10#14nmos@199_poly-right##23 NAND1_to_NAND10#14nmos@199_poly-right##24 9.898
R11749 NAND1_to_NAND10#14nmos@199_poly-right##24 NAND1_to_NAND10#14nmos@199_poly-right##25 9.898
R11750 NAND1_to_NAND10#14nmos@199_poly-right##25 NAND1_to_NAND10#14nmos@199_poly-right##26 9.898
R11751 NAND1_to_NAND10#14nmos@199_poly-right##26 NAND1_to_NAND10#14nmos@199_poly-right##27 9.898
R11752 NAND1_to_NAND10#14nmos@199_poly-right##27 NAND1_to_NAND10#14nmos@199_poly-right##28 9.898
R11753 NAND1_to_NAND10#14nmos@199_poly-right##28 NAND1_to_NAND10#14nmos@199_poly-right##29 9.898
R11754 NAND1_to_NAND10#14nmos@199_poly-right##29 NAND1_to_NAND10#14nmos@199_poly-right##30 9.898
R11755 NAND1_to_NAND10#14nmos@199_poly-right##30 NAND1_to_NAND10#14nmos@199_poly-right##31 9.898
R11756 NAND1_to_NAND10#14nmos@199_poly-right##31 NAND1_to_NAND10#14nmos@199_poly-right##32 9.898
R11757 NAND1_to_NAND10#14nmos@199_poly-right##32 NAND1_to_NAND10#14nmos@199_poly-right##33 9.898
R11758 NAND1_to_NAND10#14nmos@199_poly-right##33 NAND1_to_NAND10#14nmos@199_poly-right##34 9.898
R11759 NAND1_to_NAND10#14nmos@199_poly-right##34 NAND1_to_NAND10#14nmos@199_poly-right##35 9.898
R11760 NAND1_to_NAND10#14nmos@199_poly-right##35 NAND1_to_NAND10#14nmos@199_poly-right##36 9.898
R11761 NAND1_to_NAND10#14nmos@199_poly-right##36 NAND1_to_NAND10#14nmos@199_poly-right##37 9.898
R11762 NAND1_to_NAND10#14nmos@199_poly-right##37 NAND1_to_NAND10#14nmos@199_poly-right##38 9.898
R11763 NAND1_to_NAND10#14nmos@199_poly-right##38 NAND1_to_NAND10#14nmos@199_poly-right##39 9.898
R11764 NAND1_to_NAND10#14nmos@199_poly-right##39 NAND1_to_NAND10#14nmos@199_poly-right##40 9.898
R11765 NAND1_to_NAND10#14nmos@199_poly-right##40 NAND1_to_NAND10#14nmos@199_poly-right##41 9.898
R11766 NAND1_to_NAND10#14nmos@199_poly-right##41 NAND1_to_NAND10#14nmos@199_poly-right##42 9.898
R11767 NAND1_to_NAND10#14nmos@199_poly-right##42 NAND1_to_NAND10#14nmos@199_poly-right##43 9.898
R11768 NAND1_to_NAND10#14nmos@199_poly-right##43 NAND1_to_NAND10#14nmos@199_poly-right##44 9.898
R11769 NAND1_to_NAND10#14nmos@199_poly-right##44 NAND1_to_NAND10#14nmos@199_poly-right##45 9.898
R11770 NAND1_to_NAND10#14nmos@199_poly-right##45 NAND1_to_NAND10#14nmos@199_poly-right##46 9.898
R11771 NAND1_to_NAND10#14nmos@199_poly-right##46 NAND1_to_NAND10#14nmos@199_poly-right##47 9.898
R11772 NAND1_to_NAND10#14nmos@199_poly-right##47 NAND1_to_NAND10#14nmos@199_poly-right##48 9.898
R11773 NAND1_to_NAND10#14nmos@199_poly-right##48 NAND1_to_NAND10#14nmos@199_poly-right##49 9.898
R11774 NAND1_to_NAND10#14nmos@199_poly-right##49 NAND1_to_NAND10#14nmos@199_poly-right##50 9.898
R11775 NAND1_to_NAND10#14nmos@199_poly-right##50 NAND1_to_NAND10#14nmos@199_poly-right##51 9.898
R11776 NAND1_to_NAND10#14nmos@199_poly-right##51 NAND1_to_NAND10#14nmos@199_poly-right##52 9.898
R11777 NAND1_to_NAND10#14nmos@199_poly-right##52 NAND1_to_NAND10#14nmos@199_poly-right##53 9.898
R11778 NAND1_to_NAND10#14nmos@199_poly-right##53 NAND1_to_NAND10#14nmos@199_poly-right##54 9.898
R11779 NAND1_to_NAND10#14nmos@199_poly-right##54 NAND1_to_NAND10#14nmos@199_poly-right##55 9.898
R11780 NAND1_to_NAND10#14nmos@199_poly-right##55 NAND1_to_NAND10#11pmos@199_poly-right 9.898
R11781 Cout Cout#2nmos@199_diff-bottom 4.42
R11782 NAND2_to_Nand10 NAND2_to_Nand10#4nmos@197_diff-bottom 4.42
R11783 net@2726#17nmos@165_diff-top net@2726#47nmos@185_diff-top 8.629
R11784 net@2726 net@2726#17nmos@165_diff-top 8.629
R11785 XOR1_to_NAND6 XOR1_to_NAND6##0 6.717
R11786 XOR1_to_NAND6##0 XOR1_to_NAND6##1 6.717
R11787 XOR1_to_NAND6##1 XOR1_to_NAND6#8pin@868_polysilicon-1 6.717
R11788 A5 A5##0 9.076
C564 A5##0 0 12.518fF
R11789 A5##0 A5##1 9.076
C565 A5##1 0 12.518fF
R11790 A5##1 A5##2 9.076
C566 A5##2 0 12.518fF
R11791 A5##2 A5##3 9.076
C567 A5##3 0 12.518fF
R11792 A5##3 A5##4 9.076
C568 A5##4 0 12.518fF
R11793 A5##4 A5#1pin@878_metal-2 9.076
R11794 B5 B5##0 9.048
C569 B5##0 0 12.479fF
R11795 B5##0 B5##1 9.048
C570 B5##1 0 12.479fF
R11796 B5##1 B5##2 9.048
C571 B5##2 0 12.479fF
R11797 B5##2 B5##3 9.048
C572 B5##3 0 12.479fF
R11798 B5##3 B5##4 9.048
C573 B5##4 0 12.479fF
R11799 B5##4 B5#1pin@880_metal-2 9.048
R11800 A6 A6##0 9.418
C574 A6##0 0 13.259fF
R11801 A6##0 A6##1 9.418
C575 A6##1 0 13.259fF
R11802 A6##1 A6##2 9.418
C576 A6##2 0 13.259fF
R11803 A6##2 A6##3 9.418
C577 A6##3 0 13.259fF
R11804 A6##3 A6##4 9.418
C578 A6##4 0 13.259fF
R11805 A6##4 A6##5 9.418
C579 A6##5 0 13.259fF
R11806 A6##5 A6#1pin@961_metal-2 9.418
R11807 B6 B6##0 9.39
C580 B6##0 0 13.22fF
R11808 B6##0 B6##1 9.39
C581 B6##1 0 13.22fF
R11809 B6##1 B6##2 9.39
C582 B6##2 0 13.22fF
R11810 B6##2 B6##3 9.39
C583 B6##3 0 13.22fF
R11811 B6##3 B6##4 9.39
C584 B6##4 0 13.22fF
R11812 B6##4 B6##5 9.39
C585 B6##5 0 13.22fF
R11813 B6##5 B6#1pin@963_metal-2 9.39
R11814 A7 A7##0 9.682
C586 A7##0 0 13.847fF
R11815 A7##0 A7##1 9.682
C587 A7##1 0 13.847fF
R11816 A7##1 A7##2 9.682
C588 A7##2 0 13.847fF
R11817 A7##2 A7##3 9.682
C589 A7##3 0 13.847fF
R11818 A7##3 A7##4 9.682
C590 A7##4 0 13.847fF
R11819 A7##4 A7##5 9.682
C591 A7##5 0 13.847fF
R11820 A7##5 A7##6 9.682
C592 A7##6 0 13.847fF
R11821 A7##6 A7#1pin@1039_metal-2 9.682
R11822 B7 B7##0 9.654
C593 B7##0 0 13.808fF
R11823 B7##0 B7##1 9.654
C594 B7##1 0 13.808fF
R11824 B7##1 B7##2 9.654
C595 B7##2 0 13.808fF
R11825 B7##2 B7##3 9.654
C596 B7##3 0 13.808fF
R11826 B7##3 B7##4 9.654
C597 B7##4 0 13.808fF
R11827 B7##4 B7##5 9.654
C598 B7##5 0 13.808fF
R11828 B7##5 B7##6 9.654
C599 B7##6 0 13.808fF
R11829 B7##6 B7#1pin@1041_metal-2 9.654

* Spice Code nodes in cell cell 'Eight_bit_adder{lay}'
VDD VDD 0 DC 3.3
VGND GND 0 DC 0
vin1 A0 vdd
vin2 A1 vdd
vin3 A2 vdd
vin4 A3 0
vin5 A4 0
vin6 A5 0
vin7 A6 0
vin8 A7 0
vin9  B0 vdd
vin10 B1 vdd
vin11 B2 0
vin12 B3 vdd
vin13 B4 0
vin14 B5 vdd
vin15 B6 vdd
vin16 B7 0
vin17 Cin 0
cload out 0 250fF
.tran 0 100n
.include C:\Electric\C5_models.txt
.END
