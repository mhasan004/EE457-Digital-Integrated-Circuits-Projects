*** SPICE deck for cell Eight_bit_adder{lay} from library Proj2
*** Created on Wed Mar 18, 2020 20:18:53
*** Last revised on Wed Mar 18, 2020 23:04:32
*** Written on Wed Mar 18, 2020 23:04:35 by Electric VLSI Design System, version 9.07
*** Layout tech: mocmos, foundry MOSIS
*** UC SPICE *** , MIN_RESIST 4.0, MIN_CAPAC 0.1FF
***    P-Active:	areacap=0.9FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    N-Active:	areacap=0.9FF/um^2,	edgecap=0.0FF/um,	res=3.0ohms/sq
***    Polysilicon-1:	areacap=0.1467FF/um^2,	edgecap=0.0608FF/um,	res=6.2ohms/sq
***    Polysilicon-2:	areacap=1.0FF/um^2,	edgecap=0.0FF/um,	res=50.0ohms/sq
***    Transistor-Poly:	areacap=0.09FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    Poly-Cut:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=2.2ohms/sq
***    Active-Cut:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    Metal-1:	areacap=0.1209FF/um^2,	edgecap=0.1104FF/um,	res=0.078ohms/sq
***    Via1:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=1.0ohms/sq
***    Metal-2:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via2:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.9ohms/sq
***    Metal-3:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via3:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-4:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via4:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-5:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via5:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-6:	areacap=0.0423FF/um^2,	edgecap=0.1273FF/um,	res=0.036ohms/sq
***    Hi-Res:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=1.0ohms/sq

*** TOP LEVEL CELL: Eight_bit_adder{lay}
Mnmos@40 net@676#2contact@256_metal-1-polysilicon-1 A0#15nmos@40_poly-right net@560 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@41 net@817 net@562#11nmos@41_poly-right net@676#2contact@256_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@42 gnd B0#14nmos@42_poly-left net@817 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@43 net@560 net@684#9nmos@43_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@44 net@684#2contact@231_metal-1-metal-2 B0#9nmos@44_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@45 net@562#2pin@166_metal-1 A0#14nmos@45_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@46 XOR1_to_NAND1#1contact@309_metal-1-metal-2 net@676#4nmos@46_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@47 net@576#2contact@295_metal-1-polysilicon-1 XOR1_to_NAND1#26nmos@47_poly-right net@566 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@48 net@638 net@564#11nmos@48_poly-right net@576#2contact@295_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@49 gnd Cin#9nmos@49_poly-left net@638 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@50 net@566 net@577#9nmos@50_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@51 net@577#2contact@270_metal-1-metal-2 Cin#5nmos@51_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@52 net@564#2pin@192_metal-1 XOR1_to_NAND1#24nmos@52_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@53 Sum0 net@576#4nmos@53_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@54 net@674 XOR1_to_NAND1#27nmos@54_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@55 Cin_to_XOR2___NAND2#7nmos@55_diff-bottom Cin#16nmos@55_poly-right net@674 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@56 net@706 A0#17nmos@56_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@57 NAND2_to_Nand3#4nmos@57_diff-bottom B0#11nmos@57_poly-right net@706 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@58 net@737 NAND2_to_Nand3#11nmos@58_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@59 net@733#2nmos@59_diff-bottom Cin_to_XOR2___NAND2#17nmos@59_poly-right net@737 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@60 net@1307#2contact@491_metal-1-polysilicon-1 A1#18nmos@60_poly-right net@1207 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@61 net@1420 net@1209#11nmos@61_poly-right net@1307#2contact@491_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@62 gnd B1#17nmos@62_poly-left net@1420 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@63 net@1207 net@1314#9nmos@63_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@64 net@1314#2contact@466_metal-1-metal-2 B1#12nmos@64_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@65 net@1209#2pin@342_metal-1 A1#17nmos@65_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@66 XOR1_to_NAND2#1contact@544_metal-1-metal-2 net@1307#4nmos@66_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@67 net@1220#2contact@530_metal-1-polysilicon-1 XOR1_to_NAND2#26nmos@67_poly-right net@1212 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@68 net@1271 net@1211#11nmos@68_poly-right net@1220#2contact@530_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@69 gnd Cin_to_XOR2___NAND2#26nmos@69_poly-left net@1271 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@70 net@1212 net@1221#9nmos@70_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@71 net@1221#2contact@505_metal-1-metal-2 Cin_to_XOR2___NAND2#22nmos@71_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@72 net@1211#2pin@367_metal-1 XOR1_to_NAND2#24nmos@72_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@73 Sum1 net@1220#4nmos@73_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@74 net@1305 XOR1_to_NAND2#27nmos@74_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@75 Cin_to_XOR2___NAND3#7nmos@75_diff-bottom Cin_to_XOR2___NAND2#33nmos@75_poly-right net@1305 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@76 net@1332 A1#20nmos@76_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@77 NAND2_to_Nand4#4nmos@77_diff-bottom B1#14nmos@77_poly-right net@1332 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@78 net@1356 NAND2_to_Nand4#11nmos@78_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@79 net@1352#2nmos@79_diff-bottom Cin_to_XOR2___NAND3#17nmos@79_poly-right net@1356 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@80 net@1907#2contact@603_metal-1-polysilicon-1 A2#17nmos@80_poly-right net@1807 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@81 net@2020 net@1809#11nmos@81_poly-right net@1907#2contact@603_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@82 gnd B2#16nmos@82_poly-left net@2020 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@83 net@1807 net@1914#9nmos@83_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@84 net@1914#2contact@579_metal-1-metal-2 B2#11nmos@84_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@85 net@1809#2pin@536_metal-1 A2#16nmos@85_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@86 XOR1_to_NAND3#1contact@656_metal-1-metal-2 net@1907#4nmos@86_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@87 net@1820#2contact@642_metal-1-polysilicon-1 XOR1_to_NAND3#26nmos@87_poly-right net@1812 gnd NMOS L=0.35U W=1.75U AS=1.684P AD=0.919P PS=5.425U PD=2.8U
Mnmos@88 net@1871 net@1811#11nmos@88_poly-right net@1820#2contact@642_metal-1-polysilicon-1 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mnmos@89 gnd Cin_to_XOR2___NAND3#26nmos@89_poly-left net@1871 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=6.514P PS=2.8U PD=16.329U
Mnmos@90 net@1812 net@1821#9nmos@90_poly-left gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@91 net@1821#2contact@617_metal-1-metal-2 Cin_to_XOR2___NAND3#22nmos@91_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@92 net@1811#2pin@561_metal-1 XOR1_to_NAND3#24nmos@92_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@93 Sum2 net@1820#4nmos@93_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=1.684P PS=16.329U PD=5.425U
Mnmos@94 net@1905 XOR1_to_NAND3#27nmos@94_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@95 NAND1_to_NAND5#4nmos@95_diff-bottom Cin_to_XOR2___NAND3#33nmos@95_poly-right net@1905 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@96 net@1932 A2#19nmos@96_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@97 NAND2_to_Nand5#4nmos@97_diff-bottom B2#13nmos@97_poly-right net@1932 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mnmos@98 net@1956 NAND2_to_Nand5#11nmos@98_poly-right gnd gnd NMOS L=0.35U W=1.75U AS=6.514P AD=0.919P PS=16.329U PD=2.8U
Mnmos@99 Cout#2nmos@99_diff-bottom NAND1_to_NAND5#14nmos@99_poly-right net@1956 gnd NMOS L=0.35U W=1.75U AS=0.919P AD=1.174P PS=2.8U PD=3.675U
Mpmos@40 vdd A0#10pmos@40_poly-left net@800 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@41 net@800 net@562#7pmos@41_poly-left net@676 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@42 net@676 B0#16pmos@42_poly-right net@800 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@43 net@800 net@684#14pmos@43_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@44 vdd B0#15pmos@44_poly-right net@684 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@45 vdd A0#3pmos@45_poly-right net@562#5pmos@45_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@46 vdd net@676#12pmos@46_poly-right XOR1_to_NAND1#22pmos@46_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@47 vdd XOR1_to_NAND1#9pmos@47_poly-left net@621 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@48 net@621 net@564#7pmos@48_poly-left net@576 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@49 net@576 Cin#18pmos@49_poly-right net@621 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@50 net@621 net@577#14pmos@50_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@51 vdd Cin#17pmos@51_poly-right net@577 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@52 vdd XOR1_to_NAND1#4pmos@52_poly-right net@564#5pmos@52_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@53 vdd net@576#12pmos@53_poly-right Sum0#4pmos@53_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@54 vdd XOR1_to_NAND1#16pmos@54_poly-right Cin_to_XOR2___NAND2#1contact@534_metal-1-metal-2 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@55 Cin_to_XOR2___NAND2#1contact@534_metal-1-metal-2 Cin#20pmos@55_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@56 vdd A0#9pmos@56_poly-right NAND2_to_Nand3 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@57 NAND2_to_Nand3 B0#18pmos@57_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@58 vdd NAND2_to_Nand3#10pmos@58_poly-right net@733 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@59 net@733 Cin_to_XOR2___NAND2#14pmos@59_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@60 vdd A1#13pmos@60_poly-left net@1404 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@61 net@1404 net@1209#7pmos@61_poly-left net@1307 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@62 net@1307 B1#19pmos@62_poly-right net@1404 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@63 net@1404 net@1314#14pmos@63_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@64 vdd B1#18pmos@64_poly-right net@1314 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@65 vdd A1#5pmos@65_poly-right net@1209#5pmos@65_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@66 vdd net@1307#12pmos@66_poly-right XOR1_to_NAND2#22pmos@66_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@67 vdd XOR1_to_NAND2#9pmos@67_poly-left net@1255 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@68 net@1255 net@1211#7pmos@68_poly-left net@1220 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@69 net@1220 Cin_to_XOR2___NAND2#35pmos@69_poly-right net@1255 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@70 net@1255 net@1221#14pmos@70_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@71 vdd Cin_to_XOR2___NAND2#34pmos@71_poly-right net@1221 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@72 vdd XOR1_to_NAND2#4pmos@72_poly-right net@1211#5pmos@72_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@73 vdd net@1220#12pmos@73_poly-right Sum1#4pmos@73_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@74 vdd XOR1_to_NAND2#16pmos@74_poly-right Cin_to_XOR2___NAND3#1contact@646_metal-1-metal-2 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@75 Cin_to_XOR2___NAND3#1contact@646_metal-1-metal-2 Cin_to_XOR2___NAND2#37pmos@75_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@76 vdd A1#12pmos@76_poly-right NAND2_to_Nand4 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@77 NAND2_to_Nand4 B1#21pmos@77_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@78 vdd NAND2_to_Nand4#10pmos@78_poly-right net@1352 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@79 net@1352 Cin_to_XOR2___NAND3#14pmos@79_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@80 vdd A2#12pmos@80_poly-left net@2004 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@81 net@2004 net@1809#7pmos@81_poly-left net@1907 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@82 net@1907 B2#18pmos@82_poly-right net@2004 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@83 net@2004 net@1914#14pmos@83_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@84 vdd B2#17pmos@84_poly-right net@1914 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@85 vdd A2#4pmos@85_poly-right net@1809#5pmos@85_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@86 vdd net@1907#12pmos@86_poly-right XOR1_to_NAND3#22pmos@86_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@87 vdd XOR1_to_NAND3#9pmos@87_poly-left net@1855 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=9.934P PS=2.8U PD=15.072U
Mpmos@88 net@1855 net@1811#7pmos@88_poly-left net@1820 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@89 net@1820 Cin_to_XOR2___NAND3#35pmos@89_poly-right net@1855 vdd PMOS L=0.35U W=1.75U AS=0.919P AD=0.919P PS=2.8U PD=2.8U
Mpmos@90 net@1855 net@1821#14pmos@90_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=0.919P PS=15.072U PD=2.8U
Mpmos@91 vdd Cin_to_XOR2___NAND3#34pmos@91_poly-right net@1821 vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@92 vdd XOR1_to_NAND3#4pmos@92_poly-right net@1811#5pmos@92_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@93 vdd net@1820#12pmos@93_poly-right Sum2#4pmos@93_diff-top vdd PMOS L=0.35U W=1.75U AS=1.684P AD=9.934P PS=5.425U PD=15.072U
Mpmos@94 vdd XOR1_to_NAND3#16pmos@94_poly-right NAND1_to_NAND5 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@95 NAND1_to_NAND5 Cin_to_XOR2___NAND3#37pmos@95_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@96 vdd A2#11pmos@96_poly-right NAND2_to_Nand5 vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@97 NAND2_to_Nand5 B2#20pmos@97_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
Mpmos@98 vdd NAND2_to_Nand5#10pmos@98_poly-right Cout vdd PMOS L=0.35U W=1.75U AS=1.174P AD=9.934P PS=3.675U PD=15.072U
Mpmos@99 Cout NAND1_to_NAND5#11pmos@99_poly-right vdd vdd PMOS L=0.35U W=1.75U AS=9.934P AD=1.174P PS=15.072U PD=3.675U
** Extracted Parasitic Capacitors ***
C0 net@560 0 3.833fF
C1 net@676 0 4.502fF
C2 net@800 0 1.741fF
C3 net@676#2contact@256_metal-1-polysilicon-1 0 7.287fF
C4 net@684#2contact@231_metal-1-metal-2 0 8.905fF
C5 net@684 0 4.589fF
C6 B0 0 10.065fF
C7 A0 0 11.542fF
C8 net@562#2pin@166_metal-1 0 5.84fF
C9 net@562#5pmos@45_diff-top 0 4.602fF
C10 XOR1_to_NAND1#1contact@309_metal-1-metal-2 0 22.356fF
C11 XOR1_to_NAND1#22pmos@46_diff-top 0 4.651fF
C12 net@566 0 3.833fF
C13 net@576 0 4.452fF
C14 net@621 0 1.741fF
C15 net@576#2contact@295_metal-1-polysilicon-1 0 7.187fF
C16 net@577#2contact@270_metal-1-metal-2 0 8.905fF
C17 net@577 0 4.589fF
C18 Cin#0pin@206_metal-2 0 11.38fF
C19 net@564#2pin@192_metal-1 0 5.84fF
C20 net@564#5pmos@52_diff-top 0 4.602fF
C21 Sum0 0 12.444fF
C22 Sum0#4pmos@53_diff-top 0 4.614fF
C23 Cin 0 3.389fF
C24 Cin_to_XOR2___NAND2#1contact@534_metal-1-metal-2 0 21.539fF
C25 Cin_to_XOR2___NAND2#7nmos@55_diff-bottom 0 4.614fF
C26 XOR1_to_NAND1 0 3.919fF
C27 Cin#11contact@308_metal-1-metal-2 0 4.06fF
C28 NAND2_to_Nand3 0 6.989fF
C29 NAND2_to_Nand3#4nmos@57_diff-bottom 0 4.229fF
C30 A0#0contact@317_metal-1-metal-2 0 7.684fF
C31 B0#0contact@318_metal-1-metal-2 0 5.6fF
C32 net@733 0 6.218fF
C33 net@733#2nmos@59_diff-bottom 0 4.229fF
C34 B1 0 5.383fF
C35 B2 0 16.009fF
C36 B3 0 5.543fF
C37 B4 0 5.543fF
C38 B5 0 5.543fF
C39 B6 0 5.543fF
C40 B7 0 5.543fF
C41 A6 0 5.543fF
C42 A5 0 5.543fF
C43 A4 0 5.543fF
C44 A3 0 5.543fF
C45 A2 0 16.113fF
C46 A1 0 12.184fF
C47 net@1207 0 3.833fF
C48 net@1307 0 4.502fF
C49 net@1404 0 1.741fF
C50 net@1307#2contact@491_metal-1-polysilicon-1 0 7.287fF
C51 net@1314#2contact@466_metal-1-metal-2 0 8.905fF
C52 net@1314 0 4.589fF
C53 B1#0pin@508_metal-2 0 18.272fF
C54 A1#1pin@517_metal-2 0 18.539fF
C55 net@1209#2pin@342_metal-1 0 5.84fF
C56 net@1209#5pmos@65_diff-top 0 4.602fF
C57 XOR1_to_NAND2#1contact@544_metal-1-metal-2 0 22.356fF
C58 XOR1_to_NAND2#22pmos@66_diff-top 0 4.651fF
C59 net@1212 0 3.833fF
C60 net@1220 0 4.452fF
C61 net@1255 0 1.741fF
C62 net@1220#2contact@530_metal-1-polysilicon-1 0 7.187fF
C63 net@1221#2contact@505_metal-1-metal-2 0 8.905fF
C64 net@1221 0 4.589fF
C65 Cin_to_XOR2___NAND2 0 11.38fF
C66 net@1211#2pin@367_metal-1 0 5.84fF
C67 net@1211#5pmos@72_diff-top 0 4.602fF
C68 Sum1 0 12.047fF
C69 Sum1#4pmos@73_diff-top 0 4.614fF
C70 Cin_to_XOR2___NAND3#1contact@646_metal-1-metal-2 0 21.539fF
C71 Cin_to_XOR2___NAND3#7nmos@75_diff-bottom 0 4.614fF
C72 XOR1_to_NAND2 0 3.919fF
C73 Cin_to_XOR2___NAND2#28contact@543_metal-1-metal-2 0 4.06fF
C74 NAND2_to_Nand4 0 6.989fF
C75 NAND2_to_Nand4#4nmos@77_diff-bottom 0 4.229fF
C76 A1#2contact@552_metal-1-metal-2 0 7.684fF
C77 B1#2contact@553_metal-1-metal-2 0 5.6fF
C78 net@1352 0 6.218fF
C79 net@1352#2nmos@79_diff-bottom 0 4.229fF
C80 A7 0 5.543fF
C81 net@1807 0 3.833fF
C82 net@1907 0 4.502fF
C83 net@2004 0 1.741fF
C84 net@1907#2contact@603_metal-1-polysilicon-1 0 7.287fF
C85 net@1914#2contact@579_metal-1-metal-2 0 8.905fF
C86 net@1914 0 4.589fF
C87 B2#1pin@588_metal-2 0 21.389fF
C88 A2#1pin@586_metal-2 0 22.844fF
C89 net@1809#2pin@536_metal-1 0 5.84fF
C90 net@1809#5pmos@85_diff-top 0 4.602fF
C91 XOR1_to_NAND3#1contact@656_metal-1-metal-2 0 22.356fF
C92 XOR1_to_NAND3#22pmos@86_diff-top 0 4.651fF
C93 net@1812 0 3.833fF
C94 net@1820 0 4.452fF
C95 net@1855 0 1.741fF
C96 net@1820#2contact@642_metal-1-polysilicon-1 0 7.187fF
C97 net@1821#2contact@617_metal-1-metal-2 0 8.905fF
C98 net@1821 0 4.589fF
C99 Cin_to_XOR2___NAND3 0 11.38fF
C100 net@1811#2pin@561_metal-1 0 5.84fF
C101 net@1811#5pmos@92_diff-top 0 4.602fF
C102 Sum2 0 12.083fF
C103 Sum2#4pmos@93_diff-top 0 4.614fF
C104 NAND1_to_NAND5 0 9.146fF
C105 NAND1_to_NAND5#4nmos@95_diff-bottom 0 4.614fF
C106 XOR1_to_NAND3 0 3.919fF
C107 Cin_to_XOR2___NAND3#28contact@655_metal-1-metal-2 0 4.06fF
C108 NAND2_to_Nand5 0 6.989fF
C109 NAND2_to_Nand5#4nmos@97_diff-bottom 0 4.229fF
C110 A2#0contact@664_metal-1-metal-2 0 7.684fF
C111 B2#0contact@665_metal-1-metal-2 0 5.6fF
C112 Cout 0 6.218fF
C113 Cout#2nmos@99_diff-bottom 0 4.229fF
C114 B0#14nmos@42_poly-left 0 0.135fF
C115 net@684#9nmos@43_poly-left 0 0.178fF
C116 Cin#9nmos@49_poly-left 0 0.135fF
C117 net@577#9nmos@50_poly-left 0 0.178fF
C118 B1#17nmos@62_poly-left 0 0.135fF
C119 net@1314#9nmos@63_poly-left 0 0.178fF
C120 Cin_to_XOR2___NAND2#26nmos@69_poly-left 0 0.135fF
C121 net@1221#9nmos@70_poly-left 0 0.178fF
C122 B2#16nmos@82_poly-left 0 0.135fF
C123 net@1914#9nmos@83_poly-left 0 0.178fF
C124 Cin_to_XOR2___NAND3#26nmos@89_poly-left 0 0.135fF
C125 net@1821#9nmos@90_poly-left 0 0.178fF
C126 net@562 0 0.143fF
C127 B0#12pin@157_polysilicon-1 0 0.132fF
C128 A0#11pin@164_polysilicon-1 0 0.12fF
C129 A0#13pin@165_polysilicon-1 0 0.106fF
C130 B0#10pin@167_polysilicon-1 0 0.203fF
C131 net@676#5pin@169_polysilicon-1 0 0.221fF
C132 B0#13pin@174_polysilicon-1 0 0.175fF
C133 net@562#1pin@176_polysilicon-1 0 0.187fF
C134 A0#2pin@177_polysilicon-1 0 0.199fF
C135 net@564 0 0.143fF
C136 Cin#7pin@183_polysilicon-1 0 0.132fF
C137 XOR1_to_NAND1#10pin@190_polysilicon-1 0 0.12fF
C138 XOR1_to_NAND1#12pin@191_polysilicon-1 0 0.106fF
C139 Cin#6pin@193_polysilicon-1 0 0.203fF
C140 net@576#5pin@195_polysilicon-1 0 0.236fF
C141 Cin#8pin@200_polysilicon-1 0 0.175fF
C142 net@564#1pin@202_polysilicon-1 0 0.187fF
C143 XOR1_to_NAND1#3pin@203_polysilicon-1 0 0.199fF
C144 XOR1_to_NAND1#14pin@207_polysilicon-1 0 0.184fF
C145 Cin#14pin@212_polysilicon-1 0 0.244fF
C146 A0#8pin@215_polysilicon-1 0 0.224fF
C147 B0#8pin@220_polysilicon-1 0 0.237fF
C148 NAND2_to_Nand3#9pin@224_polysilicon-1 0 0.224fF
C149 Cin_to_XOR2___NAND2#15pin@229_polysilicon-1 0 0.103fF
C150 net@1209 0 0.143fF
C151 B1#15pin@333_polysilicon-1 0 0.132fF
C152 A1#14pin@340_polysilicon-1 0 0.12fF
C153 A1#16pin@341_polysilicon-1 0 0.106fF
C154 B1#13pin@343_polysilicon-1 0 0.203fF
C155 net@1307#5pin@345_polysilicon-1 0 0.221fF
C156 B1#16pin@350_polysilicon-1 0 0.175fF
C157 net@1209#1pin@352_polysilicon-1 0 0.187fF
C158 A1#4pin@353_polysilicon-1 0 0.199fF
C159 net@1211 0 0.143fF
C160 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1 0 0.132fF
C161 XOR1_to_NAND2#10pin@365_polysilicon-1 0 0.12fF
C162 XOR1_to_NAND2#12pin@366_polysilicon-1 0 0.106fF
C163 Cin_to_XOR2___NAND2#23pin@368_polysilicon-1 0 0.203fF
C164 net@1220#5pin@370_polysilicon-1 0 0.236fF
C165 Cin_to_XOR2___NAND2#25pin@375_polysilicon-1 0 0.175fF
C166 net@1211#1pin@377_polysilicon-1 0 0.187fF
C167 XOR1_to_NAND2#3pin@378_polysilicon-1 0 0.199fF
C168 XOR1_to_NAND2#14pin@382_polysilicon-1 0 0.184fF
C169 Cin_to_XOR2___NAND2#31pin@386_polysilicon-1 0 0.244fF
C170 A1#11pin@389_polysilicon-1 0 0.224fF
C171 B1#11pin@393_polysilicon-1 0 0.237fF
C172 NAND2_to_Nand4#9pin@395_polysilicon-1 0 0.224fF
C173 Cin_to_XOR2___NAND3#15pin@399_polysilicon-1 0 0.103fF
C174 net@1809 0 0.143fF
C175 B2#14pin@527_polysilicon-1 0 0.132fF
C176 A2#13pin@534_polysilicon-1 0 0.12fF
C177 A2#15pin@535_polysilicon-1 0 0.106fF
C178 B2#12pin@537_polysilicon-1 0 0.203fF
C179 net@1907#5pin@539_polysilicon-1 0 0.221fF
C180 B2#15pin@544_polysilicon-1 0 0.175fF
C181 net@1809#1pin@546_polysilicon-1 0 0.187fF
C182 A2#3pin@547_polysilicon-1 0 0.199fF
C183 net@1811 0 0.143fF
C184 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1 0 0.132fF
C185 XOR1_to_NAND3#10pin@559_polysilicon-1 0 0.12fF
C186 XOR1_to_NAND3#12pin@560_polysilicon-1 0 0.106fF
C187 Cin_to_XOR2___NAND3#23pin@562_polysilicon-1 0 0.203fF
C188 net@1820#5pin@564_polysilicon-1 0 0.236fF
C189 Cin_to_XOR2___NAND3#25pin@569_polysilicon-1 0 0.175fF
C190 net@1811#1pin@571_polysilicon-1 0 0.187fF
C191 XOR1_to_NAND3#3pin@572_polysilicon-1 0 0.199fF
C192 XOR1_to_NAND3#14pin@576_polysilicon-1 0 0.184fF
C193 Cin_to_XOR2___NAND3#31pin@580_polysilicon-1 0 0.244fF
C194 A2#10pin@583_polysilicon-1 0 0.224fF
C195 B2#10pin@587_polysilicon-1 0 0.237fF
C196 NAND2_to_Nand5#9pin@589_polysilicon-1 0 0.224fF
C197 NAND1_to_NAND5#12pin@593_polysilicon-1 0 0.103fF
C198 A0#10pmos@40_poly-left 0 0.158fF
C199 net@562#7pmos@41_poly-left 0 0.145fF
C200 XOR1_to_NAND1#9pmos@47_poly-left 0 0.158fF
C201 net@564#7pmos@48_poly-left 0 0.145fF
C202 Cin_to_XOR2___NAND2#14pmos@59_poly-right 0 0.13fF
C203 A1#13pmos@60_poly-left 0 0.158fF
C204 net@1209#7pmos@61_poly-left 0 0.145fF
C205 XOR1_to_NAND2#9pmos@67_poly-left 0 0.158fF
C206 net@1211#7pmos@68_poly-left 0 0.145fF
C207 Cin_to_XOR2___NAND3#14pmos@79_poly-right 0 0.13fF
C208 A2#12pmos@80_poly-left 0 0.158fF
C209 net@1809#7pmos@81_poly-left 0 0.145fF
C210 XOR1_to_NAND3#9pmos@87_poly-left 0 0.158fF
C211 net@1811#7pmos@88_poly-left 0 0.145fF
C212 NAND1_to_NAND5#11pmos@99_poly-right 0 0.13fF
** Extracted Parasitic Resistors ***
R0 A1 A1#1pin@517_metal-2 8.255
R1 A0#0contact@317_metal-1-metal-2 A0 9.49
R2 A1#2contact@552_metal-1-metal-2 A1#1pin@517_metal-2 9.49
R3 A2#0contact@664_metal-1-metal-2 A2#1pin@586_metal-2 9.49
R4 B0#0contact@318_metal-1-metal-2 B0#0contact@318_metal-1-metal-2##0 5.161
C213 B0#0contact@318_metal-1-metal-2##0 0 5.536fF
R5 B0#0contact@318_metal-1-metal-2##0 B0 5.161
R6 B1#2contact@553_metal-1-metal-2 B1#2contact@553_metal-1-metal-2##0 5.161
C214 B1#2contact@553_metal-1-metal-2##0 0 5.536fF
R7 B1#2contact@553_metal-1-metal-2##0 B1#0pin@508_metal-2 5.161
R8 B2#0contact@665_metal-1-metal-2 B2#0contact@665_metal-1-metal-2##0 5.161
C215 B2#0contact@665_metal-1-metal-2##0 0 5.536fF
R9 B2#0contact@665_metal-1-metal-2##0 B2#1pin@588_metal-2 5.161
R10 Cin#0pin@206_metal-2 Cin 4.212
R11 Cin_to_XOR2___NAND2 Cin_to_XOR2___NAND2#1contact@534_metal-1-metal-2 4.212
R12 Cin_to_XOR2___NAND3 Cin_to_XOR2___NAND3#1contact@646_metal-1-metal-2 4.212
R13 XOR1_to_NAND1 XOR1_to_NAND1#1contact@309_metal-1-metal-2 4.42
R14 XOR1_to_NAND2 XOR1_to_NAND2#1contact@544_metal-1-metal-2 4.42
R15 XOR1_to_NAND3 XOR1_to_NAND3#1contact@656_metal-1-metal-2 4.42
R16 net@562 net@562##0 9.92
R17 net@562##0 net@562##1 9.92
R18 net@562##1 net@562##2 9.92
R19 net@562##2 net@562##3 9.92
R20 net@562##3 net@562##4 9.92
R21 net@562##4 net@562##5 9.92
R22 net@562##5 net@562##6 9.92
R23 net@562##6 net@562##7 9.92
R24 net@562##7 net@562##8 9.92
R25 net@562##8 net@562##9 9.92
R26 net@562##9 net@562##10 9.92
R27 net@562##10 net@562##11 9.92
R28 net@562##11 net@562##12 9.92
R29 net@562##12 net@562##13 9.92
R30 net@562##13 net@562##14 9.92
R31 net@562##14 net@562##15 9.92
R32 net@562##15 net@562##16 9.92
R33 net@562##16 net@562##17 9.92
R34 net@562##17 net@562##18 9.92
R35 net@562##18 net@562#1pin@176_polysilicon-1 9.92
R36 net@564 net@564##0 9.92
R37 net@564##0 net@564##1 9.92
R38 net@564##1 net@564##2 9.92
R39 net@564##2 net@564##3 9.92
R40 net@564##3 net@564##4 9.92
R41 net@564##4 net@564##5 9.92
R42 net@564##5 net@564##6 9.92
R43 net@564##6 net@564##7 9.92
R44 net@564##7 net@564##8 9.92
R45 net@564##8 net@564##9 9.92
R46 net@564##9 net@564##10 9.92
R47 net@564##10 net@564##11 9.92
R48 net@564##11 net@564##12 9.92
R49 net@564##12 net@564##13 9.92
R50 net@564##13 net@564##14 9.92
R51 net@564##14 net@564##15 9.92
R52 net@564##15 net@564##16 9.92
R53 net@564##16 net@564##17 9.92
R54 net@564##17 net@564##18 9.92
R55 net@564##18 net@564#1pin@202_polysilicon-1 9.92
R56 XOR1_to_NAND1#3pin@203_polysilicon-1 XOR1_to_NAND1#3pin@203_polysilicon-1##0 6.2
R57 XOR1_to_NAND1#3pin@203_polysilicon-1##0 XOR1_to_NAND1#4pmos@52_poly-right 6.2
R58 XOR1_to_NAND1#3pin@203_polysilicon-1 XOR1_to_NAND1#3pin@203_polysilicon-1##0 8.138
R59 XOR1_to_NAND1#3pin@203_polysilicon-1##0 XOR1_to_NAND1#3pin@203_polysilicon-1##1 8.138
R60 XOR1_to_NAND1#3pin@203_polysilicon-1##1 XOR1_to_NAND1#3pin@203_polysilicon-1##2 8.138
R61 XOR1_to_NAND1#3pin@203_polysilicon-1##2 XOR1_to_NAND1#1contact@309_metal-1-metal-2 8.138
R62 Cin#5nmos@51_poly-right Cin#5nmos@51_poly-right##0 5.425
R63 Cin#5nmos@51_poly-right##0 Cin#6pin@193_polysilicon-1 5.425
R64 Cin#0pin@206_metal-2 Cin#0pin@206_metal-2##0 8.99
R65 Cin#0pin@206_metal-2##0 Cin#0pin@206_metal-2##1 8.99
R66 Cin#0pin@206_metal-2##1 Cin#0pin@206_metal-2##2 8.99
R67 Cin#0pin@206_metal-2##2 Cin#0pin@206_metal-2##3 8.99
R68 Cin#0pin@206_metal-2##3 Cin#6pin@193_polysilicon-1 8.99
R69 A0#2pin@177_polysilicon-1 A0#2pin@177_polysilicon-1##0 6.2
R70 A0#2pin@177_polysilicon-1##0 A0#3pmos@45_poly-right 6.2
R71 XOR1_to_NAND1#9pmos@47_poly-left XOR1_to_NAND1#9pmos@47_poly-left##0 8.138
R72 XOR1_to_NAND1#9pmos@47_poly-left##0 XOR1_to_NAND1#9pmos@47_poly-left##1 8.138
R73 XOR1_to_NAND1#9pmos@47_poly-left##1 XOR1_to_NAND1#9pmos@47_poly-left##2 8.138
R74 XOR1_to_NAND1#9pmos@47_poly-left##2 XOR1_to_NAND1#10pin@190_polysilicon-1 8.138
R75 Cin#7pin@183_polysilicon-1 Cin#7pin@183_polysilicon-1##0 9.843
R76 Cin#7pin@183_polysilicon-1##0 Cin#7pin@183_polysilicon-1##1 9.843
R77 Cin#7pin@183_polysilicon-1##1 Cin#7pin@183_polysilicon-1##2 9.843
R78 Cin#7pin@183_polysilicon-1##2 Cin#7pin@183_polysilicon-1##3 9.843
R79 Cin#7pin@183_polysilicon-1##3 Cin#7pin@183_polysilicon-1##4 9.843
R80 Cin#7pin@183_polysilicon-1##4 Cin#7pin@183_polysilicon-1##5 9.843
R81 Cin#7pin@183_polysilicon-1##5 Cin#7pin@183_polysilicon-1##6 9.843
R82 Cin#7pin@183_polysilicon-1##6 Cin#7pin@183_polysilicon-1##7 9.843
R83 Cin#7pin@183_polysilicon-1##7 Cin#7pin@183_polysilicon-1##8 9.843
R84 Cin#7pin@183_polysilicon-1##8 Cin#7pin@183_polysilicon-1##9 9.843
R85 Cin#7pin@183_polysilicon-1##9 Cin#7pin@183_polysilicon-1##10 9.843
R86 Cin#7pin@183_polysilicon-1##10 Cin#7pin@183_polysilicon-1##11 9.843
R87 Cin#7pin@183_polysilicon-1##11 Cin#7pin@183_polysilicon-1##12 9.843
R88 Cin#7pin@183_polysilicon-1##12 Cin#7pin@183_polysilicon-1##13 9.843
R89 Cin#7pin@183_polysilicon-1##13 Cin#7pin@183_polysilicon-1##14 9.843
R90 Cin#7pin@183_polysilicon-1##14 Cin#7pin@183_polysilicon-1##15 9.843
R91 Cin#7pin@183_polysilicon-1##15 Cin#7pin@183_polysilicon-1##16 9.843
R92 Cin#7pin@183_polysilicon-1##16 Cin#7pin@183_polysilicon-1##17 9.843
R93 Cin#7pin@183_polysilicon-1##17 Cin#7pin@183_polysilicon-1##18 9.843
R94 Cin#7pin@183_polysilicon-1##18 Cin#8pin@200_polysilicon-1 9.843
R95 net@576#4nmos@53_poly-right net@576#4nmos@53_poly-right##0 9.3
R96 net@576#4nmos@53_poly-right##0 net@576#4nmos@53_poly-right##1 9.3
R97 net@576#4nmos@53_poly-right##1 net@576#5pin@195_polysilicon-1 9.3
R98 net@576#2contact@295_metal-1-polysilicon-1 net@576#2contact@295_metal-1-polysilicon-1##0 8.99
R99 net@576#2contact@295_metal-1-polysilicon-1##0 net@576#2contact@295_metal-1-polysilicon-1##1 8.99
R100 net@576#2contact@295_metal-1-polysilicon-1##1 net@576#2contact@295_metal-1-polysilicon-1##2 8.99
R101 net@576#2contact@295_metal-1-polysilicon-1##2 net@576#2contact@295_metal-1-polysilicon-1##3 8.99
R102 net@576#2contact@295_metal-1-polysilicon-1##3 net@576#5pin@195_polysilicon-1 8.99
R103 A0#2pin@177_polysilicon-1 A0#2pin@177_polysilicon-1##0 8.138
R104 A0#2pin@177_polysilicon-1##0 A0#2pin@177_polysilicon-1##1 8.138
R105 A0#2pin@177_polysilicon-1##1 A0#2pin@177_polysilicon-1##2 8.138
R106 A0#2pin@177_polysilicon-1##2 A0 8.138
R107 XOR1_to_NAND1#1contact@309_metal-1-metal-2 XOR1_to_NAND1#1contact@309_metal-1-metal-2##0 6.717
R108 XOR1_to_NAND1#1contact@309_metal-1-metal-2##0 XOR1_to_NAND1#1contact@309_metal-1-metal-2##1 6.717
R109 XOR1_to_NAND1#1contact@309_metal-1-metal-2##1 XOR1_to_NAND1#12pin@191_polysilicon-1 6.717
R110 XOR1_to_NAND1#10pin@190_polysilicon-1 XOR1_to_NAND1#10pin@190_polysilicon-1##0 7.75
R111 XOR1_to_NAND1#10pin@190_polysilicon-1##0 XOR1_to_NAND1#10pin@190_polysilicon-1##1 7.75
R112 XOR1_to_NAND1#10pin@190_polysilicon-1##1 XOR1_to_NAND1#12pin@191_polysilicon-1 7.75
R113 Cin#8pin@200_polysilicon-1 Cin#8pin@200_polysilicon-1##0 9.743
R114 Cin#8pin@200_polysilicon-1##0 Cin#8pin@200_polysilicon-1##1 9.743
R115 Cin#8pin@200_polysilicon-1##1 Cin#8pin@200_polysilicon-1##2 9.743
R116 Cin#8pin@200_polysilicon-1##2 Cin#8pin@200_polysilicon-1##3 9.743
R117 Cin#8pin@200_polysilicon-1##3 Cin#8pin@200_polysilicon-1##4 9.743
R118 Cin#8pin@200_polysilicon-1##4 Cin#8pin@200_polysilicon-1##5 9.743
R119 Cin#8pin@200_polysilicon-1##5 Cin#0pin@206_metal-2 9.743
R120 net@564#7pmos@48_poly-left net@564#7pmos@48_poly-left##0 7.75
R121 net@564#7pmos@48_poly-left##0 net@564 7.75
R122 Cin#9nmos@49_poly-left Cin#9nmos@49_poly-left##0 6.2
R123 Cin#9nmos@49_poly-left##0 Cin#7pin@183_polysilicon-1 6.2
R124 net@577#9nmos@50_poly-left net@577#9nmos@50_poly-left##0 8.37
R125 net@577#9nmos@50_poly-left##0 net@577#9nmos@50_poly-left##1 8.37
R126 net@577#9nmos@50_poly-left##1 net@577#9nmos@50_poly-left##2 8.37
R127 net@577#9nmos@50_poly-left##2 net@577#9nmos@50_poly-left##3 8.37
R128 net@577#9nmos@50_poly-left##3 net@577#2contact@270_metal-1-metal-2 8.37
R129 XOR1_to_NAND1 XOR1_to_NAND1##0 6.717
R130 XOR1_to_NAND1##0 XOR1_to_NAND1##1 6.717
R131 XOR1_to_NAND1##1 XOR1_to_NAND1#14pin@207_polysilicon-1 6.717
R132 XOR1_to_NAND1#16pmos@54_poly-right XOR1_to_NAND1#16pmos@54_poly-right##0 6.2
R133 XOR1_to_NAND1#16pmos@54_poly-right##0 XOR1_to_NAND1#14pin@207_polysilicon-1 6.2
R134 Cin#14pin@212_polysilicon-1 Cin#14pin@212_polysilicon-1##0 9.688
R135 Cin#14pin@212_polysilicon-1##0 Cin#14pin@212_polysilicon-1##1 9.688
R136 Cin#14pin@212_polysilicon-1##1 Cin#14pin@212_polysilicon-1##2 9.688
R137 Cin#14pin@212_polysilicon-1##2 Cin#11contact@308_metal-1-metal-2 9.688
R138 Cin#11contact@308_metal-1-metal-2 Cin#0pin@206_metal-2 4.953
R139 A0#0contact@317_metal-1-metal-2 A0#0contact@317_metal-1-metal-2##0 6.717
R140 A0#0contact@317_metal-1-metal-2##0 A0#0contact@317_metal-1-metal-2##1 6.717
R141 A0#0contact@317_metal-1-metal-2##1 A0#8pin@215_polysilicon-1 6.717
R142 A0#9pmos@56_poly-right A0#9pmos@56_poly-right##0 9.558
R143 A0#9pmos@56_poly-right##0 A0#9pmos@56_poly-right##1 9.558
R144 A0#9pmos@56_poly-right##1 A0#9pmos@56_poly-right##2 9.558
R145 A0#9pmos@56_poly-right##2 A0#9pmos@56_poly-right##3 9.558
R146 A0#9pmos@56_poly-right##3 A0#9pmos@56_poly-right##4 9.558
R147 A0#9pmos@56_poly-right##4 A0#8pin@215_polysilicon-1 9.558
R148 B0#8pin@220_polysilicon-1 B0#8pin@220_polysilicon-1##0 8.138
R149 B0#8pin@220_polysilicon-1##0 B0#8pin@220_polysilicon-1##1 8.138
R150 B0#8pin@220_polysilicon-1##1 B0#8pin@220_polysilicon-1##2 8.138
R151 B0#8pin@220_polysilicon-1##2 B0#0contact@318_metal-1-metal-2 8.138
R152 B0#9nmos@44_poly-right B0#9nmos@44_poly-right##0 5.425
R153 B0#9nmos@44_poly-right##0 B0#10pin@167_polysilicon-1 5.425
R154 NAND2_to_Nand3 NAND2_to_Nand3##0 6.717
R155 NAND2_to_Nand3##0 NAND2_to_Nand3##1 6.717
R156 NAND2_to_Nand3##1 NAND2_to_Nand3#9pin@224_polysilicon-1 6.717
R157 NAND2_to_Nand3#10pmos@58_poly-right NAND2_to_Nand3#10pmos@58_poly-right##0 9.558
R158 NAND2_to_Nand3#10pmos@58_poly-right##0 NAND2_to_Nand3#10pmos@58_poly-right##1 9.558
R159 NAND2_to_Nand3#10pmos@58_poly-right##1 NAND2_to_Nand3#10pmos@58_poly-right##2 9.558
R160 NAND2_to_Nand3#10pmos@58_poly-right##2 NAND2_to_Nand3#10pmos@58_poly-right##3 9.558
R161 NAND2_to_Nand3#10pmos@58_poly-right##3 NAND2_to_Nand3#10pmos@58_poly-right##4 9.558
R162 NAND2_to_Nand3#10pmos@58_poly-right##4 NAND2_to_Nand3#9pin@224_polysilicon-1 9.558
R163 B0 B0##0 8.99
R164 B0##0 B0##1 8.99
R165 B0##1 B0##2 8.99
R166 B0##2 B0##3 8.99
R167 B0##3 B0#10pin@167_polysilicon-1 8.99
R168 Cin_to_XOR2___NAND2#14pmos@59_poly-right Cin_to_XOR2___NAND2#14pmos@59_poly-right##0 5.425
R169 Cin_to_XOR2___NAND2#14pmos@59_poly-right##0 Cin_to_XOR2___NAND2#15pin@229_polysilicon-1 5.425
R170 Cin_to_XOR2___NAND2#15pin@229_polysilicon-1 Cin_to_XOR2___NAND2#15pin@229_polysilicon-1##0 9.3
R171 Cin_to_XOR2___NAND2#15pin@229_polysilicon-1##0 Cin_to_XOR2___NAND2#15pin@229_polysilicon-1##1 9.3
R172 Cin_to_XOR2___NAND2#15pin@229_polysilicon-1##1 Cin_to_XOR2___NAND2#1contact@534_metal-1-metal-2 9.3
R173 Cin#16nmos@55_poly-right Cin#16nmos@55_poly-right##0 8.636
R174 Cin#16nmos@55_poly-right##0 Cin#16nmos@55_poly-right##1 8.636
R175 Cin#16nmos@55_poly-right##1 Cin#16nmos@55_poly-right##2 8.636
R176 Cin#16nmos@55_poly-right##2 Cin#16nmos@55_poly-right##3 8.636
R177 Cin#16nmos@55_poly-right##3 Cin#16nmos@55_poly-right##4 8.636
R178 Cin#16nmos@55_poly-right##4 Cin#16nmos@55_poly-right##5 8.636
R179 Cin#16nmos@55_poly-right##5 Cin#14pin@212_polysilicon-1 8.636
R180 B0#11nmos@57_poly-right B0#11nmos@57_poly-right##0 8.956
R181 B0#11nmos@57_poly-right##0 B0#11nmos@57_poly-right##1 8.956
R182 B0#11nmos@57_poly-right##1 B0#11nmos@57_poly-right##2 8.956
R183 B0#11nmos@57_poly-right##2 B0#11nmos@57_poly-right##3 8.956
R184 B0#11nmos@57_poly-right##3 B0#11nmos@57_poly-right##4 8.956
R185 B0#11nmos@57_poly-right##4 B0#11nmos@57_poly-right##5 8.956
R186 B0#11nmos@57_poly-right##5 B0#11nmos@57_poly-right##6 8.956
R187 B0#11nmos@57_poly-right##6 B0#11nmos@57_poly-right##7 8.956
R188 B0#11nmos@57_poly-right##7 B0#8pin@220_polysilicon-1 8.956
R189 A0#10pmos@40_poly-left A0#10pmos@40_poly-left##0 8.138
R190 A0#10pmos@40_poly-left##0 A0#10pmos@40_poly-left##1 8.138
R191 A0#10pmos@40_poly-left##1 A0#10pmos@40_poly-left##2 8.138
R192 A0#10pmos@40_poly-left##2 A0#11pin@164_polysilicon-1 8.138
R193 B0#12pin@157_polysilicon-1 B0#12pin@157_polysilicon-1##0 9.843
R194 B0#12pin@157_polysilicon-1##0 B0#12pin@157_polysilicon-1##1 9.843
R195 B0#12pin@157_polysilicon-1##1 B0#12pin@157_polysilicon-1##2 9.843
R196 B0#12pin@157_polysilicon-1##2 B0#12pin@157_polysilicon-1##3 9.843
R197 B0#12pin@157_polysilicon-1##3 B0#12pin@157_polysilicon-1##4 9.843
R198 B0#12pin@157_polysilicon-1##4 B0#12pin@157_polysilicon-1##5 9.843
R199 B0#12pin@157_polysilicon-1##5 B0#12pin@157_polysilicon-1##6 9.843
R200 B0#12pin@157_polysilicon-1##6 B0#12pin@157_polysilicon-1##7 9.843
R201 B0#12pin@157_polysilicon-1##7 B0#12pin@157_polysilicon-1##8 9.843
R202 B0#12pin@157_polysilicon-1##8 B0#12pin@157_polysilicon-1##9 9.843
R203 B0#12pin@157_polysilicon-1##9 B0#12pin@157_polysilicon-1##10 9.843
R204 B0#12pin@157_polysilicon-1##10 B0#12pin@157_polysilicon-1##11 9.843
R205 B0#12pin@157_polysilicon-1##11 B0#12pin@157_polysilicon-1##12 9.843
R206 B0#12pin@157_polysilicon-1##12 B0#12pin@157_polysilicon-1##13 9.843
R207 B0#12pin@157_polysilicon-1##13 B0#12pin@157_polysilicon-1##14 9.843
R208 B0#12pin@157_polysilicon-1##14 B0#12pin@157_polysilicon-1##15 9.843
R209 B0#12pin@157_polysilicon-1##15 B0#12pin@157_polysilicon-1##16 9.843
R210 B0#12pin@157_polysilicon-1##16 B0#12pin@157_polysilicon-1##17 9.843
R211 B0#12pin@157_polysilicon-1##17 B0#12pin@157_polysilicon-1##18 9.843
R212 B0#12pin@157_polysilicon-1##18 B0#13pin@174_polysilicon-1 9.843
R213 net@676#4nmos@46_poly-right net@676#4nmos@46_poly-right##0 7.233
R214 net@676#4nmos@46_poly-right##0 net@676#4nmos@46_poly-right##1 7.233
R215 net@676#4nmos@46_poly-right##1 net@676#5pin@169_polysilicon-1 7.233
R216 net@676#2contact@256_metal-1-polysilicon-1 net@676#2contact@256_metal-1-polysilicon-1##0 8.99
R217 net@676#2contact@256_metal-1-polysilicon-1##0 net@676#2contact@256_metal-1-polysilicon-1##1 8.99
R218 net@676#2contact@256_metal-1-polysilicon-1##1 net@676#2contact@256_metal-1-polysilicon-1##2 8.99
R219 net@676#2contact@256_metal-1-polysilicon-1##2 net@676#2contact@256_metal-1-polysilicon-1##3 8.99
R220 net@676#2contact@256_metal-1-polysilicon-1##3 net@676#5pin@169_polysilicon-1 8.99
R221 A0 A0##0 6.717
R222 A0##0 A0##1 6.717
R223 A0##1 A0#13pin@165_polysilicon-1 6.717
R224 A0#11pin@164_polysilicon-1 A0#11pin@164_polysilicon-1##0 7.75
R225 A0#11pin@164_polysilicon-1##0 A0#11pin@164_polysilicon-1##1 7.75
R226 A0#11pin@164_polysilicon-1##1 A0#13pin@165_polysilicon-1 7.75
R227 B0#13pin@174_polysilicon-1 B0#13pin@174_polysilicon-1##0 9.743
R228 B0#13pin@174_polysilicon-1##0 B0#13pin@174_polysilicon-1##1 9.743
R229 B0#13pin@174_polysilicon-1##1 B0#13pin@174_polysilicon-1##2 9.743
R230 B0#13pin@174_polysilicon-1##2 B0#13pin@174_polysilicon-1##3 9.743
R231 B0#13pin@174_polysilicon-1##3 B0#13pin@174_polysilicon-1##4 9.743
R232 B0#13pin@174_polysilicon-1##4 B0#13pin@174_polysilicon-1##5 9.743
R233 B0#13pin@174_polysilicon-1##5 B0 9.743
R234 net@562#7pmos@41_poly-left net@562#7pmos@41_poly-left##0 7.75
R235 net@562#7pmos@41_poly-left##0 net@562 7.75
R236 B0#14nmos@42_poly-left B0#14nmos@42_poly-left##0 6.2
R237 B0#14nmos@42_poly-left##0 B0#12pin@157_polysilicon-1 6.2
R238 net@684#9nmos@43_poly-left net@684#9nmos@43_poly-left##0 8.37
R239 net@684#9nmos@43_poly-left##0 net@684#9nmos@43_poly-left##1 8.37
R240 net@684#9nmos@43_poly-left##1 net@684#9nmos@43_poly-left##2 8.37
R241 net@684#9nmos@43_poly-left##2 net@684#9nmos@43_poly-left##3 8.37
R242 net@684#9nmos@43_poly-left##3 net@684#2contact@231_metal-1-metal-2 8.37
R243 A0#2pin@177_polysilicon-1 A0#2pin@177_polysilicon-1##0 9.881
R244 A0#2pin@177_polysilicon-1##0 A0#2pin@177_polysilicon-1##1 9.881
R245 A0#2pin@177_polysilicon-1##1 A0#2pin@177_polysilicon-1##2 9.881
R246 A0#2pin@177_polysilicon-1##2 A0#2pin@177_polysilicon-1##3 9.881
R247 A0#2pin@177_polysilicon-1##3 A0#2pin@177_polysilicon-1##4 9.881
R248 A0#2pin@177_polysilicon-1##4 A0#2pin@177_polysilicon-1##5 9.881
R249 A0#2pin@177_polysilicon-1##5 A0#2pin@177_polysilicon-1##6 9.881
R250 A0#2pin@177_polysilicon-1##6 A0#2pin@177_polysilicon-1##7 9.881
R251 A0#2pin@177_polysilicon-1##7 A0#2pin@177_polysilicon-1##8 9.881
R252 A0#2pin@177_polysilicon-1##8 A0#2pin@177_polysilicon-1##9 9.881
R253 A0#2pin@177_polysilicon-1##9 A0#2pin@177_polysilicon-1##10 9.881
R254 A0#2pin@177_polysilicon-1##10 A0#2pin@177_polysilicon-1##11 9.881
R255 A0#2pin@177_polysilicon-1##11 A0#2pin@177_polysilicon-1##12 9.881
R256 A0#2pin@177_polysilicon-1##12 A0#2pin@177_polysilicon-1##13 9.881
R257 A0#2pin@177_polysilicon-1##13 A0#2pin@177_polysilicon-1##14 9.881
R258 A0#2pin@177_polysilicon-1##14 A0#2pin@177_polysilicon-1##15 9.881
R259 A0#2pin@177_polysilicon-1##15 A0#2pin@177_polysilicon-1##16 9.881
R260 A0#2pin@177_polysilicon-1##16 A0#2pin@177_polysilicon-1##17 9.881
R261 A0#2pin@177_polysilicon-1##17 A0#2pin@177_polysilicon-1##18 9.881
R262 A0#2pin@177_polysilicon-1##18 A0#2pin@177_polysilicon-1##19 9.881
R263 A0#2pin@177_polysilicon-1##19 A0#2pin@177_polysilicon-1##20 9.881
R264 A0#2pin@177_polysilicon-1##20 A0#2pin@177_polysilicon-1##21 9.881
R265 A0#2pin@177_polysilicon-1##21 A0#2pin@177_polysilicon-1##22 9.881
R266 A0#2pin@177_polysilicon-1##22 A0#2pin@177_polysilicon-1##23 9.881
R267 A0#2pin@177_polysilicon-1##23 A0#2pin@177_polysilicon-1##24 9.881
R268 A0#2pin@177_polysilicon-1##24 A0#2pin@177_polysilicon-1##25 9.881
R269 A0#2pin@177_polysilicon-1##25 A0#2pin@177_polysilicon-1##26 9.881
R270 A0#2pin@177_polysilicon-1##26 A0#2pin@177_polysilicon-1##27 9.881
R271 A0#2pin@177_polysilicon-1##27 A0#2pin@177_polysilicon-1##28 9.881
R272 A0#2pin@177_polysilicon-1##28 A0#2pin@177_polysilicon-1##29 9.881
R273 A0#2pin@177_polysilicon-1##29 A0#2pin@177_polysilicon-1##30 9.881
R274 A0#2pin@177_polysilicon-1##30 A0#2pin@177_polysilicon-1##31 9.881
R275 A0#2pin@177_polysilicon-1##31 A0#2pin@177_polysilicon-1##32 9.881
R276 A0#2pin@177_polysilicon-1##32 A0#2pin@177_polysilicon-1##33 9.881
R277 A0#2pin@177_polysilicon-1##33 A0#2pin@177_polysilicon-1##34 9.881
R278 A0#2pin@177_polysilicon-1##34 A0#2pin@177_polysilicon-1##35 9.881
R279 A0#2pin@177_polysilicon-1##35 A0#2pin@177_polysilicon-1##36 9.881
R280 A0#2pin@177_polysilicon-1##36 A0#2pin@177_polysilicon-1##37 9.881
R281 A0#2pin@177_polysilicon-1##37 A0#2pin@177_polysilicon-1##38 9.881
R282 A0#2pin@177_polysilicon-1##38 A0#2pin@177_polysilicon-1##39 9.881
R283 A0#2pin@177_polysilicon-1##39 A0#2pin@177_polysilicon-1##40 9.881
R284 A0#2pin@177_polysilicon-1##40 A0#2pin@177_polysilicon-1##41 9.881
R285 A0#2pin@177_polysilicon-1##41 A0#2pin@177_polysilicon-1##42 9.881
R286 A0#2pin@177_polysilicon-1##42 A0#2pin@177_polysilicon-1##43 9.881
R287 A0#2pin@177_polysilicon-1##43 A0#2pin@177_polysilicon-1##44 9.881
R288 A0#2pin@177_polysilicon-1##44 A0#2pin@177_polysilicon-1##45 9.881
R289 A0#2pin@177_polysilicon-1##45 A0#2pin@177_polysilicon-1##46 9.881
R290 A0#2pin@177_polysilicon-1##46 A0#2pin@177_polysilicon-1##47 9.881
R291 A0#2pin@177_polysilicon-1##47 A0#2pin@177_polysilicon-1##48 9.881
R292 A0#2pin@177_polysilicon-1##48 A0#2pin@177_polysilicon-1##49 9.881
R293 A0#2pin@177_polysilicon-1##49 A0#2pin@177_polysilicon-1##50 9.881
R294 A0#2pin@177_polysilicon-1##50 A0#2pin@177_polysilicon-1##51 9.881
R295 A0#2pin@177_polysilicon-1##51 A0#2pin@177_polysilicon-1##52 9.881
R296 A0#2pin@177_polysilicon-1##52 A0#2pin@177_polysilicon-1##53 9.881
R297 A0#2pin@177_polysilicon-1##53 A0#2pin@177_polysilicon-1##54 9.881
R298 A0#2pin@177_polysilicon-1##54 A0#14nmos@45_poly-right 9.881
R299 net@562#5pmos@45_diff-top net@562#2pin@166_metal-1 4.81
R300 net@562#1pin@176_polysilicon-1 net@562#1pin@176_polysilicon-1##0 9.85
R301 net@562#1pin@176_polysilicon-1##0 net@562#1pin@176_polysilicon-1##1 9.85
R302 net@562#1pin@176_polysilicon-1##1 net@562#1pin@176_polysilicon-1##2 9.85
R303 net@562#1pin@176_polysilicon-1##2 net@562#1pin@176_polysilicon-1##3 9.85
R304 net@562#1pin@176_polysilicon-1##3 net@562#1pin@176_polysilicon-1##4 9.85
R305 net@562#1pin@176_polysilicon-1##4 net@562#1pin@176_polysilicon-1##5 9.85
R306 net@562#1pin@176_polysilicon-1##5 net@562#1pin@176_polysilicon-1##6 9.85
R307 net@562#1pin@176_polysilicon-1##6 net@562#1pin@176_polysilicon-1##7 9.85
R308 net@562#1pin@176_polysilicon-1##7 net@562#1pin@176_polysilicon-1##8 9.85
R309 net@562#1pin@176_polysilicon-1##8 net@562#1pin@176_polysilicon-1##9 9.85
R310 net@562#1pin@176_polysilicon-1##9 net@562#1pin@176_polysilicon-1##10 9.85
R311 net@562#1pin@176_polysilicon-1##10 net@562#1pin@176_polysilicon-1##11 9.85
R312 net@562#1pin@176_polysilicon-1##11 net@562#1pin@176_polysilicon-1##12 9.85
R313 net@562#1pin@176_polysilicon-1##12 net@562#1pin@176_polysilicon-1##13 9.85
R314 net@562#1pin@176_polysilicon-1##13 net@562#1pin@176_polysilicon-1##14 9.85
R315 net@562#1pin@176_polysilicon-1##14 net@562#1pin@176_polysilicon-1##15 9.85
R316 net@562#1pin@176_polysilicon-1##15 net@562#1pin@176_polysilicon-1##16 9.85
R317 net@562#1pin@176_polysilicon-1##16 net@562#1pin@176_polysilicon-1##17 9.85
R318 net@562#1pin@176_polysilicon-1##17 net@562#1pin@176_polysilicon-1##18 9.85
R319 net@562#1pin@176_polysilicon-1##18 net@562#1pin@176_polysilicon-1##19 9.85
R320 net@562#1pin@176_polysilicon-1##19 net@562#1pin@176_polysilicon-1##20 9.85
R321 net@562#1pin@176_polysilicon-1##20 net@562#1pin@176_polysilicon-1##21 9.85
R322 net@562#1pin@176_polysilicon-1##21 net@562#1pin@176_polysilicon-1##22 9.85
R323 net@562#1pin@176_polysilicon-1##22 net@562#1pin@176_polysilicon-1##23 9.85
R324 net@562#1pin@176_polysilicon-1##23 net@562#1pin@176_polysilicon-1##24 9.85
R325 net@562#1pin@176_polysilicon-1##24 net@562#1pin@176_polysilicon-1##25 9.85
R326 net@562#1pin@176_polysilicon-1##25 net@562#1pin@176_polysilicon-1##26 9.85
R327 net@562#1pin@176_polysilicon-1##26 net@562#1pin@176_polysilicon-1##27 9.85
R328 net@562#1pin@176_polysilicon-1##27 net@562#1pin@176_polysilicon-1##28 9.85
R329 net@562#1pin@176_polysilicon-1##28 net@562#1pin@176_polysilicon-1##29 9.85
R330 net@562#1pin@176_polysilicon-1##29 net@562#1pin@176_polysilicon-1##30 9.85
R331 net@562#1pin@176_polysilicon-1##30 net@562#1pin@176_polysilicon-1##31 9.85
R332 net@562#1pin@176_polysilicon-1##31 net@562#1pin@176_polysilicon-1##32 9.85
R333 net@562#1pin@176_polysilicon-1##32 net@562#1pin@176_polysilicon-1##33 9.85
R334 net@562#1pin@176_polysilicon-1##33 net@562#1pin@176_polysilicon-1##34 9.85
R335 net@562#1pin@176_polysilicon-1##34 net@562#1pin@176_polysilicon-1##35 9.85
R336 net@562#1pin@176_polysilicon-1##35 net@562#1pin@176_polysilicon-1##36 9.85
R337 net@562#1pin@176_polysilicon-1##36 net@562#1pin@176_polysilicon-1##37 9.85
R338 net@562#1pin@176_polysilicon-1##37 net@562#1pin@176_polysilicon-1##38 9.85
R339 net@562#1pin@176_polysilicon-1##38 net@562#1pin@176_polysilicon-1##39 9.85
R340 net@562#1pin@176_polysilicon-1##39 net@562#1pin@176_polysilicon-1##40 9.85
R341 net@562#1pin@176_polysilicon-1##40 net@562#1pin@176_polysilicon-1##41 9.85
R342 net@562#1pin@176_polysilicon-1##41 net@562#1pin@176_polysilicon-1##42 9.85
R343 net@562#1pin@176_polysilicon-1##42 net@562#1pin@176_polysilicon-1##43 9.85
R344 net@562#1pin@176_polysilicon-1##43 net@562#1pin@176_polysilicon-1##44 9.85
R345 net@562#1pin@176_polysilicon-1##44 net@562#1pin@176_polysilicon-1##45 9.85
R346 net@562#1pin@176_polysilicon-1##45 net@562#1pin@176_polysilicon-1##46 9.85
R347 net@562#1pin@176_polysilicon-1##46 net@562#1pin@176_polysilicon-1##47 9.85
R348 net@562#1pin@176_polysilicon-1##47 net@562#1pin@176_polysilicon-1##48 9.85
R349 net@562#1pin@176_polysilicon-1##48 net@562#1pin@176_polysilicon-1##49 9.85
R350 net@562#1pin@176_polysilicon-1##49 net@562#1pin@176_polysilicon-1##50 9.85
R351 net@562#1pin@176_polysilicon-1##50 net@562#1pin@176_polysilicon-1##51 9.85
R352 net@562#1pin@176_polysilicon-1##51 net@562#1pin@176_polysilicon-1##52 9.85
R353 net@562#1pin@176_polysilicon-1##52 net@562#1pin@176_polysilicon-1##53 9.85
R354 net@562#1pin@176_polysilicon-1##53 net@562#1pin@176_polysilicon-1##54 9.85
R355 net@562#1pin@176_polysilicon-1##54 net@562#1pin@176_polysilicon-1##55 9.85
R356 net@562#1pin@176_polysilicon-1##55 net@562#1pin@176_polysilicon-1##56 9.85
R357 net@562#1pin@176_polysilicon-1##56 net@562#1pin@176_polysilicon-1##57 9.85
R358 net@562#1pin@176_polysilicon-1##57 net@562#1pin@176_polysilicon-1##58 9.85
R359 net@562#1pin@176_polysilicon-1##58 net@562#1pin@176_polysilicon-1##59 9.85
R360 net@562#1pin@176_polysilicon-1##59 net@562#1pin@176_polysilicon-1##60 9.85
R361 net@562#1pin@176_polysilicon-1##60 net@562#2pin@166_metal-1 9.85
R362 B0#15pmos@44_poly-right B0#15pmos@44_poly-right##0 9.854
R363 B0#15pmos@44_poly-right##0 B0#15pmos@44_poly-right##1 9.854
R364 B0#15pmos@44_poly-right##1 B0#15pmos@44_poly-right##2 9.854
R365 B0#15pmos@44_poly-right##2 B0#15pmos@44_poly-right##3 9.854
R366 B0#15pmos@44_poly-right##3 B0#15pmos@44_poly-right##4 9.854
R367 B0#15pmos@44_poly-right##4 B0#15pmos@44_poly-right##5 9.854
R368 B0#15pmos@44_poly-right##5 B0#15pmos@44_poly-right##6 9.854
R369 B0#15pmos@44_poly-right##6 B0#15pmos@44_poly-right##7 9.854
R370 B0#15pmos@44_poly-right##7 B0#15pmos@44_poly-right##8 9.854
R371 B0#15pmos@44_poly-right##8 B0#15pmos@44_poly-right##9 9.854
R372 B0#15pmos@44_poly-right##9 B0#15pmos@44_poly-right##10 9.854
R373 B0#15pmos@44_poly-right##10 B0#15pmos@44_poly-right##11 9.854
R374 B0#15pmos@44_poly-right##11 B0#15pmos@44_poly-right##12 9.854
R375 B0#15pmos@44_poly-right##12 B0#15pmos@44_poly-right##13 9.854
R376 B0#15pmos@44_poly-right##13 B0#15pmos@44_poly-right##14 9.854
R377 B0#15pmos@44_poly-right##14 B0#15pmos@44_poly-right##15 9.854
R378 B0#15pmos@44_poly-right##15 B0#15pmos@44_poly-right##16 9.854
R379 B0#15pmos@44_poly-right##16 B0#15pmos@44_poly-right##17 9.854
R380 B0#15pmos@44_poly-right##17 B0#15pmos@44_poly-right##18 9.854
R381 B0#15pmos@44_poly-right##18 B0#15pmos@44_poly-right##19 9.854
R382 B0#15pmos@44_poly-right##19 B0#15pmos@44_poly-right##20 9.854
R383 B0#15pmos@44_poly-right##20 B0#15pmos@44_poly-right##21 9.854
R384 B0#15pmos@44_poly-right##21 B0#15pmos@44_poly-right##22 9.854
R385 B0#15pmos@44_poly-right##22 B0#15pmos@44_poly-right##23 9.854
R386 B0#15pmos@44_poly-right##23 B0#15pmos@44_poly-right##24 9.854
R387 B0#15pmos@44_poly-right##24 B0#15pmos@44_poly-right##25 9.854
R388 B0#15pmos@44_poly-right##25 B0#15pmos@44_poly-right##26 9.854
R389 B0#15pmos@44_poly-right##26 B0#15pmos@44_poly-right##27 9.854
R390 B0#15pmos@44_poly-right##27 B0#15pmos@44_poly-right##28 9.854
R391 B0#15pmos@44_poly-right##28 B0#15pmos@44_poly-right##29 9.854
R392 B0#15pmos@44_poly-right##29 B0#15pmos@44_poly-right##30 9.854
R393 B0#15pmos@44_poly-right##30 B0#15pmos@44_poly-right##31 9.854
R394 B0#15pmos@44_poly-right##31 B0#15pmos@44_poly-right##32 9.854
R395 B0#15pmos@44_poly-right##32 B0#15pmos@44_poly-right##33 9.854
R396 B0#15pmos@44_poly-right##33 B0#15pmos@44_poly-right##34 9.854
R397 B0#15pmos@44_poly-right##34 B0#15pmos@44_poly-right##35 9.854
R398 B0#15pmos@44_poly-right##35 B0#15pmos@44_poly-right##36 9.854
R399 B0#15pmos@44_poly-right##36 B0#15pmos@44_poly-right##37 9.854
R400 B0#15pmos@44_poly-right##37 B0#15pmos@44_poly-right##38 9.854
R401 B0#15pmos@44_poly-right##38 B0#15pmos@44_poly-right##39 9.854
R402 B0#15pmos@44_poly-right##39 B0#15pmos@44_poly-right##40 9.854
R403 B0#15pmos@44_poly-right##40 B0#15pmos@44_poly-right##41 9.854
R404 B0#15pmos@44_poly-right##41 B0#15pmos@44_poly-right##42 9.854
R405 B0#15pmos@44_poly-right##42 B0#15pmos@44_poly-right##43 9.854
R406 B0#15pmos@44_poly-right##43 B0#15pmos@44_poly-right##44 9.854
R407 B0#15pmos@44_poly-right##44 B0#15pmos@44_poly-right##45 9.854
R408 B0#15pmos@44_poly-right##45 B0#15pmos@44_poly-right##46 9.854
R409 B0#15pmos@44_poly-right##46 B0#15pmos@44_poly-right##47 9.854
R410 B0#15pmos@44_poly-right##47 B0#15pmos@44_poly-right##48 9.854
R411 B0#15pmos@44_poly-right##48 B0#15pmos@44_poly-right##49 9.854
R412 B0#15pmos@44_poly-right##49 B0#15pmos@44_poly-right##50 9.854
R413 B0#15pmos@44_poly-right##50 B0#15pmos@44_poly-right##51 9.854
R414 B0#15pmos@44_poly-right##51 B0#15pmos@44_poly-right##52 9.854
R415 B0#15pmos@44_poly-right##52 B0#15pmos@44_poly-right##53 9.854
R416 B0#15pmos@44_poly-right##53 B0#15pmos@44_poly-right##54 9.854
R417 B0#15pmos@44_poly-right##54 B0#10pin@167_polysilicon-1 9.854
R418 net@684 net@684#2contact@231_metal-1-metal-2 4.797
R419 A0#15nmos@40_poly-right A0#15nmos@40_poly-right##0 9.871
R420 A0#15nmos@40_poly-right##0 A0#15nmos@40_poly-right##1 9.871
R421 A0#15nmos@40_poly-right##1 A0#15nmos@40_poly-right##2 9.871
R422 A0#15nmos@40_poly-right##2 A0#15nmos@40_poly-right##3 9.871
R423 A0#15nmos@40_poly-right##3 A0#15nmos@40_poly-right##4 9.871
R424 A0#15nmos@40_poly-right##4 A0#15nmos@40_poly-right##5 9.871
R425 A0#15nmos@40_poly-right##5 A0#15nmos@40_poly-right##6 9.871
R426 A0#15nmos@40_poly-right##6 A0#15nmos@40_poly-right##7 9.871
R427 A0#15nmos@40_poly-right##7 A0#15nmos@40_poly-right##8 9.871
R428 A0#15nmos@40_poly-right##8 A0#15nmos@40_poly-right##9 9.871
R429 A0#15nmos@40_poly-right##9 A0#15nmos@40_poly-right##10 9.871
R430 A0#15nmos@40_poly-right##10 A0#15nmos@40_poly-right##11 9.871
R431 A0#15nmos@40_poly-right##11 A0#15nmos@40_poly-right##12 9.871
R432 A0#15nmos@40_poly-right##12 A0#15nmos@40_poly-right##13 9.871
R433 A0#15nmos@40_poly-right##13 A0#15nmos@40_poly-right##14 9.871
R434 A0#15nmos@40_poly-right##14 A0#15nmos@40_poly-right##15 9.871
R435 A0#15nmos@40_poly-right##15 A0#15nmos@40_poly-right##16 9.871
R436 A0#15nmos@40_poly-right##16 A0#15nmos@40_poly-right##17 9.871
R437 A0#15nmos@40_poly-right##17 A0#15nmos@40_poly-right##18 9.871
R438 A0#15nmos@40_poly-right##18 A0#15nmos@40_poly-right##19 9.871
R439 A0#15nmos@40_poly-right##19 A0#15nmos@40_poly-right##20 9.871
R440 A0#15nmos@40_poly-right##20 A0#15nmos@40_poly-right##21 9.871
R441 A0#15nmos@40_poly-right##21 A0#15nmos@40_poly-right##22 9.871
R442 A0#15nmos@40_poly-right##22 A0#15nmos@40_poly-right##23 9.871
R443 A0#15nmos@40_poly-right##23 A0#15nmos@40_poly-right##24 9.871
R444 A0#15nmos@40_poly-right##24 A0#15nmos@40_poly-right##25 9.871
R445 A0#15nmos@40_poly-right##25 A0#15nmos@40_poly-right##26 9.871
R446 A0#15nmos@40_poly-right##26 A0#15nmos@40_poly-right##27 9.871
R447 A0#15nmos@40_poly-right##27 A0#15nmos@40_poly-right##28 9.871
R448 A0#15nmos@40_poly-right##28 A0#15nmos@40_poly-right##29 9.871
R449 A0#15nmos@40_poly-right##29 A0#15nmos@40_poly-right##30 9.871
R450 A0#15nmos@40_poly-right##30 A0#15nmos@40_poly-right##31 9.871
R451 A0#15nmos@40_poly-right##31 A0#15nmos@40_poly-right##32 9.871
R452 A0#15nmos@40_poly-right##32 A0#15nmos@40_poly-right##33 9.871
R453 A0#15nmos@40_poly-right##33 A0#15nmos@40_poly-right##34 9.871
R454 A0#15nmos@40_poly-right##34 A0#15nmos@40_poly-right##35 9.871
R455 A0#15nmos@40_poly-right##35 A0#15nmos@40_poly-right##36 9.871
R456 A0#15nmos@40_poly-right##36 A0#15nmos@40_poly-right##37 9.871
R457 A0#15nmos@40_poly-right##37 A0#15nmos@40_poly-right##38 9.871
R458 A0#15nmos@40_poly-right##38 A0#15nmos@40_poly-right##39 9.871
R459 A0#15nmos@40_poly-right##39 A0#15nmos@40_poly-right##40 9.871
R460 A0#15nmos@40_poly-right##40 A0#15nmos@40_poly-right##41 9.871
R461 A0#15nmos@40_poly-right##41 A0#15nmos@40_poly-right##42 9.871
R462 A0#15nmos@40_poly-right##42 A0#15nmos@40_poly-right##43 9.871
R463 A0#15nmos@40_poly-right##43 A0#15nmos@40_poly-right##44 9.871
R464 A0#15nmos@40_poly-right##44 A0#15nmos@40_poly-right##45 9.871
R465 A0#15nmos@40_poly-right##45 A0#15nmos@40_poly-right##46 9.871
R466 A0#15nmos@40_poly-right##46 A0#15nmos@40_poly-right##47 9.871
R467 A0#15nmos@40_poly-right##47 A0#15nmos@40_poly-right##48 9.871
R468 A0#15nmos@40_poly-right##48 A0#15nmos@40_poly-right##49 9.871
R469 A0#15nmos@40_poly-right##49 A0#15nmos@40_poly-right##50 9.871
R470 A0#15nmos@40_poly-right##50 A0#15nmos@40_poly-right##51 9.871
R471 A0#15nmos@40_poly-right##51 A0#15nmos@40_poly-right##52 9.871
R472 A0#15nmos@40_poly-right##52 A0#15nmos@40_poly-right##53 9.871
R473 A0#15nmos@40_poly-right##53 A0#15nmos@40_poly-right##54 9.871
R474 A0#15nmos@40_poly-right##54 A0#15nmos@40_poly-right##55 9.871
R475 A0#15nmos@40_poly-right##55 A0#10pmos@40_poly-left 9.871
R476 net@562#7pmos@41_poly-left net@562#7pmos@41_poly-left##0 9.871
R477 net@562#7pmos@41_poly-left##0 net@562#7pmos@41_poly-left##1 9.871
R478 net@562#7pmos@41_poly-left##1 net@562#7pmos@41_poly-left##2 9.871
R479 net@562#7pmos@41_poly-left##2 net@562#7pmos@41_poly-left##3 9.871
R480 net@562#7pmos@41_poly-left##3 net@562#7pmos@41_poly-left##4 9.871
R481 net@562#7pmos@41_poly-left##4 net@562#7pmos@41_poly-left##5 9.871
R482 net@562#7pmos@41_poly-left##5 net@562#7pmos@41_poly-left##6 9.871
R483 net@562#7pmos@41_poly-left##6 net@562#7pmos@41_poly-left##7 9.871
R484 net@562#7pmos@41_poly-left##7 net@562#7pmos@41_poly-left##8 9.871
R485 net@562#7pmos@41_poly-left##8 net@562#7pmos@41_poly-left##9 9.871
R486 net@562#7pmos@41_poly-left##9 net@562#7pmos@41_poly-left##10 9.871
R487 net@562#7pmos@41_poly-left##10 net@562#7pmos@41_poly-left##11 9.871
R488 net@562#7pmos@41_poly-left##11 net@562#7pmos@41_poly-left##12 9.871
R489 net@562#7pmos@41_poly-left##12 net@562#7pmos@41_poly-left##13 9.871
R490 net@562#7pmos@41_poly-left##13 net@562#7pmos@41_poly-left##14 9.871
R491 net@562#7pmos@41_poly-left##14 net@562#7pmos@41_poly-left##15 9.871
R492 net@562#7pmos@41_poly-left##15 net@562#7pmos@41_poly-left##16 9.871
R493 net@562#7pmos@41_poly-left##16 net@562#7pmos@41_poly-left##17 9.871
R494 net@562#7pmos@41_poly-left##17 net@562#7pmos@41_poly-left##18 9.871
R495 net@562#7pmos@41_poly-left##18 net@562#7pmos@41_poly-left##19 9.871
R496 net@562#7pmos@41_poly-left##19 net@562#7pmos@41_poly-left##20 9.871
R497 net@562#7pmos@41_poly-left##20 net@562#7pmos@41_poly-left##21 9.871
R498 net@562#7pmos@41_poly-left##21 net@562#7pmos@41_poly-left##22 9.871
R499 net@562#7pmos@41_poly-left##22 net@562#7pmos@41_poly-left##23 9.871
R500 net@562#7pmos@41_poly-left##23 net@562#7pmos@41_poly-left##24 9.871
R501 net@562#7pmos@41_poly-left##24 net@562#7pmos@41_poly-left##25 9.871
R502 net@562#7pmos@41_poly-left##25 net@562#7pmos@41_poly-left##26 9.871
R503 net@562#7pmos@41_poly-left##26 net@562#7pmos@41_poly-left##27 9.871
R504 net@562#7pmos@41_poly-left##27 net@562#7pmos@41_poly-left##28 9.871
R505 net@562#7pmos@41_poly-left##28 net@562#7pmos@41_poly-left##29 9.871
R506 net@562#7pmos@41_poly-left##29 net@562#7pmos@41_poly-left##30 9.871
R507 net@562#7pmos@41_poly-left##30 net@562#7pmos@41_poly-left##31 9.871
R508 net@562#7pmos@41_poly-left##31 net@562#7pmos@41_poly-left##32 9.871
R509 net@562#7pmos@41_poly-left##32 net@562#7pmos@41_poly-left##33 9.871
R510 net@562#7pmos@41_poly-left##33 net@562#7pmos@41_poly-left##34 9.871
R511 net@562#7pmos@41_poly-left##34 net@562#7pmos@41_poly-left##35 9.871
R512 net@562#7pmos@41_poly-left##35 net@562#7pmos@41_poly-left##36 9.871
R513 net@562#7pmos@41_poly-left##36 net@562#7pmos@41_poly-left##37 9.871
R514 net@562#7pmos@41_poly-left##37 net@562#7pmos@41_poly-left##38 9.871
R515 net@562#7pmos@41_poly-left##38 net@562#7pmos@41_poly-left##39 9.871
R516 net@562#7pmos@41_poly-left##39 net@562#7pmos@41_poly-left##40 9.871
R517 net@562#7pmos@41_poly-left##40 net@562#7pmos@41_poly-left##41 9.871
R518 net@562#7pmos@41_poly-left##41 net@562#7pmos@41_poly-left##42 9.871
R519 net@562#7pmos@41_poly-left##42 net@562#7pmos@41_poly-left##43 9.871
R520 net@562#7pmos@41_poly-left##43 net@562#7pmos@41_poly-left##44 9.871
R521 net@562#7pmos@41_poly-left##44 net@562#7pmos@41_poly-left##45 9.871
R522 net@562#7pmos@41_poly-left##45 net@562#7pmos@41_poly-left##46 9.871
R523 net@562#7pmos@41_poly-left##46 net@562#7pmos@41_poly-left##47 9.871
R524 net@562#7pmos@41_poly-left##47 net@562#7pmos@41_poly-left##48 9.871
R525 net@562#7pmos@41_poly-left##48 net@562#7pmos@41_poly-left##49 9.871
R526 net@562#7pmos@41_poly-left##49 net@562#7pmos@41_poly-left##50 9.871
R527 net@562#7pmos@41_poly-left##50 net@562#7pmos@41_poly-left##51 9.871
R528 net@562#7pmos@41_poly-left##51 net@562#7pmos@41_poly-left##52 9.871
R529 net@562#7pmos@41_poly-left##52 net@562#7pmos@41_poly-left##53 9.871
R530 net@562#7pmos@41_poly-left##53 net@562#7pmos@41_poly-left##54 9.871
R531 net@562#7pmos@41_poly-left##54 net@562#7pmos@41_poly-left##55 9.871
R532 net@562#7pmos@41_poly-left##55 net@562#11nmos@41_poly-right 9.871
R533 B0#16pmos@42_poly-right B0#16pmos@42_poly-right##0 9.871
R534 B0#16pmos@42_poly-right##0 B0#16pmos@42_poly-right##1 9.871
R535 B0#16pmos@42_poly-right##1 B0#16pmos@42_poly-right##2 9.871
R536 B0#16pmos@42_poly-right##2 B0#16pmos@42_poly-right##3 9.871
R537 B0#16pmos@42_poly-right##3 B0#16pmos@42_poly-right##4 9.871
R538 B0#16pmos@42_poly-right##4 B0#16pmos@42_poly-right##5 9.871
R539 B0#16pmos@42_poly-right##5 B0#16pmos@42_poly-right##6 9.871
R540 B0#16pmos@42_poly-right##6 B0#16pmos@42_poly-right##7 9.871
R541 B0#16pmos@42_poly-right##7 B0#16pmos@42_poly-right##8 9.871
R542 B0#16pmos@42_poly-right##8 B0#16pmos@42_poly-right##9 9.871
R543 B0#16pmos@42_poly-right##9 B0#16pmos@42_poly-right##10 9.871
R544 B0#16pmos@42_poly-right##10 B0#16pmos@42_poly-right##11 9.871
R545 B0#16pmos@42_poly-right##11 B0#16pmos@42_poly-right##12 9.871
R546 B0#16pmos@42_poly-right##12 B0#16pmos@42_poly-right##13 9.871
R547 B0#16pmos@42_poly-right##13 B0#16pmos@42_poly-right##14 9.871
R548 B0#16pmos@42_poly-right##14 B0#16pmos@42_poly-right##15 9.871
R549 B0#16pmos@42_poly-right##15 B0#16pmos@42_poly-right##16 9.871
R550 B0#16pmos@42_poly-right##16 B0#16pmos@42_poly-right##17 9.871
R551 B0#16pmos@42_poly-right##17 B0#16pmos@42_poly-right##18 9.871
R552 B0#16pmos@42_poly-right##18 B0#16pmos@42_poly-right##19 9.871
R553 B0#16pmos@42_poly-right##19 B0#16pmos@42_poly-right##20 9.871
R554 B0#16pmos@42_poly-right##20 B0#16pmos@42_poly-right##21 9.871
R555 B0#16pmos@42_poly-right##21 B0#16pmos@42_poly-right##22 9.871
R556 B0#16pmos@42_poly-right##22 B0#16pmos@42_poly-right##23 9.871
R557 B0#16pmos@42_poly-right##23 B0#16pmos@42_poly-right##24 9.871
R558 B0#16pmos@42_poly-right##24 B0#16pmos@42_poly-right##25 9.871
R559 B0#16pmos@42_poly-right##25 B0#16pmos@42_poly-right##26 9.871
R560 B0#16pmos@42_poly-right##26 B0#16pmos@42_poly-right##27 9.871
R561 B0#16pmos@42_poly-right##27 B0#16pmos@42_poly-right##28 9.871
R562 B0#16pmos@42_poly-right##28 B0#16pmos@42_poly-right##29 9.871
R563 B0#16pmos@42_poly-right##29 B0#16pmos@42_poly-right##30 9.871
R564 B0#16pmos@42_poly-right##30 B0#16pmos@42_poly-right##31 9.871
R565 B0#16pmos@42_poly-right##31 B0#16pmos@42_poly-right##32 9.871
R566 B0#16pmos@42_poly-right##32 B0#16pmos@42_poly-right##33 9.871
R567 B0#16pmos@42_poly-right##33 B0#16pmos@42_poly-right##34 9.871
R568 B0#16pmos@42_poly-right##34 B0#16pmos@42_poly-right##35 9.871
R569 B0#16pmos@42_poly-right##35 B0#16pmos@42_poly-right##36 9.871
R570 B0#16pmos@42_poly-right##36 B0#16pmos@42_poly-right##37 9.871
R571 B0#16pmos@42_poly-right##37 B0#16pmos@42_poly-right##38 9.871
R572 B0#16pmos@42_poly-right##38 B0#16pmos@42_poly-right##39 9.871
R573 B0#16pmos@42_poly-right##39 B0#16pmos@42_poly-right##40 9.871
R574 B0#16pmos@42_poly-right##40 B0#16pmos@42_poly-right##41 9.871
R575 B0#16pmos@42_poly-right##41 B0#16pmos@42_poly-right##42 9.871
R576 B0#16pmos@42_poly-right##42 B0#16pmos@42_poly-right##43 9.871
R577 B0#16pmos@42_poly-right##43 B0#16pmos@42_poly-right##44 9.871
R578 B0#16pmos@42_poly-right##44 B0#16pmos@42_poly-right##45 9.871
R579 B0#16pmos@42_poly-right##45 B0#16pmos@42_poly-right##46 9.871
R580 B0#16pmos@42_poly-right##46 B0#16pmos@42_poly-right##47 9.871
R581 B0#16pmos@42_poly-right##47 B0#16pmos@42_poly-right##48 9.871
R582 B0#16pmos@42_poly-right##48 B0#16pmos@42_poly-right##49 9.871
R583 B0#16pmos@42_poly-right##49 B0#16pmos@42_poly-right##50 9.871
R584 B0#16pmos@42_poly-right##50 B0#16pmos@42_poly-right##51 9.871
R585 B0#16pmos@42_poly-right##51 B0#16pmos@42_poly-right##52 9.871
R586 B0#16pmos@42_poly-right##52 B0#16pmos@42_poly-right##53 9.871
R587 B0#16pmos@42_poly-right##53 B0#16pmos@42_poly-right##54 9.871
R588 B0#16pmos@42_poly-right##54 B0#16pmos@42_poly-right##55 9.871
R589 B0#16pmos@42_poly-right##55 B0#14nmos@42_poly-left 9.871
R590 net@684#14pmos@43_poly-right net@684#14pmos@43_poly-right##0 9.871
R591 net@684#14pmos@43_poly-right##0 net@684#14pmos@43_poly-right##1 9.871
R592 net@684#14pmos@43_poly-right##1 net@684#14pmos@43_poly-right##2 9.871
R593 net@684#14pmos@43_poly-right##2 net@684#14pmos@43_poly-right##3 9.871
R594 net@684#14pmos@43_poly-right##3 net@684#14pmos@43_poly-right##4 9.871
R595 net@684#14pmos@43_poly-right##4 net@684#14pmos@43_poly-right##5 9.871
R596 net@684#14pmos@43_poly-right##5 net@684#14pmos@43_poly-right##6 9.871
R597 net@684#14pmos@43_poly-right##6 net@684#14pmos@43_poly-right##7 9.871
R598 net@684#14pmos@43_poly-right##7 net@684#14pmos@43_poly-right##8 9.871
R599 net@684#14pmos@43_poly-right##8 net@684#14pmos@43_poly-right##9 9.871
R600 net@684#14pmos@43_poly-right##9 net@684#14pmos@43_poly-right##10 9.871
R601 net@684#14pmos@43_poly-right##10 net@684#14pmos@43_poly-right##11 9.871
R602 net@684#14pmos@43_poly-right##11 net@684#14pmos@43_poly-right##12 9.871
R603 net@684#14pmos@43_poly-right##12 net@684#14pmos@43_poly-right##13 9.871
R604 net@684#14pmos@43_poly-right##13 net@684#14pmos@43_poly-right##14 9.871
R605 net@684#14pmos@43_poly-right##14 net@684#14pmos@43_poly-right##15 9.871
R606 net@684#14pmos@43_poly-right##15 net@684#14pmos@43_poly-right##16 9.871
R607 net@684#14pmos@43_poly-right##16 net@684#14pmos@43_poly-right##17 9.871
R608 net@684#14pmos@43_poly-right##17 net@684#14pmos@43_poly-right##18 9.871
R609 net@684#14pmos@43_poly-right##18 net@684#14pmos@43_poly-right##19 9.871
R610 net@684#14pmos@43_poly-right##19 net@684#14pmos@43_poly-right##20 9.871
R611 net@684#14pmos@43_poly-right##20 net@684#14pmos@43_poly-right##21 9.871
R612 net@684#14pmos@43_poly-right##21 net@684#14pmos@43_poly-right##22 9.871
R613 net@684#14pmos@43_poly-right##22 net@684#14pmos@43_poly-right##23 9.871
R614 net@684#14pmos@43_poly-right##23 net@684#14pmos@43_poly-right##24 9.871
R615 net@684#14pmos@43_poly-right##24 net@684#14pmos@43_poly-right##25 9.871
R616 net@684#14pmos@43_poly-right##25 net@684#14pmos@43_poly-right##26 9.871
R617 net@684#14pmos@43_poly-right##26 net@684#14pmos@43_poly-right##27 9.871
R618 net@684#14pmos@43_poly-right##27 net@684#14pmos@43_poly-right##28 9.871
R619 net@684#14pmos@43_poly-right##28 net@684#14pmos@43_poly-right##29 9.871
R620 net@684#14pmos@43_poly-right##29 net@684#14pmos@43_poly-right##30 9.871
R621 net@684#14pmos@43_poly-right##30 net@684#14pmos@43_poly-right##31 9.871
R622 net@684#14pmos@43_poly-right##31 net@684#14pmos@43_poly-right##32 9.871
R623 net@684#14pmos@43_poly-right##32 net@684#14pmos@43_poly-right##33 9.871
R624 net@684#14pmos@43_poly-right##33 net@684#14pmos@43_poly-right##34 9.871
R625 net@684#14pmos@43_poly-right##34 net@684#14pmos@43_poly-right##35 9.871
R626 net@684#14pmos@43_poly-right##35 net@684#14pmos@43_poly-right##36 9.871
R627 net@684#14pmos@43_poly-right##36 net@684#14pmos@43_poly-right##37 9.871
R628 net@684#14pmos@43_poly-right##37 net@684#14pmos@43_poly-right##38 9.871
R629 net@684#14pmos@43_poly-right##38 net@684#14pmos@43_poly-right##39 9.871
R630 net@684#14pmos@43_poly-right##39 net@684#14pmos@43_poly-right##40 9.871
R631 net@684#14pmos@43_poly-right##40 net@684#14pmos@43_poly-right##41 9.871
R632 net@684#14pmos@43_poly-right##41 net@684#14pmos@43_poly-right##42 9.871
R633 net@684#14pmos@43_poly-right##42 net@684#14pmos@43_poly-right##43 9.871
R634 net@684#14pmos@43_poly-right##43 net@684#14pmos@43_poly-right##44 9.871
R635 net@684#14pmos@43_poly-right##44 net@684#14pmos@43_poly-right##45 9.871
R636 net@684#14pmos@43_poly-right##45 net@684#14pmos@43_poly-right##46 9.871
R637 net@684#14pmos@43_poly-right##46 net@684#14pmos@43_poly-right##47 9.871
R638 net@684#14pmos@43_poly-right##47 net@684#14pmos@43_poly-right##48 9.871
R639 net@684#14pmos@43_poly-right##48 net@684#14pmos@43_poly-right##49 9.871
R640 net@684#14pmos@43_poly-right##49 net@684#14pmos@43_poly-right##50 9.871
R641 net@684#14pmos@43_poly-right##50 net@684#14pmos@43_poly-right##51 9.871
R642 net@684#14pmos@43_poly-right##51 net@684#14pmos@43_poly-right##52 9.871
R643 net@684#14pmos@43_poly-right##52 net@684#14pmos@43_poly-right##53 9.871
R644 net@684#14pmos@43_poly-right##53 net@684#14pmos@43_poly-right##54 9.871
R645 net@684#14pmos@43_poly-right##54 net@684#14pmos@43_poly-right##55 9.871
R646 net@684#14pmos@43_poly-right##55 net@684#9nmos@43_poly-left 9.871
R647 net@676#2contact@256_metal-1-polysilicon-1 net@676 4.706
R648 net@676#12pmos@46_poly-right net@676#12pmos@46_poly-right##0 9.864
R649 net@676#12pmos@46_poly-right##0 net@676#12pmos@46_poly-right##1 9.864
R650 net@676#12pmos@46_poly-right##1 net@676#12pmos@46_poly-right##2 9.864
R651 net@676#12pmos@46_poly-right##2 net@676#12pmos@46_poly-right##3 9.864
R652 net@676#12pmos@46_poly-right##3 net@676#12pmos@46_poly-right##4 9.864
R653 net@676#12pmos@46_poly-right##4 net@676#12pmos@46_poly-right##5 9.864
R654 net@676#12pmos@46_poly-right##5 net@676#12pmos@46_poly-right##6 9.864
R655 net@676#12pmos@46_poly-right##6 net@676#12pmos@46_poly-right##7 9.864
R656 net@676#12pmos@46_poly-right##7 net@676#12pmos@46_poly-right##8 9.864
R657 net@676#12pmos@46_poly-right##8 net@676#12pmos@46_poly-right##9 9.864
R658 net@676#12pmos@46_poly-right##9 net@676#12pmos@46_poly-right##10 9.864
R659 net@676#12pmos@46_poly-right##10 net@676#12pmos@46_poly-right##11 9.864
R660 net@676#12pmos@46_poly-right##11 net@676#12pmos@46_poly-right##12 9.864
R661 net@676#12pmos@46_poly-right##12 net@676#12pmos@46_poly-right##13 9.864
R662 net@676#12pmos@46_poly-right##13 net@676#12pmos@46_poly-right##14 9.864
R663 net@676#12pmos@46_poly-right##14 net@676#12pmos@46_poly-right##15 9.864
R664 net@676#12pmos@46_poly-right##15 net@676#12pmos@46_poly-right##16 9.864
R665 net@676#12pmos@46_poly-right##16 net@676#12pmos@46_poly-right##17 9.864
R666 net@676#12pmos@46_poly-right##17 net@676#12pmos@46_poly-right##18 9.864
R667 net@676#12pmos@46_poly-right##18 net@676#12pmos@46_poly-right##19 9.864
R668 net@676#12pmos@46_poly-right##19 net@676#12pmos@46_poly-right##20 9.864
R669 net@676#12pmos@46_poly-right##20 net@676#12pmos@46_poly-right##21 9.864
R670 net@676#12pmos@46_poly-right##21 net@676#12pmos@46_poly-right##22 9.864
R671 net@676#12pmos@46_poly-right##22 net@676#12pmos@46_poly-right##23 9.864
R672 net@676#12pmos@46_poly-right##23 net@676#12pmos@46_poly-right##24 9.864
R673 net@676#12pmos@46_poly-right##24 net@676#12pmos@46_poly-right##25 9.864
R674 net@676#12pmos@46_poly-right##25 net@676#12pmos@46_poly-right##26 9.864
R675 net@676#12pmos@46_poly-right##26 net@676#12pmos@46_poly-right##27 9.864
R676 net@676#12pmos@46_poly-right##27 net@676#12pmos@46_poly-right##28 9.864
R677 net@676#12pmos@46_poly-right##28 net@676#12pmos@46_poly-right##29 9.864
R678 net@676#12pmos@46_poly-right##29 net@676#12pmos@46_poly-right##30 9.864
R679 net@676#12pmos@46_poly-right##30 net@676#12pmos@46_poly-right##31 9.864
R680 net@676#12pmos@46_poly-right##31 net@676#12pmos@46_poly-right##32 9.864
R681 net@676#12pmos@46_poly-right##32 net@676#12pmos@46_poly-right##33 9.864
R682 net@676#12pmos@46_poly-right##33 net@676#12pmos@46_poly-right##34 9.864
R683 net@676#12pmos@46_poly-right##34 net@676#12pmos@46_poly-right##35 9.864
R684 net@676#12pmos@46_poly-right##35 net@676#12pmos@46_poly-right##36 9.864
R685 net@676#12pmos@46_poly-right##36 net@676#12pmos@46_poly-right##37 9.864
R686 net@676#12pmos@46_poly-right##37 net@676#12pmos@46_poly-right##38 9.864
R687 net@676#12pmos@46_poly-right##38 net@676#12pmos@46_poly-right##39 9.864
R688 net@676#12pmos@46_poly-right##39 net@676#12pmos@46_poly-right##40 9.864
R689 net@676#12pmos@46_poly-right##40 net@676#12pmos@46_poly-right##41 9.864
R690 net@676#12pmos@46_poly-right##41 net@676#12pmos@46_poly-right##42 9.864
R691 net@676#12pmos@46_poly-right##42 net@676#12pmos@46_poly-right##43 9.864
R692 net@676#12pmos@46_poly-right##43 net@676#12pmos@46_poly-right##44 9.864
R693 net@676#12pmos@46_poly-right##44 net@676#12pmos@46_poly-right##45 9.864
R694 net@676#12pmos@46_poly-right##45 net@676#12pmos@46_poly-right##46 9.864
R695 net@676#12pmos@46_poly-right##46 net@676#12pmos@46_poly-right##47 9.864
R696 net@676#12pmos@46_poly-right##47 net@676#12pmos@46_poly-right##48 9.864
R697 net@676#12pmos@46_poly-right##48 net@676#12pmos@46_poly-right##49 9.864
R698 net@676#12pmos@46_poly-right##49 net@676#12pmos@46_poly-right##50 9.864
R699 net@676#12pmos@46_poly-right##50 net@676#12pmos@46_poly-right##51 9.864
R700 net@676#12pmos@46_poly-right##51 net@676#12pmos@46_poly-right##52 9.864
R701 net@676#12pmos@46_poly-right##52 net@676#12pmos@46_poly-right##53 9.864
R702 net@676#12pmos@46_poly-right##53 net@676#5pin@169_polysilicon-1 9.864
R703 XOR1_to_NAND1#22pmos@46_diff-top XOR1_to_NAND1#1contact@309_metal-1-metal-2 4.862
R704 XOR1_to_NAND1#3pin@203_polysilicon-1 XOR1_to_NAND1#3pin@203_polysilicon-1##0 9.881
R705 XOR1_to_NAND1#3pin@203_polysilicon-1##0 XOR1_to_NAND1#3pin@203_polysilicon-1##1 9.881
R706 XOR1_to_NAND1#3pin@203_polysilicon-1##1 XOR1_to_NAND1#3pin@203_polysilicon-1##2 9.881
R707 XOR1_to_NAND1#3pin@203_polysilicon-1##2 XOR1_to_NAND1#3pin@203_polysilicon-1##3 9.881
R708 XOR1_to_NAND1#3pin@203_polysilicon-1##3 XOR1_to_NAND1#3pin@203_polysilicon-1##4 9.881
R709 XOR1_to_NAND1#3pin@203_polysilicon-1##4 XOR1_to_NAND1#3pin@203_polysilicon-1##5 9.881
R710 XOR1_to_NAND1#3pin@203_polysilicon-1##5 XOR1_to_NAND1#3pin@203_polysilicon-1##6 9.881
R711 XOR1_to_NAND1#3pin@203_polysilicon-1##6 XOR1_to_NAND1#3pin@203_polysilicon-1##7 9.881
R712 XOR1_to_NAND1#3pin@203_polysilicon-1##7 XOR1_to_NAND1#3pin@203_polysilicon-1##8 9.881
R713 XOR1_to_NAND1#3pin@203_polysilicon-1##8 XOR1_to_NAND1#3pin@203_polysilicon-1##9 9.881
R714 XOR1_to_NAND1#3pin@203_polysilicon-1##9 XOR1_to_NAND1#3pin@203_polysilicon-1##10 9.881
R715 XOR1_to_NAND1#3pin@203_polysilicon-1##10 XOR1_to_NAND1#3pin@203_polysilicon-1##11 9.881
R716 XOR1_to_NAND1#3pin@203_polysilicon-1##11 XOR1_to_NAND1#3pin@203_polysilicon-1##12 9.881
R717 XOR1_to_NAND1#3pin@203_polysilicon-1##12 XOR1_to_NAND1#3pin@203_polysilicon-1##13 9.881
R718 XOR1_to_NAND1#3pin@203_polysilicon-1##13 XOR1_to_NAND1#3pin@203_polysilicon-1##14 9.881
R719 XOR1_to_NAND1#3pin@203_polysilicon-1##14 XOR1_to_NAND1#3pin@203_polysilicon-1##15 9.881
R720 XOR1_to_NAND1#3pin@203_polysilicon-1##15 XOR1_to_NAND1#3pin@203_polysilicon-1##16 9.881
R721 XOR1_to_NAND1#3pin@203_polysilicon-1##16 XOR1_to_NAND1#3pin@203_polysilicon-1##17 9.881
R722 XOR1_to_NAND1#3pin@203_polysilicon-1##17 XOR1_to_NAND1#3pin@203_polysilicon-1##18 9.881
R723 XOR1_to_NAND1#3pin@203_polysilicon-1##18 XOR1_to_NAND1#3pin@203_polysilicon-1##19 9.881
R724 XOR1_to_NAND1#3pin@203_polysilicon-1##19 XOR1_to_NAND1#3pin@203_polysilicon-1##20 9.881
R725 XOR1_to_NAND1#3pin@203_polysilicon-1##20 XOR1_to_NAND1#3pin@203_polysilicon-1##21 9.881
R726 XOR1_to_NAND1#3pin@203_polysilicon-1##21 XOR1_to_NAND1#3pin@203_polysilicon-1##22 9.881
R727 XOR1_to_NAND1#3pin@203_polysilicon-1##22 XOR1_to_NAND1#3pin@203_polysilicon-1##23 9.881
R728 XOR1_to_NAND1#3pin@203_polysilicon-1##23 XOR1_to_NAND1#3pin@203_polysilicon-1##24 9.881
R729 XOR1_to_NAND1#3pin@203_polysilicon-1##24 XOR1_to_NAND1#3pin@203_polysilicon-1##25 9.881
R730 XOR1_to_NAND1#3pin@203_polysilicon-1##25 XOR1_to_NAND1#3pin@203_polysilicon-1##26 9.881
R731 XOR1_to_NAND1#3pin@203_polysilicon-1##26 XOR1_to_NAND1#3pin@203_polysilicon-1##27 9.881
R732 XOR1_to_NAND1#3pin@203_polysilicon-1##27 XOR1_to_NAND1#3pin@203_polysilicon-1##28 9.881
R733 XOR1_to_NAND1#3pin@203_polysilicon-1##28 XOR1_to_NAND1#3pin@203_polysilicon-1##29 9.881
R734 XOR1_to_NAND1#3pin@203_polysilicon-1##29 XOR1_to_NAND1#3pin@203_polysilicon-1##30 9.881
R735 XOR1_to_NAND1#3pin@203_polysilicon-1##30 XOR1_to_NAND1#3pin@203_polysilicon-1##31 9.881
R736 XOR1_to_NAND1#3pin@203_polysilicon-1##31 XOR1_to_NAND1#3pin@203_polysilicon-1##32 9.881
R737 XOR1_to_NAND1#3pin@203_polysilicon-1##32 XOR1_to_NAND1#3pin@203_polysilicon-1##33 9.881
R738 XOR1_to_NAND1#3pin@203_polysilicon-1##33 XOR1_to_NAND1#3pin@203_polysilicon-1##34 9.881
R739 XOR1_to_NAND1#3pin@203_polysilicon-1##34 XOR1_to_NAND1#3pin@203_polysilicon-1##35 9.881
R740 XOR1_to_NAND1#3pin@203_polysilicon-1##35 XOR1_to_NAND1#3pin@203_polysilicon-1##36 9.881
R741 XOR1_to_NAND1#3pin@203_polysilicon-1##36 XOR1_to_NAND1#3pin@203_polysilicon-1##37 9.881
R742 XOR1_to_NAND1#3pin@203_polysilicon-1##37 XOR1_to_NAND1#3pin@203_polysilicon-1##38 9.881
R743 XOR1_to_NAND1#3pin@203_polysilicon-1##38 XOR1_to_NAND1#3pin@203_polysilicon-1##39 9.881
R744 XOR1_to_NAND1#3pin@203_polysilicon-1##39 XOR1_to_NAND1#3pin@203_polysilicon-1##40 9.881
R745 XOR1_to_NAND1#3pin@203_polysilicon-1##40 XOR1_to_NAND1#3pin@203_polysilicon-1##41 9.881
R746 XOR1_to_NAND1#3pin@203_polysilicon-1##41 XOR1_to_NAND1#3pin@203_polysilicon-1##42 9.881
R747 XOR1_to_NAND1#3pin@203_polysilicon-1##42 XOR1_to_NAND1#3pin@203_polysilicon-1##43 9.881
R748 XOR1_to_NAND1#3pin@203_polysilicon-1##43 XOR1_to_NAND1#3pin@203_polysilicon-1##44 9.881
R749 XOR1_to_NAND1#3pin@203_polysilicon-1##44 XOR1_to_NAND1#3pin@203_polysilicon-1##45 9.881
R750 XOR1_to_NAND1#3pin@203_polysilicon-1##45 XOR1_to_NAND1#3pin@203_polysilicon-1##46 9.881
R751 XOR1_to_NAND1#3pin@203_polysilicon-1##46 XOR1_to_NAND1#3pin@203_polysilicon-1##47 9.881
R752 XOR1_to_NAND1#3pin@203_polysilicon-1##47 XOR1_to_NAND1#3pin@203_polysilicon-1##48 9.881
R753 XOR1_to_NAND1#3pin@203_polysilicon-1##48 XOR1_to_NAND1#3pin@203_polysilicon-1##49 9.881
R754 XOR1_to_NAND1#3pin@203_polysilicon-1##49 XOR1_to_NAND1#3pin@203_polysilicon-1##50 9.881
R755 XOR1_to_NAND1#3pin@203_polysilicon-1##50 XOR1_to_NAND1#3pin@203_polysilicon-1##51 9.881
R756 XOR1_to_NAND1#3pin@203_polysilicon-1##51 XOR1_to_NAND1#3pin@203_polysilicon-1##52 9.881
R757 XOR1_to_NAND1#3pin@203_polysilicon-1##52 XOR1_to_NAND1#3pin@203_polysilicon-1##53 9.881
R758 XOR1_to_NAND1#3pin@203_polysilicon-1##53 XOR1_to_NAND1#3pin@203_polysilicon-1##54 9.881
R759 XOR1_to_NAND1#3pin@203_polysilicon-1##54 XOR1_to_NAND1#24nmos@52_poly-right 9.881
R760 net@564#5pmos@52_diff-top net@564#2pin@192_metal-1 4.81
R761 net@564#1pin@202_polysilicon-1 net@564#1pin@202_polysilicon-1##0 9.85
R762 net@564#1pin@202_polysilicon-1##0 net@564#1pin@202_polysilicon-1##1 9.85
R763 net@564#1pin@202_polysilicon-1##1 net@564#1pin@202_polysilicon-1##2 9.85
R764 net@564#1pin@202_polysilicon-1##2 net@564#1pin@202_polysilicon-1##3 9.85
R765 net@564#1pin@202_polysilicon-1##3 net@564#1pin@202_polysilicon-1##4 9.85
R766 net@564#1pin@202_polysilicon-1##4 net@564#1pin@202_polysilicon-1##5 9.85
R767 net@564#1pin@202_polysilicon-1##5 net@564#1pin@202_polysilicon-1##6 9.85
R768 net@564#1pin@202_polysilicon-1##6 net@564#1pin@202_polysilicon-1##7 9.85
R769 net@564#1pin@202_polysilicon-1##7 net@564#1pin@202_polysilicon-1##8 9.85
R770 net@564#1pin@202_polysilicon-1##8 net@564#1pin@202_polysilicon-1##9 9.85
R771 net@564#1pin@202_polysilicon-1##9 net@564#1pin@202_polysilicon-1##10 9.85
R772 net@564#1pin@202_polysilicon-1##10 net@564#1pin@202_polysilicon-1##11 9.85
R773 net@564#1pin@202_polysilicon-1##11 net@564#1pin@202_polysilicon-1##12 9.85
R774 net@564#1pin@202_polysilicon-1##12 net@564#1pin@202_polysilicon-1##13 9.85
R775 net@564#1pin@202_polysilicon-1##13 net@564#1pin@202_polysilicon-1##14 9.85
R776 net@564#1pin@202_polysilicon-1##14 net@564#1pin@202_polysilicon-1##15 9.85
R777 net@564#1pin@202_polysilicon-1##15 net@564#1pin@202_polysilicon-1##16 9.85
R778 net@564#1pin@202_polysilicon-1##16 net@564#1pin@202_polysilicon-1##17 9.85
R779 net@564#1pin@202_polysilicon-1##17 net@564#1pin@202_polysilicon-1##18 9.85
R780 net@564#1pin@202_polysilicon-1##18 net@564#1pin@202_polysilicon-1##19 9.85
R781 net@564#1pin@202_polysilicon-1##19 net@564#1pin@202_polysilicon-1##20 9.85
R782 net@564#1pin@202_polysilicon-1##20 net@564#1pin@202_polysilicon-1##21 9.85
R783 net@564#1pin@202_polysilicon-1##21 net@564#1pin@202_polysilicon-1##22 9.85
R784 net@564#1pin@202_polysilicon-1##22 net@564#1pin@202_polysilicon-1##23 9.85
R785 net@564#1pin@202_polysilicon-1##23 net@564#1pin@202_polysilicon-1##24 9.85
R786 net@564#1pin@202_polysilicon-1##24 net@564#1pin@202_polysilicon-1##25 9.85
R787 net@564#1pin@202_polysilicon-1##25 net@564#1pin@202_polysilicon-1##26 9.85
R788 net@564#1pin@202_polysilicon-1##26 net@564#1pin@202_polysilicon-1##27 9.85
R789 net@564#1pin@202_polysilicon-1##27 net@564#1pin@202_polysilicon-1##28 9.85
R790 net@564#1pin@202_polysilicon-1##28 net@564#1pin@202_polysilicon-1##29 9.85
R791 net@564#1pin@202_polysilicon-1##29 net@564#1pin@202_polysilicon-1##30 9.85
R792 net@564#1pin@202_polysilicon-1##30 net@564#1pin@202_polysilicon-1##31 9.85
R793 net@564#1pin@202_polysilicon-1##31 net@564#1pin@202_polysilicon-1##32 9.85
R794 net@564#1pin@202_polysilicon-1##32 net@564#1pin@202_polysilicon-1##33 9.85
R795 net@564#1pin@202_polysilicon-1##33 net@564#1pin@202_polysilicon-1##34 9.85
R796 net@564#1pin@202_polysilicon-1##34 net@564#1pin@202_polysilicon-1##35 9.85
R797 net@564#1pin@202_polysilicon-1##35 net@564#1pin@202_polysilicon-1##36 9.85
R798 net@564#1pin@202_polysilicon-1##36 net@564#1pin@202_polysilicon-1##37 9.85
R799 net@564#1pin@202_polysilicon-1##37 net@564#1pin@202_polysilicon-1##38 9.85
R800 net@564#1pin@202_polysilicon-1##38 net@564#1pin@202_polysilicon-1##39 9.85
R801 net@564#1pin@202_polysilicon-1##39 net@564#1pin@202_polysilicon-1##40 9.85
R802 net@564#1pin@202_polysilicon-1##40 net@564#1pin@202_polysilicon-1##41 9.85
R803 net@564#1pin@202_polysilicon-1##41 net@564#1pin@202_polysilicon-1##42 9.85
R804 net@564#1pin@202_polysilicon-1##42 net@564#1pin@202_polysilicon-1##43 9.85
R805 net@564#1pin@202_polysilicon-1##43 net@564#1pin@202_polysilicon-1##44 9.85
R806 net@564#1pin@202_polysilicon-1##44 net@564#1pin@202_polysilicon-1##45 9.85
R807 net@564#1pin@202_polysilicon-1##45 net@564#1pin@202_polysilicon-1##46 9.85
R808 net@564#1pin@202_polysilicon-1##46 net@564#1pin@202_polysilicon-1##47 9.85
R809 net@564#1pin@202_polysilicon-1##47 net@564#1pin@202_polysilicon-1##48 9.85
R810 net@564#1pin@202_polysilicon-1##48 net@564#1pin@202_polysilicon-1##49 9.85
R811 net@564#1pin@202_polysilicon-1##49 net@564#1pin@202_polysilicon-1##50 9.85
R812 net@564#1pin@202_polysilicon-1##50 net@564#1pin@202_polysilicon-1##51 9.85
R813 net@564#1pin@202_polysilicon-1##51 net@564#1pin@202_polysilicon-1##52 9.85
R814 net@564#1pin@202_polysilicon-1##52 net@564#1pin@202_polysilicon-1##53 9.85
R815 net@564#1pin@202_polysilicon-1##53 net@564#1pin@202_polysilicon-1##54 9.85
R816 net@564#1pin@202_polysilicon-1##54 net@564#1pin@202_polysilicon-1##55 9.85
R817 net@564#1pin@202_polysilicon-1##55 net@564#1pin@202_polysilicon-1##56 9.85
R818 net@564#1pin@202_polysilicon-1##56 net@564#1pin@202_polysilicon-1##57 9.85
R819 net@564#1pin@202_polysilicon-1##57 net@564#1pin@202_polysilicon-1##58 9.85
R820 net@564#1pin@202_polysilicon-1##58 net@564#1pin@202_polysilicon-1##59 9.85
R821 net@564#1pin@202_polysilicon-1##59 net@564#1pin@202_polysilicon-1##60 9.85
R822 net@564#1pin@202_polysilicon-1##60 net@564#2pin@192_metal-1 9.85
R823 Cin#17pmos@51_poly-right Cin#17pmos@51_poly-right##0 9.854
R824 Cin#17pmos@51_poly-right##0 Cin#17pmos@51_poly-right##1 9.854
R825 Cin#17pmos@51_poly-right##1 Cin#17pmos@51_poly-right##2 9.854
R826 Cin#17pmos@51_poly-right##2 Cin#17pmos@51_poly-right##3 9.854
R827 Cin#17pmos@51_poly-right##3 Cin#17pmos@51_poly-right##4 9.854
R828 Cin#17pmos@51_poly-right##4 Cin#17pmos@51_poly-right##5 9.854
R829 Cin#17pmos@51_poly-right##5 Cin#17pmos@51_poly-right##6 9.854
R830 Cin#17pmos@51_poly-right##6 Cin#17pmos@51_poly-right##7 9.854
R831 Cin#17pmos@51_poly-right##7 Cin#17pmos@51_poly-right##8 9.854
R832 Cin#17pmos@51_poly-right##8 Cin#17pmos@51_poly-right##9 9.854
R833 Cin#17pmos@51_poly-right##9 Cin#17pmos@51_poly-right##10 9.854
R834 Cin#17pmos@51_poly-right##10 Cin#17pmos@51_poly-right##11 9.854
R835 Cin#17pmos@51_poly-right##11 Cin#17pmos@51_poly-right##12 9.854
R836 Cin#17pmos@51_poly-right##12 Cin#17pmos@51_poly-right##13 9.854
R837 Cin#17pmos@51_poly-right##13 Cin#17pmos@51_poly-right##14 9.854
R838 Cin#17pmos@51_poly-right##14 Cin#17pmos@51_poly-right##15 9.854
R839 Cin#17pmos@51_poly-right##15 Cin#17pmos@51_poly-right##16 9.854
R840 Cin#17pmos@51_poly-right##16 Cin#17pmos@51_poly-right##17 9.854
R841 Cin#17pmos@51_poly-right##17 Cin#17pmos@51_poly-right##18 9.854
R842 Cin#17pmos@51_poly-right##18 Cin#17pmos@51_poly-right##19 9.854
R843 Cin#17pmos@51_poly-right##19 Cin#17pmos@51_poly-right##20 9.854
R844 Cin#17pmos@51_poly-right##20 Cin#17pmos@51_poly-right##21 9.854
R845 Cin#17pmos@51_poly-right##21 Cin#17pmos@51_poly-right##22 9.854
R846 Cin#17pmos@51_poly-right##22 Cin#17pmos@51_poly-right##23 9.854
R847 Cin#17pmos@51_poly-right##23 Cin#17pmos@51_poly-right##24 9.854
R848 Cin#17pmos@51_poly-right##24 Cin#17pmos@51_poly-right##25 9.854
R849 Cin#17pmos@51_poly-right##25 Cin#17pmos@51_poly-right##26 9.854
R850 Cin#17pmos@51_poly-right##26 Cin#17pmos@51_poly-right##27 9.854
R851 Cin#17pmos@51_poly-right##27 Cin#17pmos@51_poly-right##28 9.854
R852 Cin#17pmos@51_poly-right##28 Cin#17pmos@51_poly-right##29 9.854
R853 Cin#17pmos@51_poly-right##29 Cin#17pmos@51_poly-right##30 9.854
R854 Cin#17pmos@51_poly-right##30 Cin#17pmos@51_poly-right##31 9.854
R855 Cin#17pmos@51_poly-right##31 Cin#17pmos@51_poly-right##32 9.854
R856 Cin#17pmos@51_poly-right##32 Cin#17pmos@51_poly-right##33 9.854
R857 Cin#17pmos@51_poly-right##33 Cin#17pmos@51_poly-right##34 9.854
R858 Cin#17pmos@51_poly-right##34 Cin#17pmos@51_poly-right##35 9.854
R859 Cin#17pmos@51_poly-right##35 Cin#17pmos@51_poly-right##36 9.854
R860 Cin#17pmos@51_poly-right##36 Cin#17pmos@51_poly-right##37 9.854
R861 Cin#17pmos@51_poly-right##37 Cin#17pmos@51_poly-right##38 9.854
R862 Cin#17pmos@51_poly-right##38 Cin#17pmos@51_poly-right##39 9.854
R863 Cin#17pmos@51_poly-right##39 Cin#17pmos@51_poly-right##40 9.854
R864 Cin#17pmos@51_poly-right##40 Cin#17pmos@51_poly-right##41 9.854
R865 Cin#17pmos@51_poly-right##41 Cin#17pmos@51_poly-right##42 9.854
R866 Cin#17pmos@51_poly-right##42 Cin#17pmos@51_poly-right##43 9.854
R867 Cin#17pmos@51_poly-right##43 Cin#17pmos@51_poly-right##44 9.854
R868 Cin#17pmos@51_poly-right##44 Cin#17pmos@51_poly-right##45 9.854
R869 Cin#17pmos@51_poly-right##45 Cin#17pmos@51_poly-right##46 9.854
R870 Cin#17pmos@51_poly-right##46 Cin#17pmos@51_poly-right##47 9.854
R871 Cin#17pmos@51_poly-right##47 Cin#17pmos@51_poly-right##48 9.854
R872 Cin#17pmos@51_poly-right##48 Cin#17pmos@51_poly-right##49 9.854
R873 Cin#17pmos@51_poly-right##49 Cin#17pmos@51_poly-right##50 9.854
R874 Cin#17pmos@51_poly-right##50 Cin#17pmos@51_poly-right##51 9.854
R875 Cin#17pmos@51_poly-right##51 Cin#17pmos@51_poly-right##52 9.854
R876 Cin#17pmos@51_poly-right##52 Cin#17pmos@51_poly-right##53 9.854
R877 Cin#17pmos@51_poly-right##53 Cin#17pmos@51_poly-right##54 9.854
R878 Cin#17pmos@51_poly-right##54 Cin#6pin@193_polysilicon-1 9.854
R879 net@577 net@577#2contact@270_metal-1-metal-2 4.797
R880 XOR1_to_NAND1#9pmos@47_poly-left XOR1_to_NAND1#9pmos@47_poly-left##0 9.871
R881 XOR1_to_NAND1#9pmos@47_poly-left##0 XOR1_to_NAND1#9pmos@47_poly-left##1 9.871
R882 XOR1_to_NAND1#9pmos@47_poly-left##1 XOR1_to_NAND1#9pmos@47_poly-left##2 9.871
R883 XOR1_to_NAND1#9pmos@47_poly-left##2 XOR1_to_NAND1#9pmos@47_poly-left##3 9.871
R884 XOR1_to_NAND1#9pmos@47_poly-left##3 XOR1_to_NAND1#9pmos@47_poly-left##4 9.871
R885 XOR1_to_NAND1#9pmos@47_poly-left##4 XOR1_to_NAND1#9pmos@47_poly-left##5 9.871
R886 XOR1_to_NAND1#9pmos@47_poly-left##5 XOR1_to_NAND1#9pmos@47_poly-left##6 9.871
R887 XOR1_to_NAND1#9pmos@47_poly-left##6 XOR1_to_NAND1#9pmos@47_poly-left##7 9.871
R888 XOR1_to_NAND1#9pmos@47_poly-left##7 XOR1_to_NAND1#9pmos@47_poly-left##8 9.871
R889 XOR1_to_NAND1#9pmos@47_poly-left##8 XOR1_to_NAND1#9pmos@47_poly-left##9 9.871
R890 XOR1_to_NAND1#9pmos@47_poly-left##9 XOR1_to_NAND1#9pmos@47_poly-left##10 9.871
R891 XOR1_to_NAND1#9pmos@47_poly-left##10 XOR1_to_NAND1#9pmos@47_poly-left##11 9.871
R892 XOR1_to_NAND1#9pmos@47_poly-left##11 XOR1_to_NAND1#9pmos@47_poly-left##12 9.871
R893 XOR1_to_NAND1#9pmos@47_poly-left##12 XOR1_to_NAND1#9pmos@47_poly-left##13 9.871
R894 XOR1_to_NAND1#9pmos@47_poly-left##13 XOR1_to_NAND1#9pmos@47_poly-left##14 9.871
R895 XOR1_to_NAND1#9pmos@47_poly-left##14 XOR1_to_NAND1#9pmos@47_poly-left##15 9.871
R896 XOR1_to_NAND1#9pmos@47_poly-left##15 XOR1_to_NAND1#9pmos@47_poly-left##16 9.871
R897 XOR1_to_NAND1#9pmos@47_poly-left##16 XOR1_to_NAND1#9pmos@47_poly-left##17 9.871
R898 XOR1_to_NAND1#9pmos@47_poly-left##17 XOR1_to_NAND1#9pmos@47_poly-left##18 9.871
R899 XOR1_to_NAND1#9pmos@47_poly-left##18 XOR1_to_NAND1#9pmos@47_poly-left##19 9.871
R900 XOR1_to_NAND1#9pmos@47_poly-left##19 XOR1_to_NAND1#9pmos@47_poly-left##20 9.871
R901 XOR1_to_NAND1#9pmos@47_poly-left##20 XOR1_to_NAND1#9pmos@47_poly-left##21 9.871
R902 XOR1_to_NAND1#9pmos@47_poly-left##21 XOR1_to_NAND1#9pmos@47_poly-left##22 9.871
R903 XOR1_to_NAND1#9pmos@47_poly-left##22 XOR1_to_NAND1#9pmos@47_poly-left##23 9.871
R904 XOR1_to_NAND1#9pmos@47_poly-left##23 XOR1_to_NAND1#9pmos@47_poly-left##24 9.871
R905 XOR1_to_NAND1#9pmos@47_poly-left##24 XOR1_to_NAND1#9pmos@47_poly-left##25 9.871
R906 XOR1_to_NAND1#9pmos@47_poly-left##25 XOR1_to_NAND1#9pmos@47_poly-left##26 9.871
R907 XOR1_to_NAND1#9pmos@47_poly-left##26 XOR1_to_NAND1#9pmos@47_poly-left##27 9.871
R908 XOR1_to_NAND1#9pmos@47_poly-left##27 XOR1_to_NAND1#9pmos@47_poly-left##28 9.871
R909 XOR1_to_NAND1#9pmos@47_poly-left##28 XOR1_to_NAND1#9pmos@47_poly-left##29 9.871
R910 XOR1_to_NAND1#9pmos@47_poly-left##29 XOR1_to_NAND1#9pmos@47_poly-left##30 9.871
R911 XOR1_to_NAND1#9pmos@47_poly-left##30 XOR1_to_NAND1#9pmos@47_poly-left##31 9.871
R912 XOR1_to_NAND1#9pmos@47_poly-left##31 XOR1_to_NAND1#9pmos@47_poly-left##32 9.871
R913 XOR1_to_NAND1#9pmos@47_poly-left##32 XOR1_to_NAND1#9pmos@47_poly-left##33 9.871
R914 XOR1_to_NAND1#9pmos@47_poly-left##33 XOR1_to_NAND1#9pmos@47_poly-left##34 9.871
R915 XOR1_to_NAND1#9pmos@47_poly-left##34 XOR1_to_NAND1#9pmos@47_poly-left##35 9.871
R916 XOR1_to_NAND1#9pmos@47_poly-left##35 XOR1_to_NAND1#9pmos@47_poly-left##36 9.871
R917 XOR1_to_NAND1#9pmos@47_poly-left##36 XOR1_to_NAND1#9pmos@47_poly-left##37 9.871
R918 XOR1_to_NAND1#9pmos@47_poly-left##37 XOR1_to_NAND1#9pmos@47_poly-left##38 9.871
R919 XOR1_to_NAND1#9pmos@47_poly-left##38 XOR1_to_NAND1#9pmos@47_poly-left##39 9.871
R920 XOR1_to_NAND1#9pmos@47_poly-left##39 XOR1_to_NAND1#9pmos@47_poly-left##40 9.871
R921 XOR1_to_NAND1#9pmos@47_poly-left##40 XOR1_to_NAND1#9pmos@47_poly-left##41 9.871
R922 XOR1_to_NAND1#9pmos@47_poly-left##41 XOR1_to_NAND1#9pmos@47_poly-left##42 9.871
R923 XOR1_to_NAND1#9pmos@47_poly-left##42 XOR1_to_NAND1#9pmos@47_poly-left##43 9.871
R924 XOR1_to_NAND1#9pmos@47_poly-left##43 XOR1_to_NAND1#9pmos@47_poly-left##44 9.871
R925 XOR1_to_NAND1#9pmos@47_poly-left##44 XOR1_to_NAND1#9pmos@47_poly-left##45 9.871
R926 XOR1_to_NAND1#9pmos@47_poly-left##45 XOR1_to_NAND1#9pmos@47_poly-left##46 9.871
R927 XOR1_to_NAND1#9pmos@47_poly-left##46 XOR1_to_NAND1#9pmos@47_poly-left##47 9.871
R928 XOR1_to_NAND1#9pmos@47_poly-left##47 XOR1_to_NAND1#9pmos@47_poly-left##48 9.871
R929 XOR1_to_NAND1#9pmos@47_poly-left##48 XOR1_to_NAND1#9pmos@47_poly-left##49 9.871
R930 XOR1_to_NAND1#9pmos@47_poly-left##49 XOR1_to_NAND1#9pmos@47_poly-left##50 9.871
R931 XOR1_to_NAND1#9pmos@47_poly-left##50 XOR1_to_NAND1#9pmos@47_poly-left##51 9.871
R932 XOR1_to_NAND1#9pmos@47_poly-left##51 XOR1_to_NAND1#9pmos@47_poly-left##52 9.871
R933 XOR1_to_NAND1#9pmos@47_poly-left##52 XOR1_to_NAND1#9pmos@47_poly-left##53 9.871
R934 XOR1_to_NAND1#9pmos@47_poly-left##53 XOR1_to_NAND1#9pmos@47_poly-left##54 9.871
R935 XOR1_to_NAND1#9pmos@47_poly-left##54 XOR1_to_NAND1#9pmos@47_poly-left##55 9.871
R936 XOR1_to_NAND1#9pmos@47_poly-left##55 XOR1_to_NAND1#26nmos@47_poly-right 9.871
R937 net@564#7pmos@48_poly-left net@564#7pmos@48_poly-left##0 9.871
R938 net@564#7pmos@48_poly-left##0 net@564#7pmos@48_poly-left##1 9.871
R939 net@564#7pmos@48_poly-left##1 net@564#7pmos@48_poly-left##2 9.871
R940 net@564#7pmos@48_poly-left##2 net@564#7pmos@48_poly-left##3 9.871
R941 net@564#7pmos@48_poly-left##3 net@564#7pmos@48_poly-left##4 9.871
R942 net@564#7pmos@48_poly-left##4 net@564#7pmos@48_poly-left##5 9.871
R943 net@564#7pmos@48_poly-left##5 net@564#7pmos@48_poly-left##6 9.871
R944 net@564#7pmos@48_poly-left##6 net@564#7pmos@48_poly-left##7 9.871
R945 net@564#7pmos@48_poly-left##7 net@564#7pmos@48_poly-left##8 9.871
R946 net@564#7pmos@48_poly-left##8 net@564#7pmos@48_poly-left##9 9.871
R947 net@564#7pmos@48_poly-left##9 net@564#7pmos@48_poly-left##10 9.871
R948 net@564#7pmos@48_poly-left##10 net@564#7pmos@48_poly-left##11 9.871
R949 net@564#7pmos@48_poly-left##11 net@564#7pmos@48_poly-left##12 9.871
R950 net@564#7pmos@48_poly-left##12 net@564#7pmos@48_poly-left##13 9.871
R951 net@564#7pmos@48_poly-left##13 net@564#7pmos@48_poly-left##14 9.871
R952 net@564#7pmos@48_poly-left##14 net@564#7pmos@48_poly-left##15 9.871
R953 net@564#7pmos@48_poly-left##15 net@564#7pmos@48_poly-left##16 9.871
R954 net@564#7pmos@48_poly-left##16 net@564#7pmos@48_poly-left##17 9.871
R955 net@564#7pmos@48_poly-left##17 net@564#7pmos@48_poly-left##18 9.871
R956 net@564#7pmos@48_poly-left##18 net@564#7pmos@48_poly-left##19 9.871
R957 net@564#7pmos@48_poly-left##19 net@564#7pmos@48_poly-left##20 9.871
R958 net@564#7pmos@48_poly-left##20 net@564#7pmos@48_poly-left##21 9.871
R959 net@564#7pmos@48_poly-left##21 net@564#7pmos@48_poly-left##22 9.871
R960 net@564#7pmos@48_poly-left##22 net@564#7pmos@48_poly-left##23 9.871
R961 net@564#7pmos@48_poly-left##23 net@564#7pmos@48_poly-left##24 9.871
R962 net@564#7pmos@48_poly-left##24 net@564#7pmos@48_poly-left##25 9.871
R963 net@564#7pmos@48_poly-left##25 net@564#7pmos@48_poly-left##26 9.871
R964 net@564#7pmos@48_poly-left##26 net@564#7pmos@48_poly-left##27 9.871
R965 net@564#7pmos@48_poly-left##27 net@564#7pmos@48_poly-left##28 9.871
R966 net@564#7pmos@48_poly-left##28 net@564#7pmos@48_poly-left##29 9.871
R967 net@564#7pmos@48_poly-left##29 net@564#7pmos@48_poly-left##30 9.871
R968 net@564#7pmos@48_poly-left##30 net@564#7pmos@48_poly-left##31 9.871
R969 net@564#7pmos@48_poly-left##31 net@564#7pmos@48_poly-left##32 9.871
R970 net@564#7pmos@48_poly-left##32 net@564#7pmos@48_poly-left##33 9.871
R971 net@564#7pmos@48_poly-left##33 net@564#7pmos@48_poly-left##34 9.871
R972 net@564#7pmos@48_poly-left##34 net@564#7pmos@48_poly-left##35 9.871
R973 net@564#7pmos@48_poly-left##35 net@564#7pmos@48_poly-left##36 9.871
R974 net@564#7pmos@48_poly-left##36 net@564#7pmos@48_poly-left##37 9.871
R975 net@564#7pmos@48_poly-left##37 net@564#7pmos@48_poly-left##38 9.871
R976 net@564#7pmos@48_poly-left##38 net@564#7pmos@48_poly-left##39 9.871
R977 net@564#7pmos@48_poly-left##39 net@564#7pmos@48_poly-left##40 9.871
R978 net@564#7pmos@48_poly-left##40 net@564#7pmos@48_poly-left##41 9.871
R979 net@564#7pmos@48_poly-left##41 net@564#7pmos@48_poly-left##42 9.871
R980 net@564#7pmos@48_poly-left##42 net@564#7pmos@48_poly-left##43 9.871
R981 net@564#7pmos@48_poly-left##43 net@564#7pmos@48_poly-left##44 9.871
R982 net@564#7pmos@48_poly-left##44 net@564#7pmos@48_poly-left##45 9.871
R983 net@564#7pmos@48_poly-left##45 net@564#7pmos@48_poly-left##46 9.871
R984 net@564#7pmos@48_poly-left##46 net@564#7pmos@48_poly-left##47 9.871
R985 net@564#7pmos@48_poly-left##47 net@564#7pmos@48_poly-left##48 9.871
R986 net@564#7pmos@48_poly-left##48 net@564#7pmos@48_poly-left##49 9.871
R987 net@564#7pmos@48_poly-left##49 net@564#7pmos@48_poly-left##50 9.871
R988 net@564#7pmos@48_poly-left##50 net@564#7pmos@48_poly-left##51 9.871
R989 net@564#7pmos@48_poly-left##51 net@564#7pmos@48_poly-left##52 9.871
R990 net@564#7pmos@48_poly-left##52 net@564#7pmos@48_poly-left##53 9.871
R991 net@564#7pmos@48_poly-left##53 net@564#7pmos@48_poly-left##54 9.871
R992 net@564#7pmos@48_poly-left##54 net@564#7pmos@48_poly-left##55 9.871
R993 net@564#7pmos@48_poly-left##55 net@564#11nmos@48_poly-right 9.871
R994 Cin#18pmos@49_poly-right Cin#18pmos@49_poly-right##0 9.871
R995 Cin#18pmos@49_poly-right##0 Cin#18pmos@49_poly-right##1 9.871
R996 Cin#18pmos@49_poly-right##1 Cin#18pmos@49_poly-right##2 9.871
R997 Cin#18pmos@49_poly-right##2 Cin#18pmos@49_poly-right##3 9.871
R998 Cin#18pmos@49_poly-right##3 Cin#18pmos@49_poly-right##4 9.871
R999 Cin#18pmos@49_poly-right##4 Cin#18pmos@49_poly-right##5 9.871
R1000 Cin#18pmos@49_poly-right##5 Cin#18pmos@49_poly-right##6 9.871
R1001 Cin#18pmos@49_poly-right##6 Cin#18pmos@49_poly-right##7 9.871
R1002 Cin#18pmos@49_poly-right##7 Cin#18pmos@49_poly-right##8 9.871
R1003 Cin#18pmos@49_poly-right##8 Cin#18pmos@49_poly-right##9 9.871
R1004 Cin#18pmos@49_poly-right##9 Cin#18pmos@49_poly-right##10 9.871
R1005 Cin#18pmos@49_poly-right##10 Cin#18pmos@49_poly-right##11 9.871
R1006 Cin#18pmos@49_poly-right##11 Cin#18pmos@49_poly-right##12 9.871
R1007 Cin#18pmos@49_poly-right##12 Cin#18pmos@49_poly-right##13 9.871
R1008 Cin#18pmos@49_poly-right##13 Cin#18pmos@49_poly-right##14 9.871
R1009 Cin#18pmos@49_poly-right##14 Cin#18pmos@49_poly-right##15 9.871
R1010 Cin#18pmos@49_poly-right##15 Cin#18pmos@49_poly-right##16 9.871
R1011 Cin#18pmos@49_poly-right##16 Cin#18pmos@49_poly-right##17 9.871
R1012 Cin#18pmos@49_poly-right##17 Cin#18pmos@49_poly-right##18 9.871
R1013 Cin#18pmos@49_poly-right##18 Cin#18pmos@49_poly-right##19 9.871
R1014 Cin#18pmos@49_poly-right##19 Cin#18pmos@49_poly-right##20 9.871
R1015 Cin#18pmos@49_poly-right##20 Cin#18pmos@49_poly-right##21 9.871
R1016 Cin#18pmos@49_poly-right##21 Cin#18pmos@49_poly-right##22 9.871
R1017 Cin#18pmos@49_poly-right##22 Cin#18pmos@49_poly-right##23 9.871
R1018 Cin#18pmos@49_poly-right##23 Cin#18pmos@49_poly-right##24 9.871
R1019 Cin#18pmos@49_poly-right##24 Cin#18pmos@49_poly-right##25 9.871
R1020 Cin#18pmos@49_poly-right##25 Cin#18pmos@49_poly-right##26 9.871
R1021 Cin#18pmos@49_poly-right##26 Cin#18pmos@49_poly-right##27 9.871
R1022 Cin#18pmos@49_poly-right##27 Cin#18pmos@49_poly-right##28 9.871
R1023 Cin#18pmos@49_poly-right##28 Cin#18pmos@49_poly-right##29 9.871
R1024 Cin#18pmos@49_poly-right##29 Cin#18pmos@49_poly-right##30 9.871
R1025 Cin#18pmos@49_poly-right##30 Cin#18pmos@49_poly-right##31 9.871
R1026 Cin#18pmos@49_poly-right##31 Cin#18pmos@49_poly-right##32 9.871
R1027 Cin#18pmos@49_poly-right##32 Cin#18pmos@49_poly-right##33 9.871
R1028 Cin#18pmos@49_poly-right##33 Cin#18pmos@49_poly-right##34 9.871
R1029 Cin#18pmos@49_poly-right##34 Cin#18pmos@49_poly-right##35 9.871
R1030 Cin#18pmos@49_poly-right##35 Cin#18pmos@49_poly-right##36 9.871
R1031 Cin#18pmos@49_poly-right##36 Cin#18pmos@49_poly-right##37 9.871
R1032 Cin#18pmos@49_poly-right##37 Cin#18pmos@49_poly-right##38 9.871
R1033 Cin#18pmos@49_poly-right##38 Cin#18pmos@49_poly-right##39 9.871
R1034 Cin#18pmos@49_poly-right##39 Cin#18pmos@49_poly-right##40 9.871
R1035 Cin#18pmos@49_poly-right##40 Cin#18pmos@49_poly-right##41 9.871
R1036 Cin#18pmos@49_poly-right##41 Cin#18pmos@49_poly-right##42 9.871
R1037 Cin#18pmos@49_poly-right##42 Cin#18pmos@49_poly-right##43 9.871
R1038 Cin#18pmos@49_poly-right##43 Cin#18pmos@49_poly-right##44 9.871
R1039 Cin#18pmos@49_poly-right##44 Cin#18pmos@49_poly-right##45 9.871
R1040 Cin#18pmos@49_poly-right##45 Cin#18pmos@49_poly-right##46 9.871
R1041 Cin#18pmos@49_poly-right##46 Cin#18pmos@49_poly-right##47 9.871
R1042 Cin#18pmos@49_poly-right##47 Cin#18pmos@49_poly-right##48 9.871
R1043 Cin#18pmos@49_poly-right##48 Cin#18pmos@49_poly-right##49 9.871
R1044 Cin#18pmos@49_poly-right##49 Cin#18pmos@49_poly-right##50 9.871
R1045 Cin#18pmos@49_poly-right##50 Cin#18pmos@49_poly-right##51 9.871
R1046 Cin#18pmos@49_poly-right##51 Cin#18pmos@49_poly-right##52 9.871
R1047 Cin#18pmos@49_poly-right##52 Cin#18pmos@49_poly-right##53 9.871
R1048 Cin#18pmos@49_poly-right##53 Cin#18pmos@49_poly-right##54 9.871
R1049 Cin#18pmos@49_poly-right##54 Cin#18pmos@49_poly-right##55 9.871
R1050 Cin#18pmos@49_poly-right##55 Cin#9nmos@49_poly-left 9.871
R1051 net@577#14pmos@50_poly-right net@577#14pmos@50_poly-right##0 9.871
R1052 net@577#14pmos@50_poly-right##0 net@577#14pmos@50_poly-right##1 9.871
R1053 net@577#14pmos@50_poly-right##1 net@577#14pmos@50_poly-right##2 9.871
R1054 net@577#14pmos@50_poly-right##2 net@577#14pmos@50_poly-right##3 9.871
R1055 net@577#14pmos@50_poly-right##3 net@577#14pmos@50_poly-right##4 9.871
R1056 net@577#14pmos@50_poly-right##4 net@577#14pmos@50_poly-right##5 9.871
R1057 net@577#14pmos@50_poly-right##5 net@577#14pmos@50_poly-right##6 9.871
R1058 net@577#14pmos@50_poly-right##6 net@577#14pmos@50_poly-right##7 9.871
R1059 net@577#14pmos@50_poly-right##7 net@577#14pmos@50_poly-right##8 9.871
R1060 net@577#14pmos@50_poly-right##8 net@577#14pmos@50_poly-right##9 9.871
R1061 net@577#14pmos@50_poly-right##9 net@577#14pmos@50_poly-right##10 9.871
R1062 net@577#14pmos@50_poly-right##10 net@577#14pmos@50_poly-right##11 9.871
R1063 net@577#14pmos@50_poly-right##11 net@577#14pmos@50_poly-right##12 9.871
R1064 net@577#14pmos@50_poly-right##12 net@577#14pmos@50_poly-right##13 9.871
R1065 net@577#14pmos@50_poly-right##13 net@577#14pmos@50_poly-right##14 9.871
R1066 net@577#14pmos@50_poly-right##14 net@577#14pmos@50_poly-right##15 9.871
R1067 net@577#14pmos@50_poly-right##15 net@577#14pmos@50_poly-right##16 9.871
R1068 net@577#14pmos@50_poly-right##16 net@577#14pmos@50_poly-right##17 9.871
R1069 net@577#14pmos@50_poly-right##17 net@577#14pmos@50_poly-right##18 9.871
R1070 net@577#14pmos@50_poly-right##18 net@577#14pmos@50_poly-right##19 9.871
R1071 net@577#14pmos@50_poly-right##19 net@577#14pmos@50_poly-right##20 9.871
R1072 net@577#14pmos@50_poly-right##20 net@577#14pmos@50_poly-right##21 9.871
R1073 net@577#14pmos@50_poly-right##21 net@577#14pmos@50_poly-right##22 9.871
R1074 net@577#14pmos@50_poly-right##22 net@577#14pmos@50_poly-right##23 9.871
R1075 net@577#14pmos@50_poly-right##23 net@577#14pmos@50_poly-right##24 9.871
R1076 net@577#14pmos@50_poly-right##24 net@577#14pmos@50_poly-right##25 9.871
R1077 net@577#14pmos@50_poly-right##25 net@577#14pmos@50_poly-right##26 9.871
R1078 net@577#14pmos@50_poly-right##26 net@577#14pmos@50_poly-right##27 9.871
R1079 net@577#14pmos@50_poly-right##27 net@577#14pmos@50_poly-right##28 9.871
R1080 net@577#14pmos@50_poly-right##28 net@577#14pmos@50_poly-right##29 9.871
R1081 net@577#14pmos@50_poly-right##29 net@577#14pmos@50_poly-right##30 9.871
R1082 net@577#14pmos@50_poly-right##30 net@577#14pmos@50_poly-right##31 9.871
R1083 net@577#14pmos@50_poly-right##31 net@577#14pmos@50_poly-right##32 9.871
R1084 net@577#14pmos@50_poly-right##32 net@577#14pmos@50_poly-right##33 9.871
R1085 net@577#14pmos@50_poly-right##33 net@577#14pmos@50_poly-right##34 9.871
R1086 net@577#14pmos@50_poly-right##34 net@577#14pmos@50_poly-right##35 9.871
R1087 net@577#14pmos@50_poly-right##35 net@577#14pmos@50_poly-right##36 9.871
R1088 net@577#14pmos@50_poly-right##36 net@577#14pmos@50_poly-right##37 9.871
R1089 net@577#14pmos@50_poly-right##37 net@577#14pmos@50_poly-right##38 9.871
R1090 net@577#14pmos@50_poly-right##38 net@577#14pmos@50_poly-right##39 9.871
R1091 net@577#14pmos@50_poly-right##39 net@577#14pmos@50_poly-right##40 9.871
R1092 net@577#14pmos@50_poly-right##40 net@577#14pmos@50_poly-right##41 9.871
R1093 net@577#14pmos@50_poly-right##41 net@577#14pmos@50_poly-right##42 9.871
R1094 net@577#14pmos@50_poly-right##42 net@577#14pmos@50_poly-right##43 9.871
R1095 net@577#14pmos@50_poly-right##43 net@577#14pmos@50_poly-right##44 9.871
R1096 net@577#14pmos@50_poly-right##44 net@577#14pmos@50_poly-right##45 9.871
R1097 net@577#14pmos@50_poly-right##45 net@577#14pmos@50_poly-right##46 9.871
R1098 net@577#14pmos@50_poly-right##46 net@577#14pmos@50_poly-right##47 9.871
R1099 net@577#14pmos@50_poly-right##47 net@577#14pmos@50_poly-right##48 9.871
R1100 net@577#14pmos@50_poly-right##48 net@577#14pmos@50_poly-right##49 9.871
R1101 net@577#14pmos@50_poly-right##49 net@577#14pmos@50_poly-right##50 9.871
R1102 net@577#14pmos@50_poly-right##50 net@577#14pmos@50_poly-right##51 9.871
R1103 net@577#14pmos@50_poly-right##51 net@577#14pmos@50_poly-right##52 9.871
R1104 net@577#14pmos@50_poly-right##52 net@577#14pmos@50_poly-right##53 9.871
R1105 net@577#14pmos@50_poly-right##53 net@577#14pmos@50_poly-right##54 9.871
R1106 net@577#14pmos@50_poly-right##54 net@577#14pmos@50_poly-right##55 9.871
R1107 net@577#14pmos@50_poly-right##55 net@577#9nmos@50_poly-left 9.871
R1108 net@576#2contact@295_metal-1-polysilicon-1 net@576 4.654
R1109 net@576#12pmos@53_poly-right net@576#12pmos@53_poly-right##0 9.931
R1110 net@576#12pmos@53_poly-right##0 net@576#12pmos@53_poly-right##1 9.931
R1111 net@576#12pmos@53_poly-right##1 net@576#12pmos@53_poly-right##2 9.931
R1112 net@576#12pmos@53_poly-right##2 net@576#12pmos@53_poly-right##3 9.931
R1113 net@576#12pmos@53_poly-right##3 net@576#12pmos@53_poly-right##4 9.931
R1114 net@576#12pmos@53_poly-right##4 net@576#12pmos@53_poly-right##5 9.931
R1115 net@576#12pmos@53_poly-right##5 net@576#12pmos@53_poly-right##6 9.931
R1116 net@576#12pmos@53_poly-right##6 net@576#12pmos@53_poly-right##7 9.931
R1117 net@576#12pmos@53_poly-right##7 net@576#12pmos@53_poly-right##8 9.931
R1118 net@576#12pmos@53_poly-right##8 net@576#12pmos@53_poly-right##9 9.931
R1119 net@576#12pmos@53_poly-right##9 net@576#12pmos@53_poly-right##10 9.931
R1120 net@576#12pmos@53_poly-right##10 net@576#12pmos@53_poly-right##11 9.931
R1121 net@576#12pmos@53_poly-right##11 net@576#12pmos@53_poly-right##12 9.931
R1122 net@576#12pmos@53_poly-right##12 net@576#12pmos@53_poly-right##13 9.931
R1123 net@576#12pmos@53_poly-right##13 net@576#12pmos@53_poly-right##14 9.931
R1124 net@576#12pmos@53_poly-right##14 net@576#12pmos@53_poly-right##15 9.931
R1125 net@576#12pmos@53_poly-right##15 net@576#12pmos@53_poly-right##16 9.931
R1126 net@576#12pmos@53_poly-right##16 net@576#12pmos@53_poly-right##17 9.931
R1127 net@576#12pmos@53_poly-right##17 net@576#12pmos@53_poly-right##18 9.931
R1128 net@576#12pmos@53_poly-right##18 net@576#12pmos@53_poly-right##19 9.931
R1129 net@576#12pmos@53_poly-right##19 net@576#12pmos@53_poly-right##20 9.931
R1130 net@576#12pmos@53_poly-right##20 net@576#12pmos@53_poly-right##21 9.931
R1131 net@576#12pmos@53_poly-right##21 net@576#12pmos@53_poly-right##22 9.931
R1132 net@576#12pmos@53_poly-right##22 net@576#12pmos@53_poly-right##23 9.931
R1133 net@576#12pmos@53_poly-right##23 net@576#12pmos@53_poly-right##24 9.931
R1134 net@576#12pmos@53_poly-right##24 net@576#12pmos@53_poly-right##25 9.931
R1135 net@576#12pmos@53_poly-right##25 net@576#12pmos@53_poly-right##26 9.931
R1136 net@576#12pmos@53_poly-right##26 net@576#12pmos@53_poly-right##27 9.931
R1137 net@576#12pmos@53_poly-right##27 net@576#12pmos@53_poly-right##28 9.931
R1138 net@576#12pmos@53_poly-right##28 net@576#12pmos@53_poly-right##29 9.931
R1139 net@576#12pmos@53_poly-right##29 net@576#12pmos@53_poly-right##30 9.931
R1140 net@576#12pmos@53_poly-right##30 net@576#12pmos@53_poly-right##31 9.931
R1141 net@576#12pmos@53_poly-right##31 net@576#12pmos@53_poly-right##32 9.931
R1142 net@576#12pmos@53_poly-right##32 net@576#12pmos@53_poly-right##33 9.931
R1143 net@576#12pmos@53_poly-right##33 net@576#12pmos@53_poly-right##34 9.931
R1144 net@576#12pmos@53_poly-right##34 net@576#12pmos@53_poly-right##35 9.931
R1145 net@576#12pmos@53_poly-right##35 net@576#12pmos@53_poly-right##36 9.931
R1146 net@576#12pmos@53_poly-right##36 net@576#12pmos@53_poly-right##37 9.931
R1147 net@576#12pmos@53_poly-right##37 net@576#12pmos@53_poly-right##38 9.931
R1148 net@576#12pmos@53_poly-right##38 net@576#12pmos@53_poly-right##39 9.931
R1149 net@576#12pmos@53_poly-right##39 net@576#12pmos@53_poly-right##40 9.931
R1150 net@576#12pmos@53_poly-right##40 net@576#12pmos@53_poly-right##41 9.931
R1151 net@576#12pmos@53_poly-right##41 net@576#12pmos@53_poly-right##42 9.931
R1152 net@576#12pmos@53_poly-right##42 net@576#12pmos@53_poly-right##43 9.931
R1153 net@576#12pmos@53_poly-right##43 net@576#12pmos@53_poly-right##44 9.931
R1154 net@576#12pmos@53_poly-right##44 net@576#12pmos@53_poly-right##45 9.931
R1155 net@576#12pmos@53_poly-right##45 net@576#12pmos@53_poly-right##46 9.931
R1156 net@576#12pmos@53_poly-right##46 net@576#12pmos@53_poly-right##47 9.931
R1157 net@576#12pmos@53_poly-right##47 net@576#12pmos@53_poly-right##48 9.931
R1158 net@576#12pmos@53_poly-right##48 net@576#12pmos@53_poly-right##49 9.931
R1159 net@576#12pmos@53_poly-right##49 net@576#12pmos@53_poly-right##50 9.931
R1160 net@576#12pmos@53_poly-right##50 net@576#12pmos@53_poly-right##51 9.931
R1161 net@576#12pmos@53_poly-right##51 net@576#12pmos@53_poly-right##52 9.931
R1162 net@576#12pmos@53_poly-right##52 net@576#5pin@195_polysilicon-1 9.931
R1163 Sum0#4pmos@53_diff-top Sum0 4.823
R1164 XOR1_to_NAND1#14pin@207_polysilicon-1 XOR1_to_NAND1#14pin@207_polysilicon-1##0 9.854
R1165 XOR1_to_NAND1#14pin@207_polysilicon-1##0 XOR1_to_NAND1#14pin@207_polysilicon-1##1 9.854
R1166 XOR1_to_NAND1#14pin@207_polysilicon-1##1 XOR1_to_NAND1#14pin@207_polysilicon-1##2 9.854
R1167 XOR1_to_NAND1#14pin@207_polysilicon-1##2 XOR1_to_NAND1#14pin@207_polysilicon-1##3 9.854
R1168 XOR1_to_NAND1#14pin@207_polysilicon-1##3 XOR1_to_NAND1#14pin@207_polysilicon-1##4 9.854
R1169 XOR1_to_NAND1#14pin@207_polysilicon-1##4 XOR1_to_NAND1#14pin@207_polysilicon-1##5 9.854
R1170 XOR1_to_NAND1#14pin@207_polysilicon-1##5 XOR1_to_NAND1#14pin@207_polysilicon-1##6 9.854
R1171 XOR1_to_NAND1#14pin@207_polysilicon-1##6 XOR1_to_NAND1#14pin@207_polysilicon-1##7 9.854
R1172 XOR1_to_NAND1#14pin@207_polysilicon-1##7 XOR1_to_NAND1#14pin@207_polysilicon-1##8 9.854
R1173 XOR1_to_NAND1#14pin@207_polysilicon-1##8 XOR1_to_NAND1#14pin@207_polysilicon-1##9 9.854
R1174 XOR1_to_NAND1#14pin@207_polysilicon-1##9 XOR1_to_NAND1#14pin@207_polysilicon-1##10 9.854
R1175 XOR1_to_NAND1#14pin@207_polysilicon-1##10 XOR1_to_NAND1#14pin@207_polysilicon-1##11 9.854
R1176 XOR1_to_NAND1#14pin@207_polysilicon-1##11 XOR1_to_NAND1#14pin@207_polysilicon-1##12 9.854
R1177 XOR1_to_NAND1#14pin@207_polysilicon-1##12 XOR1_to_NAND1#14pin@207_polysilicon-1##13 9.854
R1178 XOR1_to_NAND1#14pin@207_polysilicon-1##13 XOR1_to_NAND1#14pin@207_polysilicon-1##14 9.854
R1179 XOR1_to_NAND1#14pin@207_polysilicon-1##14 XOR1_to_NAND1#14pin@207_polysilicon-1##15 9.854
R1180 XOR1_to_NAND1#14pin@207_polysilicon-1##15 XOR1_to_NAND1#14pin@207_polysilicon-1##16 9.854
R1181 XOR1_to_NAND1#14pin@207_polysilicon-1##16 XOR1_to_NAND1#14pin@207_polysilicon-1##17 9.854
R1182 XOR1_to_NAND1#14pin@207_polysilicon-1##17 XOR1_to_NAND1#14pin@207_polysilicon-1##18 9.854
R1183 XOR1_to_NAND1#14pin@207_polysilicon-1##18 XOR1_to_NAND1#14pin@207_polysilicon-1##19 9.854
R1184 XOR1_to_NAND1#14pin@207_polysilicon-1##19 XOR1_to_NAND1#14pin@207_polysilicon-1##20 9.854
R1185 XOR1_to_NAND1#14pin@207_polysilicon-1##20 XOR1_to_NAND1#14pin@207_polysilicon-1##21 9.854
R1186 XOR1_to_NAND1#14pin@207_polysilicon-1##21 XOR1_to_NAND1#14pin@207_polysilicon-1##22 9.854
R1187 XOR1_to_NAND1#14pin@207_polysilicon-1##22 XOR1_to_NAND1#14pin@207_polysilicon-1##23 9.854
R1188 XOR1_to_NAND1#14pin@207_polysilicon-1##23 XOR1_to_NAND1#14pin@207_polysilicon-1##24 9.854
R1189 XOR1_to_NAND1#14pin@207_polysilicon-1##24 XOR1_to_NAND1#14pin@207_polysilicon-1##25 9.854
R1190 XOR1_to_NAND1#14pin@207_polysilicon-1##25 XOR1_to_NAND1#14pin@207_polysilicon-1##26 9.854
R1191 XOR1_to_NAND1#14pin@207_polysilicon-1##26 XOR1_to_NAND1#14pin@207_polysilicon-1##27 9.854
R1192 XOR1_to_NAND1#14pin@207_polysilicon-1##27 XOR1_to_NAND1#14pin@207_polysilicon-1##28 9.854
R1193 XOR1_to_NAND1#14pin@207_polysilicon-1##28 XOR1_to_NAND1#14pin@207_polysilicon-1##29 9.854
R1194 XOR1_to_NAND1#14pin@207_polysilicon-1##29 XOR1_to_NAND1#14pin@207_polysilicon-1##30 9.854
R1195 XOR1_to_NAND1#14pin@207_polysilicon-1##30 XOR1_to_NAND1#14pin@207_polysilicon-1##31 9.854
R1196 XOR1_to_NAND1#14pin@207_polysilicon-1##31 XOR1_to_NAND1#14pin@207_polysilicon-1##32 9.854
R1197 XOR1_to_NAND1#14pin@207_polysilicon-1##32 XOR1_to_NAND1#14pin@207_polysilicon-1##33 9.854
R1198 XOR1_to_NAND1#14pin@207_polysilicon-1##33 XOR1_to_NAND1#14pin@207_polysilicon-1##34 9.854
R1199 XOR1_to_NAND1#14pin@207_polysilicon-1##34 XOR1_to_NAND1#14pin@207_polysilicon-1##35 9.854
R1200 XOR1_to_NAND1#14pin@207_polysilicon-1##35 XOR1_to_NAND1#14pin@207_polysilicon-1##36 9.854
R1201 XOR1_to_NAND1#14pin@207_polysilicon-1##36 XOR1_to_NAND1#14pin@207_polysilicon-1##37 9.854
R1202 XOR1_to_NAND1#14pin@207_polysilicon-1##37 XOR1_to_NAND1#14pin@207_polysilicon-1##38 9.854
R1203 XOR1_to_NAND1#14pin@207_polysilicon-1##38 XOR1_to_NAND1#14pin@207_polysilicon-1##39 9.854
R1204 XOR1_to_NAND1#14pin@207_polysilicon-1##39 XOR1_to_NAND1#14pin@207_polysilicon-1##40 9.854
R1205 XOR1_to_NAND1#14pin@207_polysilicon-1##40 XOR1_to_NAND1#14pin@207_polysilicon-1##41 9.854
R1206 XOR1_to_NAND1#14pin@207_polysilicon-1##41 XOR1_to_NAND1#14pin@207_polysilicon-1##42 9.854
R1207 XOR1_to_NAND1#14pin@207_polysilicon-1##42 XOR1_to_NAND1#14pin@207_polysilicon-1##43 9.854
R1208 XOR1_to_NAND1#14pin@207_polysilicon-1##43 XOR1_to_NAND1#14pin@207_polysilicon-1##44 9.854
R1209 XOR1_to_NAND1#14pin@207_polysilicon-1##44 XOR1_to_NAND1#14pin@207_polysilicon-1##45 9.854
R1210 XOR1_to_NAND1#14pin@207_polysilicon-1##45 XOR1_to_NAND1#14pin@207_polysilicon-1##46 9.854
R1211 XOR1_to_NAND1#14pin@207_polysilicon-1##46 XOR1_to_NAND1#14pin@207_polysilicon-1##47 9.854
R1212 XOR1_to_NAND1#14pin@207_polysilicon-1##47 XOR1_to_NAND1#14pin@207_polysilicon-1##48 9.854
R1213 XOR1_to_NAND1#14pin@207_polysilicon-1##48 XOR1_to_NAND1#14pin@207_polysilicon-1##49 9.854
R1214 XOR1_to_NAND1#14pin@207_polysilicon-1##49 XOR1_to_NAND1#14pin@207_polysilicon-1##50 9.854
R1215 XOR1_to_NAND1#14pin@207_polysilicon-1##50 XOR1_to_NAND1#14pin@207_polysilicon-1##51 9.854
R1216 XOR1_to_NAND1#14pin@207_polysilicon-1##51 XOR1_to_NAND1#14pin@207_polysilicon-1##52 9.854
R1217 XOR1_to_NAND1#14pin@207_polysilicon-1##52 XOR1_to_NAND1#14pin@207_polysilicon-1##53 9.854
R1218 XOR1_to_NAND1#14pin@207_polysilicon-1##53 XOR1_to_NAND1#14pin@207_polysilicon-1##54 9.854
R1219 XOR1_to_NAND1#14pin@207_polysilicon-1##54 XOR1_to_NAND1#27nmos@54_poly-right 9.854
R1220 Cin#20pmos@55_poly-right Cin#20pmos@55_poly-right##0 9.877
R1221 Cin#20pmos@55_poly-right##0 Cin#20pmos@55_poly-right##1 9.877
R1222 Cin#20pmos@55_poly-right##1 Cin#20pmos@55_poly-right##2 9.877
R1223 Cin#20pmos@55_poly-right##2 Cin#20pmos@55_poly-right##3 9.877
R1224 Cin#20pmos@55_poly-right##3 Cin#20pmos@55_poly-right##4 9.877
R1225 Cin#20pmos@55_poly-right##4 Cin#20pmos@55_poly-right##5 9.877
R1226 Cin#20pmos@55_poly-right##5 Cin#20pmos@55_poly-right##6 9.877
R1227 Cin#20pmos@55_poly-right##6 Cin#20pmos@55_poly-right##7 9.877
R1228 Cin#20pmos@55_poly-right##7 Cin#20pmos@55_poly-right##8 9.877
R1229 Cin#20pmos@55_poly-right##8 Cin#20pmos@55_poly-right##9 9.877
R1230 Cin#20pmos@55_poly-right##9 Cin#20pmos@55_poly-right##10 9.877
R1231 Cin#20pmos@55_poly-right##10 Cin#20pmos@55_poly-right##11 9.877
R1232 Cin#20pmos@55_poly-right##11 Cin#20pmos@55_poly-right##12 9.877
R1233 Cin#20pmos@55_poly-right##12 Cin#20pmos@55_poly-right##13 9.877
R1234 Cin#20pmos@55_poly-right##13 Cin#20pmos@55_poly-right##14 9.877
R1235 Cin#20pmos@55_poly-right##14 Cin#20pmos@55_poly-right##15 9.877
R1236 Cin#20pmos@55_poly-right##15 Cin#20pmos@55_poly-right##16 9.877
R1237 Cin#20pmos@55_poly-right##16 Cin#20pmos@55_poly-right##17 9.877
R1238 Cin#20pmos@55_poly-right##17 Cin#20pmos@55_poly-right##18 9.877
R1239 Cin#20pmos@55_poly-right##18 Cin#20pmos@55_poly-right##19 9.877
R1240 Cin#20pmos@55_poly-right##19 Cin#20pmos@55_poly-right##20 9.877
R1241 Cin#20pmos@55_poly-right##20 Cin#20pmos@55_poly-right##21 9.877
R1242 Cin#20pmos@55_poly-right##21 Cin#20pmos@55_poly-right##22 9.877
R1243 Cin#20pmos@55_poly-right##22 Cin#20pmos@55_poly-right##23 9.877
R1244 Cin#20pmos@55_poly-right##23 Cin#20pmos@55_poly-right##24 9.877
R1245 Cin#20pmos@55_poly-right##24 Cin#20pmos@55_poly-right##25 9.877
R1246 Cin#20pmos@55_poly-right##25 Cin#20pmos@55_poly-right##26 9.877
R1247 Cin#20pmos@55_poly-right##26 Cin#20pmos@55_poly-right##27 9.877
R1248 Cin#20pmos@55_poly-right##27 Cin#20pmos@55_poly-right##28 9.877
R1249 Cin#20pmos@55_poly-right##28 Cin#20pmos@55_poly-right##29 9.877
R1250 Cin#20pmos@55_poly-right##29 Cin#20pmos@55_poly-right##30 9.877
R1251 Cin#20pmos@55_poly-right##30 Cin#20pmos@55_poly-right##31 9.877
R1252 Cin#20pmos@55_poly-right##31 Cin#20pmos@55_poly-right##32 9.877
R1253 Cin#20pmos@55_poly-right##32 Cin#20pmos@55_poly-right##33 9.877
R1254 Cin#20pmos@55_poly-right##33 Cin#20pmos@55_poly-right##34 9.877
R1255 Cin#20pmos@55_poly-right##34 Cin#20pmos@55_poly-right##35 9.877
R1256 Cin#20pmos@55_poly-right##35 Cin#20pmos@55_poly-right##36 9.877
R1257 Cin#20pmos@55_poly-right##36 Cin#20pmos@55_poly-right##37 9.877
R1258 Cin#20pmos@55_poly-right##37 Cin#20pmos@55_poly-right##38 9.877
R1259 Cin#20pmos@55_poly-right##38 Cin#20pmos@55_poly-right##39 9.877
R1260 Cin#20pmos@55_poly-right##39 Cin#20pmos@55_poly-right##40 9.877
R1261 Cin#20pmos@55_poly-right##40 Cin#20pmos@55_poly-right##41 9.877
R1262 Cin#20pmos@55_poly-right##41 Cin#20pmos@55_poly-right##42 9.877
R1263 Cin#20pmos@55_poly-right##42 Cin#20pmos@55_poly-right##43 9.877
R1264 Cin#20pmos@55_poly-right##43 Cin#20pmos@55_poly-right##44 9.877
R1265 Cin#20pmos@55_poly-right##44 Cin#20pmos@55_poly-right##45 9.877
R1266 Cin#20pmos@55_poly-right##45 Cin#20pmos@55_poly-right##46 9.877
R1267 Cin#20pmos@55_poly-right##46 Cin#20pmos@55_poly-right##47 9.877
R1268 Cin#20pmos@55_poly-right##47 Cin#20pmos@55_poly-right##48 9.877
R1269 Cin#20pmos@55_poly-right##48 Cin#20pmos@55_poly-right##49 9.877
R1270 Cin#20pmos@55_poly-right##49 Cin#14pin@212_polysilicon-1 9.877
R1271 Cin_to_XOR2___NAND2#1contact@534_metal-1-metal-2 Cin_to_XOR2___NAND2#7nmos@55_diff-bottom 4.823
R1272 A0#8pin@215_polysilicon-1 A0#8pin@215_polysilicon-1##0 9.938
R1273 A0#8pin@215_polysilicon-1##0 A0#8pin@215_polysilicon-1##1 9.938
R1274 A0#8pin@215_polysilicon-1##1 A0#8pin@215_polysilicon-1##2 9.938
R1275 A0#8pin@215_polysilicon-1##2 A0#8pin@215_polysilicon-1##3 9.938
R1276 A0#8pin@215_polysilicon-1##3 A0#8pin@215_polysilicon-1##4 9.938
R1277 A0#8pin@215_polysilicon-1##4 A0#8pin@215_polysilicon-1##5 9.938
R1278 A0#8pin@215_polysilicon-1##5 A0#8pin@215_polysilicon-1##6 9.938
R1279 A0#8pin@215_polysilicon-1##6 A0#8pin@215_polysilicon-1##7 9.938
R1280 A0#8pin@215_polysilicon-1##7 A0#8pin@215_polysilicon-1##8 9.938
R1281 A0#8pin@215_polysilicon-1##8 A0#8pin@215_polysilicon-1##9 9.938
R1282 A0#8pin@215_polysilicon-1##9 A0#8pin@215_polysilicon-1##10 9.938
R1283 A0#8pin@215_polysilicon-1##10 A0#8pin@215_polysilicon-1##11 9.938
R1284 A0#8pin@215_polysilicon-1##11 A0#8pin@215_polysilicon-1##12 9.938
R1285 A0#8pin@215_polysilicon-1##12 A0#8pin@215_polysilicon-1##13 9.938
R1286 A0#8pin@215_polysilicon-1##13 A0#8pin@215_polysilicon-1##14 9.938
R1287 A0#8pin@215_polysilicon-1##14 A0#8pin@215_polysilicon-1##15 9.938
R1288 A0#8pin@215_polysilicon-1##15 A0#8pin@215_polysilicon-1##16 9.938
R1289 A0#8pin@215_polysilicon-1##16 A0#8pin@215_polysilicon-1##17 9.938
R1290 A0#8pin@215_polysilicon-1##17 A0#8pin@215_polysilicon-1##18 9.938
R1291 A0#8pin@215_polysilicon-1##18 A0#8pin@215_polysilicon-1##19 9.938
R1292 A0#8pin@215_polysilicon-1##19 A0#8pin@215_polysilicon-1##20 9.938
R1293 A0#8pin@215_polysilicon-1##20 A0#8pin@215_polysilicon-1##21 9.938
R1294 A0#8pin@215_polysilicon-1##21 A0#8pin@215_polysilicon-1##22 9.938
R1295 A0#8pin@215_polysilicon-1##22 A0#8pin@215_polysilicon-1##23 9.938
R1296 A0#8pin@215_polysilicon-1##23 A0#8pin@215_polysilicon-1##24 9.938
R1297 A0#8pin@215_polysilicon-1##24 A0#8pin@215_polysilicon-1##25 9.938
R1298 A0#8pin@215_polysilicon-1##25 A0#8pin@215_polysilicon-1##26 9.938
R1299 A0#8pin@215_polysilicon-1##26 A0#8pin@215_polysilicon-1##27 9.938
R1300 A0#8pin@215_polysilicon-1##27 A0#8pin@215_polysilicon-1##28 9.938
R1301 A0#8pin@215_polysilicon-1##28 A0#8pin@215_polysilicon-1##29 9.938
R1302 A0#8pin@215_polysilicon-1##29 A0#8pin@215_polysilicon-1##30 9.938
R1303 A0#8pin@215_polysilicon-1##30 A0#8pin@215_polysilicon-1##31 9.938
R1304 A0#8pin@215_polysilicon-1##31 A0#8pin@215_polysilicon-1##32 9.938
R1305 A0#8pin@215_polysilicon-1##32 A0#8pin@215_polysilicon-1##33 9.938
R1306 A0#8pin@215_polysilicon-1##33 A0#8pin@215_polysilicon-1##34 9.938
R1307 A0#8pin@215_polysilicon-1##34 A0#8pin@215_polysilicon-1##35 9.938
R1308 A0#8pin@215_polysilicon-1##35 A0#8pin@215_polysilicon-1##36 9.938
R1309 A0#8pin@215_polysilicon-1##36 A0#8pin@215_polysilicon-1##37 9.938
R1310 A0#8pin@215_polysilicon-1##37 A0#8pin@215_polysilicon-1##38 9.938
R1311 A0#8pin@215_polysilicon-1##38 A0#8pin@215_polysilicon-1##39 9.938
R1312 A0#8pin@215_polysilicon-1##39 A0#8pin@215_polysilicon-1##40 9.938
R1313 A0#8pin@215_polysilicon-1##40 A0#8pin@215_polysilicon-1##41 9.938
R1314 A0#8pin@215_polysilicon-1##41 A0#8pin@215_polysilicon-1##42 9.938
R1315 A0#8pin@215_polysilicon-1##42 A0#8pin@215_polysilicon-1##43 9.938
R1316 A0#8pin@215_polysilicon-1##43 A0#8pin@215_polysilicon-1##44 9.938
R1317 A0#8pin@215_polysilicon-1##44 A0#8pin@215_polysilicon-1##45 9.938
R1318 A0#8pin@215_polysilicon-1##45 A0#8pin@215_polysilicon-1##46 9.938
R1319 A0#8pin@215_polysilicon-1##46 A0#8pin@215_polysilicon-1##47 9.938
R1320 A0#8pin@215_polysilicon-1##47 A0#8pin@215_polysilicon-1##48 9.938
R1321 A0#8pin@215_polysilicon-1##48 A0#8pin@215_polysilicon-1##49 9.938
R1322 A0#8pin@215_polysilicon-1##49 A0#17nmos@56_poly-right 9.938
R1323 B0#18pmos@57_poly-right B0#18pmos@57_poly-right##0 9.869
R1324 B0#18pmos@57_poly-right##0 B0#18pmos@57_poly-right##1 9.869
R1325 B0#18pmos@57_poly-right##1 B0#18pmos@57_poly-right##2 9.869
R1326 B0#18pmos@57_poly-right##2 B0#18pmos@57_poly-right##3 9.869
R1327 B0#18pmos@57_poly-right##3 B0#18pmos@57_poly-right##4 9.869
R1328 B0#18pmos@57_poly-right##4 B0#18pmos@57_poly-right##5 9.869
R1329 B0#18pmos@57_poly-right##5 B0#18pmos@57_poly-right##6 9.869
R1330 B0#18pmos@57_poly-right##6 B0#18pmos@57_poly-right##7 9.869
R1331 B0#18pmos@57_poly-right##7 B0#18pmos@57_poly-right##8 9.869
R1332 B0#18pmos@57_poly-right##8 B0#18pmos@57_poly-right##9 9.869
R1333 B0#18pmos@57_poly-right##9 B0#18pmos@57_poly-right##10 9.869
R1334 B0#18pmos@57_poly-right##10 B0#18pmos@57_poly-right##11 9.869
R1335 B0#18pmos@57_poly-right##11 B0#18pmos@57_poly-right##12 9.869
R1336 B0#18pmos@57_poly-right##12 B0#18pmos@57_poly-right##13 9.869
R1337 B0#18pmos@57_poly-right##13 B0#18pmos@57_poly-right##14 9.869
R1338 B0#18pmos@57_poly-right##14 B0#18pmos@57_poly-right##15 9.869
R1339 B0#18pmos@57_poly-right##15 B0#18pmos@57_poly-right##16 9.869
R1340 B0#18pmos@57_poly-right##16 B0#18pmos@57_poly-right##17 9.869
R1341 B0#18pmos@57_poly-right##17 B0#18pmos@57_poly-right##18 9.869
R1342 B0#18pmos@57_poly-right##18 B0#18pmos@57_poly-right##19 9.869
R1343 B0#18pmos@57_poly-right##19 B0#18pmos@57_poly-right##20 9.869
R1344 B0#18pmos@57_poly-right##20 B0#18pmos@57_poly-right##21 9.869
R1345 B0#18pmos@57_poly-right##21 B0#18pmos@57_poly-right##22 9.869
R1346 B0#18pmos@57_poly-right##22 B0#18pmos@57_poly-right##23 9.869
R1347 B0#18pmos@57_poly-right##23 B0#18pmos@57_poly-right##24 9.869
R1348 B0#18pmos@57_poly-right##24 B0#18pmos@57_poly-right##25 9.869
R1349 B0#18pmos@57_poly-right##25 B0#18pmos@57_poly-right##26 9.869
R1350 B0#18pmos@57_poly-right##26 B0#18pmos@57_poly-right##27 9.869
R1351 B0#18pmos@57_poly-right##27 B0#18pmos@57_poly-right##28 9.869
R1352 B0#18pmos@57_poly-right##28 B0#18pmos@57_poly-right##29 9.869
R1353 B0#18pmos@57_poly-right##29 B0#18pmos@57_poly-right##30 9.869
R1354 B0#18pmos@57_poly-right##30 B0#18pmos@57_poly-right##31 9.869
R1355 B0#18pmos@57_poly-right##31 B0#18pmos@57_poly-right##32 9.869
R1356 B0#18pmos@57_poly-right##32 B0#18pmos@57_poly-right##33 9.869
R1357 B0#18pmos@57_poly-right##33 B0#18pmos@57_poly-right##34 9.869
R1358 B0#18pmos@57_poly-right##34 B0#18pmos@57_poly-right##35 9.869
R1359 B0#18pmos@57_poly-right##35 B0#18pmos@57_poly-right##36 9.869
R1360 B0#18pmos@57_poly-right##36 B0#18pmos@57_poly-right##37 9.869
R1361 B0#18pmos@57_poly-right##37 B0#18pmos@57_poly-right##38 9.869
R1362 B0#18pmos@57_poly-right##38 B0#18pmos@57_poly-right##39 9.869
R1363 B0#18pmos@57_poly-right##39 B0#18pmos@57_poly-right##40 9.869
R1364 B0#18pmos@57_poly-right##40 B0#18pmos@57_poly-right##41 9.869
R1365 B0#18pmos@57_poly-right##41 B0#18pmos@57_poly-right##42 9.869
R1366 B0#18pmos@57_poly-right##42 B0#18pmos@57_poly-right##43 9.869
R1367 B0#18pmos@57_poly-right##43 B0#18pmos@57_poly-right##44 9.869
R1368 B0#18pmos@57_poly-right##44 B0#18pmos@57_poly-right##45 9.869
R1369 B0#18pmos@57_poly-right##45 B0#18pmos@57_poly-right##46 9.869
R1370 B0#18pmos@57_poly-right##46 B0#18pmos@57_poly-right##47 9.869
R1371 B0#18pmos@57_poly-right##47 B0#8pin@220_polysilicon-1 9.869
R1372 NAND2_to_Nand3#9pin@224_polysilicon-1 NAND2_to_Nand3#9pin@224_polysilicon-1##0 9.938
R1373 NAND2_to_Nand3#9pin@224_polysilicon-1##0 NAND2_to_Nand3#9pin@224_polysilicon-1##1 9.938
R1374 NAND2_to_Nand3#9pin@224_polysilicon-1##1 NAND2_to_Nand3#9pin@224_polysilicon-1##2 9.938
R1375 NAND2_to_Nand3#9pin@224_polysilicon-1##2 NAND2_to_Nand3#9pin@224_polysilicon-1##3 9.938
R1376 NAND2_to_Nand3#9pin@224_polysilicon-1##3 NAND2_to_Nand3#9pin@224_polysilicon-1##4 9.938
R1377 NAND2_to_Nand3#9pin@224_polysilicon-1##4 NAND2_to_Nand3#9pin@224_polysilicon-1##5 9.938
R1378 NAND2_to_Nand3#9pin@224_polysilicon-1##5 NAND2_to_Nand3#9pin@224_polysilicon-1##6 9.938
R1379 NAND2_to_Nand3#9pin@224_polysilicon-1##6 NAND2_to_Nand3#9pin@224_polysilicon-1##7 9.938
R1380 NAND2_to_Nand3#9pin@224_polysilicon-1##7 NAND2_to_Nand3#9pin@224_polysilicon-1##8 9.938
R1381 NAND2_to_Nand3#9pin@224_polysilicon-1##8 NAND2_to_Nand3#9pin@224_polysilicon-1##9 9.938
R1382 NAND2_to_Nand3#9pin@224_polysilicon-1##9 NAND2_to_Nand3#9pin@224_polysilicon-1##10 9.938
R1383 NAND2_to_Nand3#9pin@224_polysilicon-1##10 NAND2_to_Nand3#9pin@224_polysilicon-1##11 9.938
R1384 NAND2_to_Nand3#9pin@224_polysilicon-1##11 NAND2_to_Nand3#9pin@224_polysilicon-1##12 9.938
R1385 NAND2_to_Nand3#9pin@224_polysilicon-1##12 NAND2_to_Nand3#9pin@224_polysilicon-1##13 9.938
R1386 NAND2_to_Nand3#9pin@224_polysilicon-1##13 NAND2_to_Nand3#9pin@224_polysilicon-1##14 9.938
R1387 NAND2_to_Nand3#9pin@224_polysilicon-1##14 NAND2_to_Nand3#9pin@224_polysilicon-1##15 9.938
R1388 NAND2_to_Nand3#9pin@224_polysilicon-1##15 NAND2_to_Nand3#9pin@224_polysilicon-1##16 9.938
R1389 NAND2_to_Nand3#9pin@224_polysilicon-1##16 NAND2_to_Nand3#9pin@224_polysilicon-1##17 9.938
R1390 NAND2_to_Nand3#9pin@224_polysilicon-1##17 NAND2_to_Nand3#9pin@224_polysilicon-1##18 9.938
R1391 NAND2_to_Nand3#9pin@224_polysilicon-1##18 NAND2_to_Nand3#9pin@224_polysilicon-1##19 9.938
R1392 NAND2_to_Nand3#9pin@224_polysilicon-1##19 NAND2_to_Nand3#9pin@224_polysilicon-1##20 9.938
R1393 NAND2_to_Nand3#9pin@224_polysilicon-1##20 NAND2_to_Nand3#9pin@224_polysilicon-1##21 9.938
R1394 NAND2_to_Nand3#9pin@224_polysilicon-1##21 NAND2_to_Nand3#9pin@224_polysilicon-1##22 9.938
R1395 NAND2_to_Nand3#9pin@224_polysilicon-1##22 NAND2_to_Nand3#9pin@224_polysilicon-1##23 9.938
R1396 NAND2_to_Nand3#9pin@224_polysilicon-1##23 NAND2_to_Nand3#9pin@224_polysilicon-1##24 9.938
R1397 NAND2_to_Nand3#9pin@224_polysilicon-1##24 NAND2_to_Nand3#9pin@224_polysilicon-1##25 9.938
R1398 NAND2_to_Nand3#9pin@224_polysilicon-1##25 NAND2_to_Nand3#9pin@224_polysilicon-1##26 9.938
R1399 NAND2_to_Nand3#9pin@224_polysilicon-1##26 NAND2_to_Nand3#9pin@224_polysilicon-1##27 9.938
R1400 NAND2_to_Nand3#9pin@224_polysilicon-1##27 NAND2_to_Nand3#9pin@224_polysilicon-1##28 9.938
R1401 NAND2_to_Nand3#9pin@224_polysilicon-1##28 NAND2_to_Nand3#9pin@224_polysilicon-1##29 9.938
R1402 NAND2_to_Nand3#9pin@224_polysilicon-1##29 NAND2_to_Nand3#9pin@224_polysilicon-1##30 9.938
R1403 NAND2_to_Nand3#9pin@224_polysilicon-1##30 NAND2_to_Nand3#9pin@224_polysilicon-1##31 9.938
R1404 NAND2_to_Nand3#9pin@224_polysilicon-1##31 NAND2_to_Nand3#9pin@224_polysilicon-1##32 9.938
R1405 NAND2_to_Nand3#9pin@224_polysilicon-1##32 NAND2_to_Nand3#9pin@224_polysilicon-1##33 9.938
R1406 NAND2_to_Nand3#9pin@224_polysilicon-1##33 NAND2_to_Nand3#9pin@224_polysilicon-1##34 9.938
R1407 NAND2_to_Nand3#9pin@224_polysilicon-1##34 NAND2_to_Nand3#9pin@224_polysilicon-1##35 9.938
R1408 NAND2_to_Nand3#9pin@224_polysilicon-1##35 NAND2_to_Nand3#9pin@224_polysilicon-1##36 9.938
R1409 NAND2_to_Nand3#9pin@224_polysilicon-1##36 NAND2_to_Nand3#9pin@224_polysilicon-1##37 9.938
R1410 NAND2_to_Nand3#9pin@224_polysilicon-1##37 NAND2_to_Nand3#9pin@224_polysilicon-1##38 9.938
R1411 NAND2_to_Nand3#9pin@224_polysilicon-1##38 NAND2_to_Nand3#9pin@224_polysilicon-1##39 9.938
R1412 NAND2_to_Nand3#9pin@224_polysilicon-1##39 NAND2_to_Nand3#9pin@224_polysilicon-1##40 9.938
R1413 NAND2_to_Nand3#9pin@224_polysilicon-1##40 NAND2_to_Nand3#9pin@224_polysilicon-1##41 9.938
R1414 NAND2_to_Nand3#9pin@224_polysilicon-1##41 NAND2_to_Nand3#9pin@224_polysilicon-1##42 9.938
R1415 NAND2_to_Nand3#9pin@224_polysilicon-1##42 NAND2_to_Nand3#9pin@224_polysilicon-1##43 9.938
R1416 NAND2_to_Nand3#9pin@224_polysilicon-1##43 NAND2_to_Nand3#9pin@224_polysilicon-1##44 9.938
R1417 NAND2_to_Nand3#9pin@224_polysilicon-1##44 NAND2_to_Nand3#9pin@224_polysilicon-1##45 9.938
R1418 NAND2_to_Nand3#9pin@224_polysilicon-1##45 NAND2_to_Nand3#9pin@224_polysilicon-1##46 9.938
R1419 NAND2_to_Nand3#9pin@224_polysilicon-1##46 NAND2_to_Nand3#9pin@224_polysilicon-1##47 9.938
R1420 NAND2_to_Nand3#9pin@224_polysilicon-1##47 NAND2_to_Nand3#9pin@224_polysilicon-1##48 9.938
R1421 NAND2_to_Nand3#9pin@224_polysilicon-1##48 NAND2_to_Nand3#9pin@224_polysilicon-1##49 9.938
R1422 NAND2_to_Nand3#9pin@224_polysilicon-1##49 NAND2_to_Nand3#11nmos@58_poly-right 9.938
R1423 Cin_to_XOR2___NAND2#17nmos@59_poly-right Cin_to_XOR2___NAND2#17nmos@59_poly-right##0 9.898
R1424 Cin_to_XOR2___NAND2#17nmos@59_poly-right##0 Cin_to_XOR2___NAND2#17nmos@59_poly-right##1 9.898
R1425 Cin_to_XOR2___NAND2#17nmos@59_poly-right##1 Cin_to_XOR2___NAND2#17nmos@59_poly-right##2 9.898
R1426 Cin_to_XOR2___NAND2#17nmos@59_poly-right##2 Cin_to_XOR2___NAND2#17nmos@59_poly-right##3 9.898
R1427 Cin_to_XOR2___NAND2#17nmos@59_poly-right##3 Cin_to_XOR2___NAND2#17nmos@59_poly-right##4 9.898
R1428 Cin_to_XOR2___NAND2#17nmos@59_poly-right##4 Cin_to_XOR2___NAND2#17nmos@59_poly-right##5 9.898
R1429 Cin_to_XOR2___NAND2#17nmos@59_poly-right##5 Cin_to_XOR2___NAND2#17nmos@59_poly-right##6 9.898
R1430 Cin_to_XOR2___NAND2#17nmos@59_poly-right##6 Cin_to_XOR2___NAND2#17nmos@59_poly-right##7 9.898
R1431 Cin_to_XOR2___NAND2#17nmos@59_poly-right##7 Cin_to_XOR2___NAND2#17nmos@59_poly-right##8 9.898
R1432 Cin_to_XOR2___NAND2#17nmos@59_poly-right##8 Cin_to_XOR2___NAND2#17nmos@59_poly-right##9 9.898
R1433 Cin_to_XOR2___NAND2#17nmos@59_poly-right##9 Cin_to_XOR2___NAND2#17nmos@59_poly-right##10 9.898
R1434 Cin_to_XOR2___NAND2#17nmos@59_poly-right##10 Cin_to_XOR2___NAND2#17nmos@59_poly-right##11 9.898
R1435 Cin_to_XOR2___NAND2#17nmos@59_poly-right##11 Cin_to_XOR2___NAND2#17nmos@59_poly-right##12 9.898
R1436 Cin_to_XOR2___NAND2#17nmos@59_poly-right##12 Cin_to_XOR2___NAND2#17nmos@59_poly-right##13 9.898
R1437 Cin_to_XOR2___NAND2#17nmos@59_poly-right##13 Cin_to_XOR2___NAND2#17nmos@59_poly-right##14 9.898
R1438 Cin_to_XOR2___NAND2#17nmos@59_poly-right##14 Cin_to_XOR2___NAND2#17nmos@59_poly-right##15 9.898
R1439 Cin_to_XOR2___NAND2#17nmos@59_poly-right##15 Cin_to_XOR2___NAND2#17nmos@59_poly-right##16 9.898
R1440 Cin_to_XOR2___NAND2#17nmos@59_poly-right##16 Cin_to_XOR2___NAND2#17nmos@59_poly-right##17 9.898
R1441 Cin_to_XOR2___NAND2#17nmos@59_poly-right##17 Cin_to_XOR2___NAND2#17nmos@59_poly-right##18 9.898
R1442 Cin_to_XOR2___NAND2#17nmos@59_poly-right##18 Cin_to_XOR2___NAND2#17nmos@59_poly-right##19 9.898
R1443 Cin_to_XOR2___NAND2#17nmos@59_poly-right##19 Cin_to_XOR2___NAND2#17nmos@59_poly-right##20 9.898
R1444 Cin_to_XOR2___NAND2#17nmos@59_poly-right##20 Cin_to_XOR2___NAND2#17nmos@59_poly-right##21 9.898
R1445 Cin_to_XOR2___NAND2#17nmos@59_poly-right##21 Cin_to_XOR2___NAND2#17nmos@59_poly-right##22 9.898
R1446 Cin_to_XOR2___NAND2#17nmos@59_poly-right##22 Cin_to_XOR2___NAND2#17nmos@59_poly-right##23 9.898
R1447 Cin_to_XOR2___NAND2#17nmos@59_poly-right##23 Cin_to_XOR2___NAND2#17nmos@59_poly-right##24 9.898
R1448 Cin_to_XOR2___NAND2#17nmos@59_poly-right##24 Cin_to_XOR2___NAND2#17nmos@59_poly-right##25 9.898
R1449 Cin_to_XOR2___NAND2#17nmos@59_poly-right##25 Cin_to_XOR2___NAND2#17nmos@59_poly-right##26 9.898
R1450 Cin_to_XOR2___NAND2#17nmos@59_poly-right##26 Cin_to_XOR2___NAND2#17nmos@59_poly-right##27 9.898
R1451 Cin_to_XOR2___NAND2#17nmos@59_poly-right##27 Cin_to_XOR2___NAND2#17nmos@59_poly-right##28 9.898
R1452 Cin_to_XOR2___NAND2#17nmos@59_poly-right##28 Cin_to_XOR2___NAND2#17nmos@59_poly-right##29 9.898
R1453 Cin_to_XOR2___NAND2#17nmos@59_poly-right##29 Cin_to_XOR2___NAND2#17nmos@59_poly-right##30 9.898
R1454 Cin_to_XOR2___NAND2#17nmos@59_poly-right##30 Cin_to_XOR2___NAND2#17nmos@59_poly-right##31 9.898
R1455 Cin_to_XOR2___NAND2#17nmos@59_poly-right##31 Cin_to_XOR2___NAND2#17nmos@59_poly-right##32 9.898
R1456 Cin_to_XOR2___NAND2#17nmos@59_poly-right##32 Cin_to_XOR2___NAND2#17nmos@59_poly-right##33 9.898
R1457 Cin_to_XOR2___NAND2#17nmos@59_poly-right##33 Cin_to_XOR2___NAND2#17nmos@59_poly-right##34 9.898
R1458 Cin_to_XOR2___NAND2#17nmos@59_poly-right##34 Cin_to_XOR2___NAND2#17nmos@59_poly-right##35 9.898
R1459 Cin_to_XOR2___NAND2#17nmos@59_poly-right##35 Cin_to_XOR2___NAND2#17nmos@59_poly-right##36 9.898
R1460 Cin_to_XOR2___NAND2#17nmos@59_poly-right##36 Cin_to_XOR2___NAND2#17nmos@59_poly-right##37 9.898
R1461 Cin_to_XOR2___NAND2#17nmos@59_poly-right##37 Cin_to_XOR2___NAND2#17nmos@59_poly-right##38 9.898
R1462 Cin_to_XOR2___NAND2#17nmos@59_poly-right##38 Cin_to_XOR2___NAND2#17nmos@59_poly-right##39 9.898
R1463 Cin_to_XOR2___NAND2#17nmos@59_poly-right##39 Cin_to_XOR2___NAND2#17nmos@59_poly-right##40 9.898
R1464 Cin_to_XOR2___NAND2#17nmos@59_poly-right##40 Cin_to_XOR2___NAND2#17nmos@59_poly-right##41 9.898
R1465 Cin_to_XOR2___NAND2#17nmos@59_poly-right##41 Cin_to_XOR2___NAND2#17nmos@59_poly-right##42 9.898
R1466 Cin_to_XOR2___NAND2#17nmos@59_poly-right##42 Cin_to_XOR2___NAND2#17nmos@59_poly-right##43 9.898
R1467 Cin_to_XOR2___NAND2#17nmos@59_poly-right##43 Cin_to_XOR2___NAND2#17nmos@59_poly-right##44 9.898
R1468 Cin_to_XOR2___NAND2#17nmos@59_poly-right##44 Cin_to_XOR2___NAND2#17nmos@59_poly-right##45 9.898
R1469 Cin_to_XOR2___NAND2#17nmos@59_poly-right##45 Cin_to_XOR2___NAND2#17nmos@59_poly-right##46 9.898
R1470 Cin_to_XOR2___NAND2#17nmos@59_poly-right##46 Cin_to_XOR2___NAND2#17nmos@59_poly-right##47 9.898
R1471 Cin_to_XOR2___NAND2#17nmos@59_poly-right##47 Cin_to_XOR2___NAND2#17nmos@59_poly-right##48 9.898
R1472 Cin_to_XOR2___NAND2#17nmos@59_poly-right##48 Cin_to_XOR2___NAND2#17nmos@59_poly-right##49 9.898
R1473 Cin_to_XOR2___NAND2#17nmos@59_poly-right##49 Cin_to_XOR2___NAND2#17nmos@59_poly-right##50 9.898
R1474 Cin_to_XOR2___NAND2#17nmos@59_poly-right##50 Cin_to_XOR2___NAND2#17nmos@59_poly-right##51 9.898
R1475 Cin_to_XOR2___NAND2#17nmos@59_poly-right##51 Cin_to_XOR2___NAND2#17nmos@59_poly-right##52 9.898
R1476 Cin_to_XOR2___NAND2#17nmos@59_poly-right##52 Cin_to_XOR2___NAND2#17nmos@59_poly-right##53 9.898
R1477 Cin_to_XOR2___NAND2#17nmos@59_poly-right##53 Cin_to_XOR2___NAND2#17nmos@59_poly-right##54 9.898
R1478 Cin_to_XOR2___NAND2#17nmos@59_poly-right##54 Cin_to_XOR2___NAND2#17nmos@59_poly-right##55 9.898
R1479 Cin_to_XOR2___NAND2#17nmos@59_poly-right##55 Cin_to_XOR2___NAND2#14pmos@59_poly-right 9.898
R1480 net@733 net@733#2nmos@59_diff-bottom 4.42
R1481 NAND2_to_Nand3 NAND2_to_Nand3#4nmos@57_diff-bottom 4.42
R1482 net@1209 net@1209##0 9.92
R1483 net@1209##0 net@1209##1 9.92
R1484 net@1209##1 net@1209##2 9.92
R1485 net@1209##2 net@1209##3 9.92
R1486 net@1209##3 net@1209##4 9.92
R1487 net@1209##4 net@1209##5 9.92
R1488 net@1209##5 net@1209##6 9.92
R1489 net@1209##6 net@1209##7 9.92
R1490 net@1209##7 net@1209##8 9.92
R1491 net@1209##8 net@1209##9 9.92
R1492 net@1209##9 net@1209##10 9.92
R1493 net@1209##10 net@1209##11 9.92
R1494 net@1209##11 net@1209##12 9.92
R1495 net@1209##12 net@1209##13 9.92
R1496 net@1209##13 net@1209##14 9.92
R1497 net@1209##14 net@1209##15 9.92
R1498 net@1209##15 net@1209##16 9.92
R1499 net@1209##16 net@1209##17 9.92
R1500 net@1209##17 net@1209##18 9.92
R1501 net@1209##18 net@1209#1pin@352_polysilicon-1 9.92
R1502 net@1211 net@1211##0 9.92
R1503 net@1211##0 net@1211##1 9.92
R1504 net@1211##1 net@1211##2 9.92
R1505 net@1211##2 net@1211##3 9.92
R1506 net@1211##3 net@1211##4 9.92
R1507 net@1211##4 net@1211##5 9.92
R1508 net@1211##5 net@1211##6 9.92
R1509 net@1211##6 net@1211##7 9.92
R1510 net@1211##7 net@1211##8 9.92
R1511 net@1211##8 net@1211##9 9.92
R1512 net@1211##9 net@1211##10 9.92
R1513 net@1211##10 net@1211##11 9.92
R1514 net@1211##11 net@1211##12 9.92
R1515 net@1211##12 net@1211##13 9.92
R1516 net@1211##13 net@1211##14 9.92
R1517 net@1211##14 net@1211##15 9.92
R1518 net@1211##15 net@1211##16 9.92
R1519 net@1211##16 net@1211##17 9.92
R1520 net@1211##17 net@1211##18 9.92
R1521 net@1211##18 net@1211#1pin@377_polysilicon-1 9.92
R1522 XOR1_to_NAND2#3pin@378_polysilicon-1 XOR1_to_NAND2#3pin@378_polysilicon-1##0 6.2
R1523 XOR1_to_NAND2#3pin@378_polysilicon-1##0 XOR1_to_NAND2#4pmos@72_poly-right 6.2
R1524 XOR1_to_NAND2#3pin@378_polysilicon-1 XOR1_to_NAND2#3pin@378_polysilicon-1##0 8.138
R1525 XOR1_to_NAND2#3pin@378_polysilicon-1##0 XOR1_to_NAND2#3pin@378_polysilicon-1##1 8.138
R1526 XOR1_to_NAND2#3pin@378_polysilicon-1##1 XOR1_to_NAND2#3pin@378_polysilicon-1##2 8.138
R1527 XOR1_to_NAND2#3pin@378_polysilicon-1##2 XOR1_to_NAND2#1contact@544_metal-1-metal-2 8.138
R1528 Cin_to_XOR2___NAND2#22nmos@71_poly-right Cin_to_XOR2___NAND2#22nmos@71_poly-right##0 5.425
R1529 Cin_to_XOR2___NAND2#22nmos@71_poly-right##0 Cin_to_XOR2___NAND2#23pin@368_polysilicon-1 5.425
R1530 Cin_to_XOR2___NAND2 Cin_to_XOR2___NAND2##0 8.99
R1531 Cin_to_XOR2___NAND2##0 Cin_to_XOR2___NAND2##1 8.99
R1532 Cin_to_XOR2___NAND2##1 Cin_to_XOR2___NAND2##2 8.99
R1533 Cin_to_XOR2___NAND2##2 Cin_to_XOR2___NAND2##3 8.99
R1534 Cin_to_XOR2___NAND2##3 Cin_to_XOR2___NAND2#23pin@368_polysilicon-1 8.99
R1535 A1#4pin@353_polysilicon-1 A1#4pin@353_polysilicon-1##0 6.2
R1536 A1#4pin@353_polysilicon-1##0 A1#5pmos@65_poly-right 6.2
R1537 XOR1_to_NAND2#9pmos@67_poly-left XOR1_to_NAND2#9pmos@67_poly-left##0 8.138
R1538 XOR1_to_NAND2#9pmos@67_poly-left##0 XOR1_to_NAND2#9pmos@67_poly-left##1 8.138
R1539 XOR1_to_NAND2#9pmos@67_poly-left##1 XOR1_to_NAND2#9pmos@67_poly-left##2 8.138
R1540 XOR1_to_NAND2#9pmos@67_poly-left##2 XOR1_to_NAND2#10pin@365_polysilicon-1 8.138
R1541 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##0 9.843
R1542 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##0 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##1 9.843
R1543 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##1 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##2 9.843
R1544 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##2 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##3 9.843
R1545 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##3 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##4 9.843
R1546 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##4 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##5 9.843
R1547 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##5 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##6 9.843
R1548 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##6 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##7 9.843
R1549 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##7 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##8 9.843
R1550 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##8 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##9 9.843
R1551 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##9 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##10 9.843
R1552 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##10 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##11 9.843
R1553 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##11 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##12 9.843
R1554 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##12 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##13 9.843
R1555 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##13 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##14 9.843
R1556 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##14 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##15 9.843
R1557 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##15 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##16 9.843
R1558 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##16 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##17 9.843
R1559 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##17 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##18 9.843
R1560 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1##18 Cin_to_XOR2___NAND2#25pin@375_polysilicon-1 9.843
R1561 net@1220#4nmos@73_poly-right net@1220#4nmos@73_poly-right##0 9.3
R1562 net@1220#4nmos@73_poly-right##0 net@1220#4nmos@73_poly-right##1 9.3
R1563 net@1220#4nmos@73_poly-right##1 net@1220#5pin@370_polysilicon-1 9.3
R1564 net@1220#2contact@530_metal-1-polysilicon-1 net@1220#2contact@530_metal-1-polysilicon-1##0 8.99
R1565 net@1220#2contact@530_metal-1-polysilicon-1##0 net@1220#2contact@530_metal-1-polysilicon-1##1 8.99
R1566 net@1220#2contact@530_metal-1-polysilicon-1##1 net@1220#2contact@530_metal-1-polysilicon-1##2 8.99
R1567 net@1220#2contact@530_metal-1-polysilicon-1##2 net@1220#2contact@530_metal-1-polysilicon-1##3 8.99
R1568 net@1220#2contact@530_metal-1-polysilicon-1##3 net@1220#5pin@370_polysilicon-1 8.99
R1569 A1#4pin@353_polysilicon-1 A1#4pin@353_polysilicon-1##0 8.138
R1570 A1#4pin@353_polysilicon-1##0 A1#4pin@353_polysilicon-1##1 8.138
R1571 A1#4pin@353_polysilicon-1##1 A1#4pin@353_polysilicon-1##2 8.138
R1572 A1#4pin@353_polysilicon-1##2 A1#1pin@517_metal-2 8.138
R1573 XOR1_to_NAND2#1contact@544_metal-1-metal-2 XOR1_to_NAND2#1contact@544_metal-1-metal-2##0 6.717
R1574 XOR1_to_NAND2#1contact@544_metal-1-metal-2##0 XOR1_to_NAND2#1contact@544_metal-1-metal-2##1 6.717
R1575 XOR1_to_NAND2#1contact@544_metal-1-metal-2##1 XOR1_to_NAND2#12pin@366_polysilicon-1 6.717
R1576 XOR1_to_NAND2#10pin@365_polysilicon-1 XOR1_to_NAND2#10pin@365_polysilicon-1##0 7.75
R1577 XOR1_to_NAND2#10pin@365_polysilicon-1##0 XOR1_to_NAND2#10pin@365_polysilicon-1##1 7.75
R1578 XOR1_to_NAND2#10pin@365_polysilicon-1##1 XOR1_to_NAND2#12pin@366_polysilicon-1 7.75
R1579 Cin_to_XOR2___NAND2#25pin@375_polysilicon-1 Cin_to_XOR2___NAND2#25pin@375_polysilicon-1##0 9.743
R1580 Cin_to_XOR2___NAND2#25pin@375_polysilicon-1##0 Cin_to_XOR2___NAND2#25pin@375_polysilicon-1##1 9.743
R1581 Cin_to_XOR2___NAND2#25pin@375_polysilicon-1##1 Cin_to_XOR2___NAND2#25pin@375_polysilicon-1##2 9.743
R1582 Cin_to_XOR2___NAND2#25pin@375_polysilicon-1##2 Cin_to_XOR2___NAND2#25pin@375_polysilicon-1##3 9.743
R1583 Cin_to_XOR2___NAND2#25pin@375_polysilicon-1##3 Cin_to_XOR2___NAND2#25pin@375_polysilicon-1##4 9.743
R1584 Cin_to_XOR2___NAND2#25pin@375_polysilicon-1##4 Cin_to_XOR2___NAND2#25pin@375_polysilicon-1##5 9.743
R1585 Cin_to_XOR2___NAND2#25pin@375_polysilicon-1##5 Cin_to_XOR2___NAND2 9.743
R1586 net@1211#7pmos@68_poly-left net@1211#7pmos@68_poly-left##0 7.75
R1587 net@1211#7pmos@68_poly-left##0 net@1211 7.75
R1588 Cin_to_XOR2___NAND2#26nmos@69_poly-left Cin_to_XOR2___NAND2#26nmos@69_poly-left##0 6.2
R1589 Cin_to_XOR2___NAND2#26nmos@69_poly-left##0 Cin_to_XOR2___NAND2#24pin@358_polysilicon-1 6.2
R1590 net@1221#9nmos@70_poly-left net@1221#9nmos@70_poly-left##0 8.37
R1591 net@1221#9nmos@70_poly-left##0 net@1221#9nmos@70_poly-left##1 8.37
R1592 net@1221#9nmos@70_poly-left##1 net@1221#9nmos@70_poly-left##2 8.37
R1593 net@1221#9nmos@70_poly-left##2 net@1221#9nmos@70_poly-left##3 8.37
R1594 net@1221#9nmos@70_poly-left##3 net@1221#2contact@505_metal-1-metal-2 8.37
R1595 XOR1_to_NAND2 XOR1_to_NAND2##0 6.717
R1596 XOR1_to_NAND2##0 XOR1_to_NAND2##1 6.717
R1597 XOR1_to_NAND2##1 XOR1_to_NAND2#14pin@382_polysilicon-1 6.717
R1598 XOR1_to_NAND2#16pmos@74_poly-right XOR1_to_NAND2#16pmos@74_poly-right##0 6.2
R1599 XOR1_to_NAND2#16pmos@74_poly-right##0 XOR1_to_NAND2#14pin@382_polysilicon-1 6.2
R1600 Cin_to_XOR2___NAND2#31pin@386_polysilicon-1 Cin_to_XOR2___NAND2#31pin@386_polysilicon-1##0 9.688
R1601 Cin_to_XOR2___NAND2#31pin@386_polysilicon-1##0 Cin_to_XOR2___NAND2#31pin@386_polysilicon-1##1 9.688
R1602 Cin_to_XOR2___NAND2#31pin@386_polysilicon-1##1 Cin_to_XOR2___NAND2#31pin@386_polysilicon-1##2 9.688
R1603 Cin_to_XOR2___NAND2#31pin@386_polysilicon-1##2 Cin_to_XOR2___NAND2#28contact@543_metal-1-metal-2 9.688
R1604 Cin_to_XOR2___NAND2#28contact@543_metal-1-metal-2 Cin_to_XOR2___NAND2 4.953
R1605 A1#2contact@552_metal-1-metal-2 A1#2contact@552_metal-1-metal-2##0 6.717
R1606 A1#2contact@552_metal-1-metal-2##0 A1#2contact@552_metal-1-metal-2##1 6.717
R1607 A1#2contact@552_metal-1-metal-2##1 A1#11pin@389_polysilicon-1 6.717
R1608 A1#12pmos@76_poly-right A1#12pmos@76_poly-right##0 9.558
R1609 A1#12pmos@76_poly-right##0 A1#12pmos@76_poly-right##1 9.558
R1610 A1#12pmos@76_poly-right##1 A1#12pmos@76_poly-right##2 9.558
R1611 A1#12pmos@76_poly-right##2 A1#12pmos@76_poly-right##3 9.558
R1612 A1#12pmos@76_poly-right##3 A1#12pmos@76_poly-right##4 9.558
R1613 A1#12pmos@76_poly-right##4 A1#11pin@389_polysilicon-1 9.558
R1614 B1#11pin@393_polysilicon-1 B1#11pin@393_polysilicon-1##0 8.138
R1615 B1#11pin@393_polysilicon-1##0 B1#11pin@393_polysilicon-1##1 8.138
R1616 B1#11pin@393_polysilicon-1##1 B1#11pin@393_polysilicon-1##2 8.138
R1617 B1#11pin@393_polysilicon-1##2 B1#2contact@553_metal-1-metal-2 8.138
R1618 B1#12nmos@64_poly-right B1#12nmos@64_poly-right##0 5.425
R1619 B1#12nmos@64_poly-right##0 B1#13pin@343_polysilicon-1 5.425
R1620 NAND2_to_Nand4 NAND2_to_Nand4##0 6.717
R1621 NAND2_to_Nand4##0 NAND2_to_Nand4##1 6.717
R1622 NAND2_to_Nand4##1 NAND2_to_Nand4#9pin@395_polysilicon-1 6.717
R1623 NAND2_to_Nand4#10pmos@78_poly-right NAND2_to_Nand4#10pmos@78_poly-right##0 9.558
R1624 NAND2_to_Nand4#10pmos@78_poly-right##0 NAND2_to_Nand4#10pmos@78_poly-right##1 9.558
R1625 NAND2_to_Nand4#10pmos@78_poly-right##1 NAND2_to_Nand4#10pmos@78_poly-right##2 9.558
R1626 NAND2_to_Nand4#10pmos@78_poly-right##2 NAND2_to_Nand4#10pmos@78_poly-right##3 9.558
R1627 NAND2_to_Nand4#10pmos@78_poly-right##3 NAND2_to_Nand4#10pmos@78_poly-right##4 9.558
R1628 NAND2_to_Nand4#10pmos@78_poly-right##4 NAND2_to_Nand4#9pin@395_polysilicon-1 9.558
R1629 B1#0pin@508_metal-2 B1#0pin@508_metal-2##0 8.99
R1630 B1#0pin@508_metal-2##0 B1#0pin@508_metal-2##1 8.99
R1631 B1#0pin@508_metal-2##1 B1#0pin@508_metal-2##2 8.99
R1632 B1#0pin@508_metal-2##2 B1#0pin@508_metal-2##3 8.99
R1633 B1#0pin@508_metal-2##3 B1#13pin@343_polysilicon-1 8.99
R1634 Cin_to_XOR2___NAND3#14pmos@79_poly-right Cin_to_XOR2___NAND3#14pmos@79_poly-right##0 5.425
R1635 Cin_to_XOR2___NAND3#14pmos@79_poly-right##0 Cin_to_XOR2___NAND3#15pin@399_polysilicon-1 5.425
R1636 Cin_to_XOR2___NAND3#15pin@399_polysilicon-1 Cin_to_XOR2___NAND3#15pin@399_polysilicon-1##0 9.3
R1637 Cin_to_XOR2___NAND3#15pin@399_polysilicon-1##0 Cin_to_XOR2___NAND3#15pin@399_polysilicon-1##1 9.3
R1638 Cin_to_XOR2___NAND3#15pin@399_polysilicon-1##1 Cin_to_XOR2___NAND3#1contact@646_metal-1-metal-2 9.3
R1639 Cin_to_XOR2___NAND2#33nmos@75_poly-right Cin_to_XOR2___NAND2#33nmos@75_poly-right##0 8.636
R1640 Cin_to_XOR2___NAND2#33nmos@75_poly-right##0 Cin_to_XOR2___NAND2#33nmos@75_poly-right##1 8.636
R1641 Cin_to_XOR2___NAND2#33nmos@75_poly-right##1 Cin_to_XOR2___NAND2#33nmos@75_poly-right##2 8.636
R1642 Cin_to_XOR2___NAND2#33nmos@75_poly-right##2 Cin_to_XOR2___NAND2#33nmos@75_poly-right##3 8.636
R1643 Cin_to_XOR2___NAND2#33nmos@75_poly-right##3 Cin_to_XOR2___NAND2#33nmos@75_poly-right##4 8.636
R1644 Cin_to_XOR2___NAND2#33nmos@75_poly-right##4 Cin_to_XOR2___NAND2#33nmos@75_poly-right##5 8.636
R1645 Cin_to_XOR2___NAND2#33nmos@75_poly-right##5 Cin_to_XOR2___NAND2#31pin@386_polysilicon-1 8.636
R1646 B1#14nmos@77_poly-right B1#14nmos@77_poly-right##0 8.956
R1647 B1#14nmos@77_poly-right##0 B1#14nmos@77_poly-right##1 8.956
R1648 B1#14nmos@77_poly-right##1 B1#14nmos@77_poly-right##2 8.956
R1649 B1#14nmos@77_poly-right##2 B1#14nmos@77_poly-right##3 8.956
R1650 B1#14nmos@77_poly-right##3 B1#14nmos@77_poly-right##4 8.956
R1651 B1#14nmos@77_poly-right##4 B1#14nmos@77_poly-right##5 8.956
R1652 B1#14nmos@77_poly-right##5 B1#14nmos@77_poly-right##6 8.956
R1653 B1#14nmos@77_poly-right##6 B1#14nmos@77_poly-right##7 8.956
R1654 B1#14nmos@77_poly-right##7 B1#11pin@393_polysilicon-1 8.956
R1655 A1#13pmos@60_poly-left A1#13pmos@60_poly-left##0 8.138
R1656 A1#13pmos@60_poly-left##0 A1#13pmos@60_poly-left##1 8.138
R1657 A1#13pmos@60_poly-left##1 A1#13pmos@60_poly-left##2 8.138
R1658 A1#13pmos@60_poly-left##2 A1#14pin@340_polysilicon-1 8.138
R1659 B1#15pin@333_polysilicon-1 B1#15pin@333_polysilicon-1##0 9.843
R1660 B1#15pin@333_polysilicon-1##0 B1#15pin@333_polysilicon-1##1 9.843
R1661 B1#15pin@333_polysilicon-1##1 B1#15pin@333_polysilicon-1##2 9.843
R1662 B1#15pin@333_polysilicon-1##2 B1#15pin@333_polysilicon-1##3 9.843
R1663 B1#15pin@333_polysilicon-1##3 B1#15pin@333_polysilicon-1##4 9.843
R1664 B1#15pin@333_polysilicon-1##4 B1#15pin@333_polysilicon-1##5 9.843
R1665 B1#15pin@333_polysilicon-1##5 B1#15pin@333_polysilicon-1##6 9.843
R1666 B1#15pin@333_polysilicon-1##6 B1#15pin@333_polysilicon-1##7 9.843
R1667 B1#15pin@333_polysilicon-1##7 B1#15pin@333_polysilicon-1##8 9.843
R1668 B1#15pin@333_polysilicon-1##8 B1#15pin@333_polysilicon-1##9 9.843
R1669 B1#15pin@333_polysilicon-1##9 B1#15pin@333_polysilicon-1##10 9.843
R1670 B1#15pin@333_polysilicon-1##10 B1#15pin@333_polysilicon-1##11 9.843
R1671 B1#15pin@333_polysilicon-1##11 B1#15pin@333_polysilicon-1##12 9.843
R1672 B1#15pin@333_polysilicon-1##12 B1#15pin@333_polysilicon-1##13 9.843
R1673 B1#15pin@333_polysilicon-1##13 B1#15pin@333_polysilicon-1##14 9.843
R1674 B1#15pin@333_polysilicon-1##14 B1#15pin@333_polysilicon-1##15 9.843
R1675 B1#15pin@333_polysilicon-1##15 B1#15pin@333_polysilicon-1##16 9.843
R1676 B1#15pin@333_polysilicon-1##16 B1#15pin@333_polysilicon-1##17 9.843
R1677 B1#15pin@333_polysilicon-1##17 B1#15pin@333_polysilicon-1##18 9.843
R1678 B1#15pin@333_polysilicon-1##18 B1#16pin@350_polysilicon-1 9.843
R1679 net@1307#4nmos@66_poly-right net@1307#4nmos@66_poly-right##0 7.233
R1680 net@1307#4nmos@66_poly-right##0 net@1307#4nmos@66_poly-right##1 7.233
R1681 net@1307#4nmos@66_poly-right##1 net@1307#5pin@345_polysilicon-1 7.233
R1682 net@1307#2contact@491_metal-1-polysilicon-1 net@1307#2contact@491_metal-1-polysilicon-1##0 8.99
R1683 net@1307#2contact@491_metal-1-polysilicon-1##0 net@1307#2contact@491_metal-1-polysilicon-1##1 8.99
R1684 net@1307#2contact@491_metal-1-polysilicon-1##1 net@1307#2contact@491_metal-1-polysilicon-1##2 8.99
R1685 net@1307#2contact@491_metal-1-polysilicon-1##2 net@1307#2contact@491_metal-1-polysilicon-1##3 8.99
R1686 net@1307#2contact@491_metal-1-polysilicon-1##3 net@1307#5pin@345_polysilicon-1 8.99
R1687 A1#1pin@517_metal-2 A1#1pin@517_metal-2##0 6.717
R1688 A1#1pin@517_metal-2##0 A1#1pin@517_metal-2##1 6.717
R1689 A1#1pin@517_metal-2##1 A1#16pin@341_polysilicon-1 6.717
R1690 A1#14pin@340_polysilicon-1 A1#14pin@340_polysilicon-1##0 7.75
R1691 A1#14pin@340_polysilicon-1##0 A1#14pin@340_polysilicon-1##1 7.75
R1692 A1#14pin@340_polysilicon-1##1 A1#16pin@341_polysilicon-1 7.75
R1693 B1#16pin@350_polysilicon-1 B1#16pin@350_polysilicon-1##0 9.743
R1694 B1#16pin@350_polysilicon-1##0 B1#16pin@350_polysilicon-1##1 9.743
R1695 B1#16pin@350_polysilicon-1##1 B1#16pin@350_polysilicon-1##2 9.743
R1696 B1#16pin@350_polysilicon-1##2 B1#16pin@350_polysilicon-1##3 9.743
R1697 B1#16pin@350_polysilicon-1##3 B1#16pin@350_polysilicon-1##4 9.743
R1698 B1#16pin@350_polysilicon-1##4 B1#16pin@350_polysilicon-1##5 9.743
R1699 B1#16pin@350_polysilicon-1##5 B1#0pin@508_metal-2 9.743
R1700 net@1209#7pmos@61_poly-left net@1209#7pmos@61_poly-left##0 7.75
R1701 net@1209#7pmos@61_poly-left##0 net@1209 7.75
R1702 B1#17nmos@62_poly-left B1#17nmos@62_poly-left##0 6.2
R1703 B1#17nmos@62_poly-left##0 B1#15pin@333_polysilicon-1 6.2
R1704 net@1314#9nmos@63_poly-left net@1314#9nmos@63_poly-left##0 8.37
R1705 net@1314#9nmos@63_poly-left##0 net@1314#9nmos@63_poly-left##1 8.37
R1706 net@1314#9nmos@63_poly-left##1 net@1314#9nmos@63_poly-left##2 8.37
R1707 net@1314#9nmos@63_poly-left##2 net@1314#9nmos@63_poly-left##3 8.37
R1708 net@1314#9nmos@63_poly-left##3 net@1314#2contact@466_metal-1-metal-2 8.37
R1709 A1#4pin@353_polysilicon-1 A1#4pin@353_polysilicon-1##0 9.881
R1710 A1#4pin@353_polysilicon-1##0 A1#4pin@353_polysilicon-1##1 9.881
R1711 A1#4pin@353_polysilicon-1##1 A1#4pin@353_polysilicon-1##2 9.881
R1712 A1#4pin@353_polysilicon-1##2 A1#4pin@353_polysilicon-1##3 9.881
R1713 A1#4pin@353_polysilicon-1##3 A1#4pin@353_polysilicon-1##4 9.881
R1714 A1#4pin@353_polysilicon-1##4 A1#4pin@353_polysilicon-1##5 9.881
R1715 A1#4pin@353_polysilicon-1##5 A1#4pin@353_polysilicon-1##6 9.881
R1716 A1#4pin@353_polysilicon-1##6 A1#4pin@353_polysilicon-1##7 9.881
R1717 A1#4pin@353_polysilicon-1##7 A1#4pin@353_polysilicon-1##8 9.881
R1718 A1#4pin@353_polysilicon-1##8 A1#4pin@353_polysilicon-1##9 9.881
R1719 A1#4pin@353_polysilicon-1##9 A1#4pin@353_polysilicon-1##10 9.881
R1720 A1#4pin@353_polysilicon-1##10 A1#4pin@353_polysilicon-1##11 9.881
R1721 A1#4pin@353_polysilicon-1##11 A1#4pin@353_polysilicon-1##12 9.881
R1722 A1#4pin@353_polysilicon-1##12 A1#4pin@353_polysilicon-1##13 9.881
R1723 A1#4pin@353_polysilicon-1##13 A1#4pin@353_polysilicon-1##14 9.881
R1724 A1#4pin@353_polysilicon-1##14 A1#4pin@353_polysilicon-1##15 9.881
R1725 A1#4pin@353_polysilicon-1##15 A1#4pin@353_polysilicon-1##16 9.881
R1726 A1#4pin@353_polysilicon-1##16 A1#4pin@353_polysilicon-1##17 9.881
R1727 A1#4pin@353_polysilicon-1##17 A1#4pin@353_polysilicon-1##18 9.881
R1728 A1#4pin@353_polysilicon-1##18 A1#4pin@353_polysilicon-1##19 9.881
R1729 A1#4pin@353_polysilicon-1##19 A1#4pin@353_polysilicon-1##20 9.881
R1730 A1#4pin@353_polysilicon-1##20 A1#4pin@353_polysilicon-1##21 9.881
R1731 A1#4pin@353_polysilicon-1##21 A1#4pin@353_polysilicon-1##22 9.881
R1732 A1#4pin@353_polysilicon-1##22 A1#4pin@353_polysilicon-1##23 9.881
R1733 A1#4pin@353_polysilicon-1##23 A1#4pin@353_polysilicon-1##24 9.881
R1734 A1#4pin@353_polysilicon-1##24 A1#4pin@353_polysilicon-1##25 9.881
R1735 A1#4pin@353_polysilicon-1##25 A1#4pin@353_polysilicon-1##26 9.881
R1736 A1#4pin@353_polysilicon-1##26 A1#4pin@353_polysilicon-1##27 9.881
R1737 A1#4pin@353_polysilicon-1##27 A1#4pin@353_polysilicon-1##28 9.881
R1738 A1#4pin@353_polysilicon-1##28 A1#4pin@353_polysilicon-1##29 9.881
R1739 A1#4pin@353_polysilicon-1##29 A1#4pin@353_polysilicon-1##30 9.881
R1740 A1#4pin@353_polysilicon-1##30 A1#4pin@353_polysilicon-1##31 9.881
R1741 A1#4pin@353_polysilicon-1##31 A1#4pin@353_polysilicon-1##32 9.881
R1742 A1#4pin@353_polysilicon-1##32 A1#4pin@353_polysilicon-1##33 9.881
R1743 A1#4pin@353_polysilicon-1##33 A1#4pin@353_polysilicon-1##34 9.881
R1744 A1#4pin@353_polysilicon-1##34 A1#4pin@353_polysilicon-1##35 9.881
R1745 A1#4pin@353_polysilicon-1##35 A1#4pin@353_polysilicon-1##36 9.881
R1746 A1#4pin@353_polysilicon-1##36 A1#4pin@353_polysilicon-1##37 9.881
R1747 A1#4pin@353_polysilicon-1##37 A1#4pin@353_polysilicon-1##38 9.881
R1748 A1#4pin@353_polysilicon-1##38 A1#4pin@353_polysilicon-1##39 9.881
R1749 A1#4pin@353_polysilicon-1##39 A1#4pin@353_polysilicon-1##40 9.881
R1750 A1#4pin@353_polysilicon-1##40 A1#4pin@353_polysilicon-1##41 9.881
R1751 A1#4pin@353_polysilicon-1##41 A1#4pin@353_polysilicon-1##42 9.881
R1752 A1#4pin@353_polysilicon-1##42 A1#4pin@353_polysilicon-1##43 9.881
R1753 A1#4pin@353_polysilicon-1##43 A1#4pin@353_polysilicon-1##44 9.881
R1754 A1#4pin@353_polysilicon-1##44 A1#4pin@353_polysilicon-1##45 9.881
R1755 A1#4pin@353_polysilicon-1##45 A1#4pin@353_polysilicon-1##46 9.881
R1756 A1#4pin@353_polysilicon-1##46 A1#4pin@353_polysilicon-1##47 9.881
R1757 A1#4pin@353_polysilicon-1##47 A1#4pin@353_polysilicon-1##48 9.881
R1758 A1#4pin@353_polysilicon-1##48 A1#4pin@353_polysilicon-1##49 9.881
R1759 A1#4pin@353_polysilicon-1##49 A1#4pin@353_polysilicon-1##50 9.881
R1760 A1#4pin@353_polysilicon-1##50 A1#4pin@353_polysilicon-1##51 9.881
R1761 A1#4pin@353_polysilicon-1##51 A1#4pin@353_polysilicon-1##52 9.881
R1762 A1#4pin@353_polysilicon-1##52 A1#4pin@353_polysilicon-1##53 9.881
R1763 A1#4pin@353_polysilicon-1##53 A1#4pin@353_polysilicon-1##54 9.881
R1764 A1#4pin@353_polysilicon-1##54 A1#17nmos@65_poly-right 9.881
R1765 net@1209#5pmos@65_diff-top net@1209#2pin@342_metal-1 4.81
R1766 net@1209#1pin@352_polysilicon-1 net@1209#1pin@352_polysilicon-1##0 9.85
R1767 net@1209#1pin@352_polysilicon-1##0 net@1209#1pin@352_polysilicon-1##1 9.85
R1768 net@1209#1pin@352_polysilicon-1##1 net@1209#1pin@352_polysilicon-1##2 9.85
R1769 net@1209#1pin@352_polysilicon-1##2 net@1209#1pin@352_polysilicon-1##3 9.85
R1770 net@1209#1pin@352_polysilicon-1##3 net@1209#1pin@352_polysilicon-1##4 9.85
R1771 net@1209#1pin@352_polysilicon-1##4 net@1209#1pin@352_polysilicon-1##5 9.85
R1772 net@1209#1pin@352_polysilicon-1##5 net@1209#1pin@352_polysilicon-1##6 9.85
R1773 net@1209#1pin@352_polysilicon-1##6 net@1209#1pin@352_polysilicon-1##7 9.85
R1774 net@1209#1pin@352_polysilicon-1##7 net@1209#1pin@352_polysilicon-1##8 9.85
R1775 net@1209#1pin@352_polysilicon-1##8 net@1209#1pin@352_polysilicon-1##9 9.85
R1776 net@1209#1pin@352_polysilicon-1##9 net@1209#1pin@352_polysilicon-1##10 9.85
R1777 net@1209#1pin@352_polysilicon-1##10 net@1209#1pin@352_polysilicon-1##11 9.85
R1778 net@1209#1pin@352_polysilicon-1##11 net@1209#1pin@352_polysilicon-1##12 9.85
R1779 net@1209#1pin@352_polysilicon-1##12 net@1209#1pin@352_polysilicon-1##13 9.85
R1780 net@1209#1pin@352_polysilicon-1##13 net@1209#1pin@352_polysilicon-1##14 9.85
R1781 net@1209#1pin@352_polysilicon-1##14 net@1209#1pin@352_polysilicon-1##15 9.85
R1782 net@1209#1pin@352_polysilicon-1##15 net@1209#1pin@352_polysilicon-1##16 9.85
R1783 net@1209#1pin@352_polysilicon-1##16 net@1209#1pin@352_polysilicon-1##17 9.85
R1784 net@1209#1pin@352_polysilicon-1##17 net@1209#1pin@352_polysilicon-1##18 9.85
R1785 net@1209#1pin@352_polysilicon-1##18 net@1209#1pin@352_polysilicon-1##19 9.85
R1786 net@1209#1pin@352_polysilicon-1##19 net@1209#1pin@352_polysilicon-1##20 9.85
R1787 net@1209#1pin@352_polysilicon-1##20 net@1209#1pin@352_polysilicon-1##21 9.85
R1788 net@1209#1pin@352_polysilicon-1##21 net@1209#1pin@352_polysilicon-1##22 9.85
R1789 net@1209#1pin@352_polysilicon-1##22 net@1209#1pin@352_polysilicon-1##23 9.85
R1790 net@1209#1pin@352_polysilicon-1##23 net@1209#1pin@352_polysilicon-1##24 9.85
R1791 net@1209#1pin@352_polysilicon-1##24 net@1209#1pin@352_polysilicon-1##25 9.85
R1792 net@1209#1pin@352_polysilicon-1##25 net@1209#1pin@352_polysilicon-1##26 9.85
R1793 net@1209#1pin@352_polysilicon-1##26 net@1209#1pin@352_polysilicon-1##27 9.85
R1794 net@1209#1pin@352_polysilicon-1##27 net@1209#1pin@352_polysilicon-1##28 9.85
R1795 net@1209#1pin@352_polysilicon-1##28 net@1209#1pin@352_polysilicon-1##29 9.85
R1796 net@1209#1pin@352_polysilicon-1##29 net@1209#1pin@352_polysilicon-1##30 9.85
R1797 net@1209#1pin@352_polysilicon-1##30 net@1209#1pin@352_polysilicon-1##31 9.85
R1798 net@1209#1pin@352_polysilicon-1##31 net@1209#1pin@352_polysilicon-1##32 9.85
R1799 net@1209#1pin@352_polysilicon-1##32 net@1209#1pin@352_polysilicon-1##33 9.85
R1800 net@1209#1pin@352_polysilicon-1##33 net@1209#1pin@352_polysilicon-1##34 9.85
R1801 net@1209#1pin@352_polysilicon-1##34 net@1209#1pin@352_polysilicon-1##35 9.85
R1802 net@1209#1pin@352_polysilicon-1##35 net@1209#1pin@352_polysilicon-1##36 9.85
R1803 net@1209#1pin@352_polysilicon-1##36 net@1209#1pin@352_polysilicon-1##37 9.85
R1804 net@1209#1pin@352_polysilicon-1##37 net@1209#1pin@352_polysilicon-1##38 9.85
R1805 net@1209#1pin@352_polysilicon-1##38 net@1209#1pin@352_polysilicon-1##39 9.85
R1806 net@1209#1pin@352_polysilicon-1##39 net@1209#1pin@352_polysilicon-1##40 9.85
R1807 net@1209#1pin@352_polysilicon-1##40 net@1209#1pin@352_polysilicon-1##41 9.85
R1808 net@1209#1pin@352_polysilicon-1##41 net@1209#1pin@352_polysilicon-1##42 9.85
R1809 net@1209#1pin@352_polysilicon-1##42 net@1209#1pin@352_polysilicon-1##43 9.85
R1810 net@1209#1pin@352_polysilicon-1##43 net@1209#1pin@352_polysilicon-1##44 9.85
R1811 net@1209#1pin@352_polysilicon-1##44 net@1209#1pin@352_polysilicon-1##45 9.85
R1812 net@1209#1pin@352_polysilicon-1##45 net@1209#1pin@352_polysilicon-1##46 9.85
R1813 net@1209#1pin@352_polysilicon-1##46 net@1209#1pin@352_polysilicon-1##47 9.85
R1814 net@1209#1pin@352_polysilicon-1##47 net@1209#1pin@352_polysilicon-1##48 9.85
R1815 net@1209#1pin@352_polysilicon-1##48 net@1209#1pin@352_polysilicon-1##49 9.85
R1816 net@1209#1pin@352_polysilicon-1##49 net@1209#1pin@352_polysilicon-1##50 9.85
R1817 net@1209#1pin@352_polysilicon-1##50 net@1209#1pin@352_polysilicon-1##51 9.85
R1818 net@1209#1pin@352_polysilicon-1##51 net@1209#1pin@352_polysilicon-1##52 9.85
R1819 net@1209#1pin@352_polysilicon-1##52 net@1209#1pin@352_polysilicon-1##53 9.85
R1820 net@1209#1pin@352_polysilicon-1##53 net@1209#1pin@352_polysilicon-1##54 9.85
R1821 net@1209#1pin@352_polysilicon-1##54 net@1209#1pin@352_polysilicon-1##55 9.85
R1822 net@1209#1pin@352_polysilicon-1##55 net@1209#1pin@352_polysilicon-1##56 9.85
R1823 net@1209#1pin@352_polysilicon-1##56 net@1209#1pin@352_polysilicon-1##57 9.85
R1824 net@1209#1pin@352_polysilicon-1##57 net@1209#1pin@352_polysilicon-1##58 9.85
R1825 net@1209#1pin@352_polysilicon-1##58 net@1209#1pin@352_polysilicon-1##59 9.85
R1826 net@1209#1pin@352_polysilicon-1##59 net@1209#1pin@352_polysilicon-1##60 9.85
R1827 net@1209#1pin@352_polysilicon-1##60 net@1209#2pin@342_metal-1 9.85
R1828 B1#18pmos@64_poly-right B1#18pmos@64_poly-right##0 9.854
R1829 B1#18pmos@64_poly-right##0 B1#18pmos@64_poly-right##1 9.854
R1830 B1#18pmos@64_poly-right##1 B1#18pmos@64_poly-right##2 9.854
R1831 B1#18pmos@64_poly-right##2 B1#18pmos@64_poly-right##3 9.854
R1832 B1#18pmos@64_poly-right##3 B1#18pmos@64_poly-right##4 9.854
R1833 B1#18pmos@64_poly-right##4 B1#18pmos@64_poly-right##5 9.854
R1834 B1#18pmos@64_poly-right##5 B1#18pmos@64_poly-right##6 9.854
R1835 B1#18pmos@64_poly-right##6 B1#18pmos@64_poly-right##7 9.854
R1836 B1#18pmos@64_poly-right##7 B1#18pmos@64_poly-right##8 9.854
R1837 B1#18pmos@64_poly-right##8 B1#18pmos@64_poly-right##9 9.854
R1838 B1#18pmos@64_poly-right##9 B1#18pmos@64_poly-right##10 9.854
R1839 B1#18pmos@64_poly-right##10 B1#18pmos@64_poly-right##11 9.854
R1840 B1#18pmos@64_poly-right##11 B1#18pmos@64_poly-right##12 9.854
R1841 B1#18pmos@64_poly-right##12 B1#18pmos@64_poly-right##13 9.854
R1842 B1#18pmos@64_poly-right##13 B1#18pmos@64_poly-right##14 9.854
R1843 B1#18pmos@64_poly-right##14 B1#18pmos@64_poly-right##15 9.854
R1844 B1#18pmos@64_poly-right##15 B1#18pmos@64_poly-right##16 9.854
R1845 B1#18pmos@64_poly-right##16 B1#18pmos@64_poly-right##17 9.854
R1846 B1#18pmos@64_poly-right##17 B1#18pmos@64_poly-right##18 9.854
R1847 B1#18pmos@64_poly-right##18 B1#18pmos@64_poly-right##19 9.854
R1848 B1#18pmos@64_poly-right##19 B1#18pmos@64_poly-right##20 9.854
R1849 B1#18pmos@64_poly-right##20 B1#18pmos@64_poly-right##21 9.854
R1850 B1#18pmos@64_poly-right##21 B1#18pmos@64_poly-right##22 9.854
R1851 B1#18pmos@64_poly-right##22 B1#18pmos@64_poly-right##23 9.854
R1852 B1#18pmos@64_poly-right##23 B1#18pmos@64_poly-right##24 9.854
R1853 B1#18pmos@64_poly-right##24 B1#18pmos@64_poly-right##25 9.854
R1854 B1#18pmos@64_poly-right##25 B1#18pmos@64_poly-right##26 9.854
R1855 B1#18pmos@64_poly-right##26 B1#18pmos@64_poly-right##27 9.854
R1856 B1#18pmos@64_poly-right##27 B1#18pmos@64_poly-right##28 9.854
R1857 B1#18pmos@64_poly-right##28 B1#18pmos@64_poly-right##29 9.854
R1858 B1#18pmos@64_poly-right##29 B1#18pmos@64_poly-right##30 9.854
R1859 B1#18pmos@64_poly-right##30 B1#18pmos@64_poly-right##31 9.854
R1860 B1#18pmos@64_poly-right##31 B1#18pmos@64_poly-right##32 9.854
R1861 B1#18pmos@64_poly-right##32 B1#18pmos@64_poly-right##33 9.854
R1862 B1#18pmos@64_poly-right##33 B1#18pmos@64_poly-right##34 9.854
R1863 B1#18pmos@64_poly-right##34 B1#18pmos@64_poly-right##35 9.854
R1864 B1#18pmos@64_poly-right##35 B1#18pmos@64_poly-right##36 9.854
R1865 B1#18pmos@64_poly-right##36 B1#18pmos@64_poly-right##37 9.854
R1866 B1#18pmos@64_poly-right##37 B1#18pmos@64_poly-right##38 9.854
R1867 B1#18pmos@64_poly-right##38 B1#18pmos@64_poly-right##39 9.854
R1868 B1#18pmos@64_poly-right##39 B1#18pmos@64_poly-right##40 9.854
R1869 B1#18pmos@64_poly-right##40 B1#18pmos@64_poly-right##41 9.854
R1870 B1#18pmos@64_poly-right##41 B1#18pmos@64_poly-right##42 9.854
R1871 B1#18pmos@64_poly-right##42 B1#18pmos@64_poly-right##43 9.854
R1872 B1#18pmos@64_poly-right##43 B1#18pmos@64_poly-right##44 9.854
R1873 B1#18pmos@64_poly-right##44 B1#18pmos@64_poly-right##45 9.854
R1874 B1#18pmos@64_poly-right##45 B1#18pmos@64_poly-right##46 9.854
R1875 B1#18pmos@64_poly-right##46 B1#18pmos@64_poly-right##47 9.854
R1876 B1#18pmos@64_poly-right##47 B1#18pmos@64_poly-right##48 9.854
R1877 B1#18pmos@64_poly-right##48 B1#18pmos@64_poly-right##49 9.854
R1878 B1#18pmos@64_poly-right##49 B1#18pmos@64_poly-right##50 9.854
R1879 B1#18pmos@64_poly-right##50 B1#18pmos@64_poly-right##51 9.854
R1880 B1#18pmos@64_poly-right##51 B1#18pmos@64_poly-right##52 9.854
R1881 B1#18pmos@64_poly-right##52 B1#18pmos@64_poly-right##53 9.854
R1882 B1#18pmos@64_poly-right##53 B1#18pmos@64_poly-right##54 9.854
R1883 B1#18pmos@64_poly-right##54 B1#13pin@343_polysilicon-1 9.854
R1884 net@1314 net@1314#2contact@466_metal-1-metal-2 4.797
R1885 A1#18nmos@60_poly-right A1#18nmos@60_poly-right##0 9.871
R1886 A1#18nmos@60_poly-right##0 A1#18nmos@60_poly-right##1 9.871
R1887 A1#18nmos@60_poly-right##1 A1#18nmos@60_poly-right##2 9.871
R1888 A1#18nmos@60_poly-right##2 A1#18nmos@60_poly-right##3 9.871
R1889 A1#18nmos@60_poly-right##3 A1#18nmos@60_poly-right##4 9.871
R1890 A1#18nmos@60_poly-right##4 A1#18nmos@60_poly-right##5 9.871
R1891 A1#18nmos@60_poly-right##5 A1#18nmos@60_poly-right##6 9.871
R1892 A1#18nmos@60_poly-right##6 A1#18nmos@60_poly-right##7 9.871
R1893 A1#18nmos@60_poly-right##7 A1#18nmos@60_poly-right##8 9.871
R1894 A1#18nmos@60_poly-right##8 A1#18nmos@60_poly-right##9 9.871
R1895 A1#18nmos@60_poly-right##9 A1#18nmos@60_poly-right##10 9.871
R1896 A1#18nmos@60_poly-right##10 A1#18nmos@60_poly-right##11 9.871
R1897 A1#18nmos@60_poly-right##11 A1#18nmos@60_poly-right##12 9.871
R1898 A1#18nmos@60_poly-right##12 A1#18nmos@60_poly-right##13 9.871
R1899 A1#18nmos@60_poly-right##13 A1#18nmos@60_poly-right##14 9.871
R1900 A1#18nmos@60_poly-right##14 A1#18nmos@60_poly-right##15 9.871
R1901 A1#18nmos@60_poly-right##15 A1#18nmos@60_poly-right##16 9.871
R1902 A1#18nmos@60_poly-right##16 A1#18nmos@60_poly-right##17 9.871
R1903 A1#18nmos@60_poly-right##17 A1#18nmos@60_poly-right##18 9.871
R1904 A1#18nmos@60_poly-right##18 A1#18nmos@60_poly-right##19 9.871
R1905 A1#18nmos@60_poly-right##19 A1#18nmos@60_poly-right##20 9.871
R1906 A1#18nmos@60_poly-right##20 A1#18nmos@60_poly-right##21 9.871
R1907 A1#18nmos@60_poly-right##21 A1#18nmos@60_poly-right##22 9.871
R1908 A1#18nmos@60_poly-right##22 A1#18nmos@60_poly-right##23 9.871
R1909 A1#18nmos@60_poly-right##23 A1#18nmos@60_poly-right##24 9.871
R1910 A1#18nmos@60_poly-right##24 A1#18nmos@60_poly-right##25 9.871
R1911 A1#18nmos@60_poly-right##25 A1#18nmos@60_poly-right##26 9.871
R1912 A1#18nmos@60_poly-right##26 A1#18nmos@60_poly-right##27 9.871
R1913 A1#18nmos@60_poly-right##27 A1#18nmos@60_poly-right##28 9.871
R1914 A1#18nmos@60_poly-right##28 A1#18nmos@60_poly-right##29 9.871
R1915 A1#18nmos@60_poly-right##29 A1#18nmos@60_poly-right##30 9.871
R1916 A1#18nmos@60_poly-right##30 A1#18nmos@60_poly-right##31 9.871
R1917 A1#18nmos@60_poly-right##31 A1#18nmos@60_poly-right##32 9.871
R1918 A1#18nmos@60_poly-right##32 A1#18nmos@60_poly-right##33 9.871
R1919 A1#18nmos@60_poly-right##33 A1#18nmos@60_poly-right##34 9.871
R1920 A1#18nmos@60_poly-right##34 A1#18nmos@60_poly-right##35 9.871
R1921 A1#18nmos@60_poly-right##35 A1#18nmos@60_poly-right##36 9.871
R1922 A1#18nmos@60_poly-right##36 A1#18nmos@60_poly-right##37 9.871
R1923 A1#18nmos@60_poly-right##37 A1#18nmos@60_poly-right##38 9.871
R1924 A1#18nmos@60_poly-right##38 A1#18nmos@60_poly-right##39 9.871
R1925 A1#18nmos@60_poly-right##39 A1#18nmos@60_poly-right##40 9.871
R1926 A1#18nmos@60_poly-right##40 A1#18nmos@60_poly-right##41 9.871
R1927 A1#18nmos@60_poly-right##41 A1#18nmos@60_poly-right##42 9.871
R1928 A1#18nmos@60_poly-right##42 A1#18nmos@60_poly-right##43 9.871
R1929 A1#18nmos@60_poly-right##43 A1#18nmos@60_poly-right##44 9.871
R1930 A1#18nmos@60_poly-right##44 A1#18nmos@60_poly-right##45 9.871
R1931 A1#18nmos@60_poly-right##45 A1#18nmos@60_poly-right##46 9.871
R1932 A1#18nmos@60_poly-right##46 A1#18nmos@60_poly-right##47 9.871
R1933 A1#18nmos@60_poly-right##47 A1#18nmos@60_poly-right##48 9.871
R1934 A1#18nmos@60_poly-right##48 A1#18nmos@60_poly-right##49 9.871
R1935 A1#18nmos@60_poly-right##49 A1#18nmos@60_poly-right##50 9.871
R1936 A1#18nmos@60_poly-right##50 A1#18nmos@60_poly-right##51 9.871
R1937 A1#18nmos@60_poly-right##51 A1#18nmos@60_poly-right##52 9.871
R1938 A1#18nmos@60_poly-right##52 A1#18nmos@60_poly-right##53 9.871
R1939 A1#18nmos@60_poly-right##53 A1#18nmos@60_poly-right##54 9.871
R1940 A1#18nmos@60_poly-right##54 A1#18nmos@60_poly-right##55 9.871
R1941 A1#18nmos@60_poly-right##55 A1#13pmos@60_poly-left 9.871
R1942 net@1209#7pmos@61_poly-left net@1209#7pmos@61_poly-left##0 9.871
R1943 net@1209#7pmos@61_poly-left##0 net@1209#7pmos@61_poly-left##1 9.871
R1944 net@1209#7pmos@61_poly-left##1 net@1209#7pmos@61_poly-left##2 9.871
R1945 net@1209#7pmos@61_poly-left##2 net@1209#7pmos@61_poly-left##3 9.871
R1946 net@1209#7pmos@61_poly-left##3 net@1209#7pmos@61_poly-left##4 9.871
R1947 net@1209#7pmos@61_poly-left##4 net@1209#7pmos@61_poly-left##5 9.871
R1948 net@1209#7pmos@61_poly-left##5 net@1209#7pmos@61_poly-left##6 9.871
R1949 net@1209#7pmos@61_poly-left##6 net@1209#7pmos@61_poly-left##7 9.871
R1950 net@1209#7pmos@61_poly-left##7 net@1209#7pmos@61_poly-left##8 9.871
R1951 net@1209#7pmos@61_poly-left##8 net@1209#7pmos@61_poly-left##9 9.871
R1952 net@1209#7pmos@61_poly-left##9 net@1209#7pmos@61_poly-left##10 9.871
R1953 net@1209#7pmos@61_poly-left##10 net@1209#7pmos@61_poly-left##11 9.871
R1954 net@1209#7pmos@61_poly-left##11 net@1209#7pmos@61_poly-left##12 9.871
R1955 net@1209#7pmos@61_poly-left##12 net@1209#7pmos@61_poly-left##13 9.871
R1956 net@1209#7pmos@61_poly-left##13 net@1209#7pmos@61_poly-left##14 9.871
R1957 net@1209#7pmos@61_poly-left##14 net@1209#7pmos@61_poly-left##15 9.871
R1958 net@1209#7pmos@61_poly-left##15 net@1209#7pmos@61_poly-left##16 9.871
R1959 net@1209#7pmos@61_poly-left##16 net@1209#7pmos@61_poly-left##17 9.871
R1960 net@1209#7pmos@61_poly-left##17 net@1209#7pmos@61_poly-left##18 9.871
R1961 net@1209#7pmos@61_poly-left##18 net@1209#7pmos@61_poly-left##19 9.871
R1962 net@1209#7pmos@61_poly-left##19 net@1209#7pmos@61_poly-left##20 9.871
R1963 net@1209#7pmos@61_poly-left##20 net@1209#7pmos@61_poly-left##21 9.871
R1964 net@1209#7pmos@61_poly-left##21 net@1209#7pmos@61_poly-left##22 9.871
R1965 net@1209#7pmos@61_poly-left##22 net@1209#7pmos@61_poly-left##23 9.871
R1966 net@1209#7pmos@61_poly-left##23 net@1209#7pmos@61_poly-left##24 9.871
R1967 net@1209#7pmos@61_poly-left##24 net@1209#7pmos@61_poly-left##25 9.871
R1968 net@1209#7pmos@61_poly-left##25 net@1209#7pmos@61_poly-left##26 9.871
R1969 net@1209#7pmos@61_poly-left##26 net@1209#7pmos@61_poly-left##27 9.871
R1970 net@1209#7pmos@61_poly-left##27 net@1209#7pmos@61_poly-left##28 9.871
R1971 net@1209#7pmos@61_poly-left##28 net@1209#7pmos@61_poly-left##29 9.871
R1972 net@1209#7pmos@61_poly-left##29 net@1209#7pmos@61_poly-left##30 9.871
R1973 net@1209#7pmos@61_poly-left##30 net@1209#7pmos@61_poly-left##31 9.871
R1974 net@1209#7pmos@61_poly-left##31 net@1209#7pmos@61_poly-left##32 9.871
R1975 net@1209#7pmos@61_poly-left##32 net@1209#7pmos@61_poly-left##33 9.871
R1976 net@1209#7pmos@61_poly-left##33 net@1209#7pmos@61_poly-left##34 9.871
R1977 net@1209#7pmos@61_poly-left##34 net@1209#7pmos@61_poly-left##35 9.871
R1978 net@1209#7pmos@61_poly-left##35 net@1209#7pmos@61_poly-left##36 9.871
R1979 net@1209#7pmos@61_poly-left##36 net@1209#7pmos@61_poly-left##37 9.871
R1980 net@1209#7pmos@61_poly-left##37 net@1209#7pmos@61_poly-left##38 9.871
R1981 net@1209#7pmos@61_poly-left##38 net@1209#7pmos@61_poly-left##39 9.871
R1982 net@1209#7pmos@61_poly-left##39 net@1209#7pmos@61_poly-left##40 9.871
R1983 net@1209#7pmos@61_poly-left##40 net@1209#7pmos@61_poly-left##41 9.871
R1984 net@1209#7pmos@61_poly-left##41 net@1209#7pmos@61_poly-left##42 9.871
R1985 net@1209#7pmos@61_poly-left##42 net@1209#7pmos@61_poly-left##43 9.871
R1986 net@1209#7pmos@61_poly-left##43 net@1209#7pmos@61_poly-left##44 9.871
R1987 net@1209#7pmos@61_poly-left##44 net@1209#7pmos@61_poly-left##45 9.871
R1988 net@1209#7pmos@61_poly-left##45 net@1209#7pmos@61_poly-left##46 9.871
R1989 net@1209#7pmos@61_poly-left##46 net@1209#7pmos@61_poly-left##47 9.871
R1990 net@1209#7pmos@61_poly-left##47 net@1209#7pmos@61_poly-left##48 9.871
R1991 net@1209#7pmos@61_poly-left##48 net@1209#7pmos@61_poly-left##49 9.871
R1992 net@1209#7pmos@61_poly-left##49 net@1209#7pmos@61_poly-left##50 9.871
R1993 net@1209#7pmos@61_poly-left##50 net@1209#7pmos@61_poly-left##51 9.871
R1994 net@1209#7pmos@61_poly-left##51 net@1209#7pmos@61_poly-left##52 9.871
R1995 net@1209#7pmos@61_poly-left##52 net@1209#7pmos@61_poly-left##53 9.871
R1996 net@1209#7pmos@61_poly-left##53 net@1209#7pmos@61_poly-left##54 9.871
R1997 net@1209#7pmos@61_poly-left##54 net@1209#7pmos@61_poly-left##55 9.871
R1998 net@1209#7pmos@61_poly-left##55 net@1209#11nmos@61_poly-right 9.871
R1999 B1#19pmos@62_poly-right B1#19pmos@62_poly-right##0 9.871
R2000 B1#19pmos@62_poly-right##0 B1#19pmos@62_poly-right##1 9.871
R2001 B1#19pmos@62_poly-right##1 B1#19pmos@62_poly-right##2 9.871
R2002 B1#19pmos@62_poly-right##2 B1#19pmos@62_poly-right##3 9.871
R2003 B1#19pmos@62_poly-right##3 B1#19pmos@62_poly-right##4 9.871
R2004 B1#19pmos@62_poly-right##4 B1#19pmos@62_poly-right##5 9.871
R2005 B1#19pmos@62_poly-right##5 B1#19pmos@62_poly-right##6 9.871
R2006 B1#19pmos@62_poly-right##6 B1#19pmos@62_poly-right##7 9.871
R2007 B1#19pmos@62_poly-right##7 B1#19pmos@62_poly-right##8 9.871
R2008 B1#19pmos@62_poly-right##8 B1#19pmos@62_poly-right##9 9.871
R2009 B1#19pmos@62_poly-right##9 B1#19pmos@62_poly-right##10 9.871
R2010 B1#19pmos@62_poly-right##10 B1#19pmos@62_poly-right##11 9.871
R2011 B1#19pmos@62_poly-right##11 B1#19pmos@62_poly-right##12 9.871
R2012 B1#19pmos@62_poly-right##12 B1#19pmos@62_poly-right##13 9.871
R2013 B1#19pmos@62_poly-right##13 B1#19pmos@62_poly-right##14 9.871
R2014 B1#19pmos@62_poly-right##14 B1#19pmos@62_poly-right##15 9.871
R2015 B1#19pmos@62_poly-right##15 B1#19pmos@62_poly-right##16 9.871
R2016 B1#19pmos@62_poly-right##16 B1#19pmos@62_poly-right##17 9.871
R2017 B1#19pmos@62_poly-right##17 B1#19pmos@62_poly-right##18 9.871
R2018 B1#19pmos@62_poly-right##18 B1#19pmos@62_poly-right##19 9.871
R2019 B1#19pmos@62_poly-right##19 B1#19pmos@62_poly-right##20 9.871
R2020 B1#19pmos@62_poly-right##20 B1#19pmos@62_poly-right##21 9.871
R2021 B1#19pmos@62_poly-right##21 B1#19pmos@62_poly-right##22 9.871
R2022 B1#19pmos@62_poly-right##22 B1#19pmos@62_poly-right##23 9.871
R2023 B1#19pmos@62_poly-right##23 B1#19pmos@62_poly-right##24 9.871
R2024 B1#19pmos@62_poly-right##24 B1#19pmos@62_poly-right##25 9.871
R2025 B1#19pmos@62_poly-right##25 B1#19pmos@62_poly-right##26 9.871
R2026 B1#19pmos@62_poly-right##26 B1#19pmos@62_poly-right##27 9.871
R2027 B1#19pmos@62_poly-right##27 B1#19pmos@62_poly-right##28 9.871
R2028 B1#19pmos@62_poly-right##28 B1#19pmos@62_poly-right##29 9.871
R2029 B1#19pmos@62_poly-right##29 B1#19pmos@62_poly-right##30 9.871
R2030 B1#19pmos@62_poly-right##30 B1#19pmos@62_poly-right##31 9.871
R2031 B1#19pmos@62_poly-right##31 B1#19pmos@62_poly-right##32 9.871
R2032 B1#19pmos@62_poly-right##32 B1#19pmos@62_poly-right##33 9.871
R2033 B1#19pmos@62_poly-right##33 B1#19pmos@62_poly-right##34 9.871
R2034 B1#19pmos@62_poly-right##34 B1#19pmos@62_poly-right##35 9.871
R2035 B1#19pmos@62_poly-right##35 B1#19pmos@62_poly-right##36 9.871
R2036 B1#19pmos@62_poly-right##36 B1#19pmos@62_poly-right##37 9.871
R2037 B1#19pmos@62_poly-right##37 B1#19pmos@62_poly-right##38 9.871
R2038 B1#19pmos@62_poly-right##38 B1#19pmos@62_poly-right##39 9.871
R2039 B1#19pmos@62_poly-right##39 B1#19pmos@62_poly-right##40 9.871
R2040 B1#19pmos@62_poly-right##40 B1#19pmos@62_poly-right##41 9.871
R2041 B1#19pmos@62_poly-right##41 B1#19pmos@62_poly-right##42 9.871
R2042 B1#19pmos@62_poly-right##42 B1#19pmos@62_poly-right##43 9.871
R2043 B1#19pmos@62_poly-right##43 B1#19pmos@62_poly-right##44 9.871
R2044 B1#19pmos@62_poly-right##44 B1#19pmos@62_poly-right##45 9.871
R2045 B1#19pmos@62_poly-right##45 B1#19pmos@62_poly-right##46 9.871
R2046 B1#19pmos@62_poly-right##46 B1#19pmos@62_poly-right##47 9.871
R2047 B1#19pmos@62_poly-right##47 B1#19pmos@62_poly-right##48 9.871
R2048 B1#19pmos@62_poly-right##48 B1#19pmos@62_poly-right##49 9.871
R2049 B1#19pmos@62_poly-right##49 B1#19pmos@62_poly-right##50 9.871
R2050 B1#19pmos@62_poly-right##50 B1#19pmos@62_poly-right##51 9.871
R2051 B1#19pmos@62_poly-right##51 B1#19pmos@62_poly-right##52 9.871
R2052 B1#19pmos@62_poly-right##52 B1#19pmos@62_poly-right##53 9.871
R2053 B1#19pmos@62_poly-right##53 B1#19pmos@62_poly-right##54 9.871
R2054 B1#19pmos@62_poly-right##54 B1#19pmos@62_poly-right##55 9.871
R2055 B1#19pmos@62_poly-right##55 B1#17nmos@62_poly-left 9.871
R2056 net@1314#14pmos@63_poly-right net@1314#14pmos@63_poly-right##0 9.871
R2057 net@1314#14pmos@63_poly-right##0 net@1314#14pmos@63_poly-right##1 9.871
R2058 net@1314#14pmos@63_poly-right##1 net@1314#14pmos@63_poly-right##2 9.871
R2059 net@1314#14pmos@63_poly-right##2 net@1314#14pmos@63_poly-right##3 9.871
R2060 net@1314#14pmos@63_poly-right##3 net@1314#14pmos@63_poly-right##4 9.871
R2061 net@1314#14pmos@63_poly-right##4 net@1314#14pmos@63_poly-right##5 9.871
R2062 net@1314#14pmos@63_poly-right##5 net@1314#14pmos@63_poly-right##6 9.871
R2063 net@1314#14pmos@63_poly-right##6 net@1314#14pmos@63_poly-right##7 9.871
R2064 net@1314#14pmos@63_poly-right##7 net@1314#14pmos@63_poly-right##8 9.871
R2065 net@1314#14pmos@63_poly-right##8 net@1314#14pmos@63_poly-right##9 9.871
R2066 net@1314#14pmos@63_poly-right##9 net@1314#14pmos@63_poly-right##10 9.871
R2067 net@1314#14pmos@63_poly-right##10 net@1314#14pmos@63_poly-right##11 9.871
R2068 net@1314#14pmos@63_poly-right##11 net@1314#14pmos@63_poly-right##12 9.871
R2069 net@1314#14pmos@63_poly-right##12 net@1314#14pmos@63_poly-right##13 9.871
R2070 net@1314#14pmos@63_poly-right##13 net@1314#14pmos@63_poly-right##14 9.871
R2071 net@1314#14pmos@63_poly-right##14 net@1314#14pmos@63_poly-right##15 9.871
R2072 net@1314#14pmos@63_poly-right##15 net@1314#14pmos@63_poly-right##16 9.871
R2073 net@1314#14pmos@63_poly-right##16 net@1314#14pmos@63_poly-right##17 9.871
R2074 net@1314#14pmos@63_poly-right##17 net@1314#14pmos@63_poly-right##18 9.871
R2075 net@1314#14pmos@63_poly-right##18 net@1314#14pmos@63_poly-right##19 9.871
R2076 net@1314#14pmos@63_poly-right##19 net@1314#14pmos@63_poly-right##20 9.871
R2077 net@1314#14pmos@63_poly-right##20 net@1314#14pmos@63_poly-right##21 9.871
R2078 net@1314#14pmos@63_poly-right##21 net@1314#14pmos@63_poly-right##22 9.871
R2079 net@1314#14pmos@63_poly-right##22 net@1314#14pmos@63_poly-right##23 9.871
R2080 net@1314#14pmos@63_poly-right##23 net@1314#14pmos@63_poly-right##24 9.871
R2081 net@1314#14pmos@63_poly-right##24 net@1314#14pmos@63_poly-right##25 9.871
R2082 net@1314#14pmos@63_poly-right##25 net@1314#14pmos@63_poly-right##26 9.871
R2083 net@1314#14pmos@63_poly-right##26 net@1314#14pmos@63_poly-right##27 9.871
R2084 net@1314#14pmos@63_poly-right##27 net@1314#14pmos@63_poly-right##28 9.871
R2085 net@1314#14pmos@63_poly-right##28 net@1314#14pmos@63_poly-right##29 9.871
R2086 net@1314#14pmos@63_poly-right##29 net@1314#14pmos@63_poly-right##30 9.871
R2087 net@1314#14pmos@63_poly-right##30 net@1314#14pmos@63_poly-right##31 9.871
R2088 net@1314#14pmos@63_poly-right##31 net@1314#14pmos@63_poly-right##32 9.871
R2089 net@1314#14pmos@63_poly-right##32 net@1314#14pmos@63_poly-right##33 9.871
R2090 net@1314#14pmos@63_poly-right##33 net@1314#14pmos@63_poly-right##34 9.871
R2091 net@1314#14pmos@63_poly-right##34 net@1314#14pmos@63_poly-right##35 9.871
R2092 net@1314#14pmos@63_poly-right##35 net@1314#14pmos@63_poly-right##36 9.871
R2093 net@1314#14pmos@63_poly-right##36 net@1314#14pmos@63_poly-right##37 9.871
R2094 net@1314#14pmos@63_poly-right##37 net@1314#14pmos@63_poly-right##38 9.871
R2095 net@1314#14pmos@63_poly-right##38 net@1314#14pmos@63_poly-right##39 9.871
R2096 net@1314#14pmos@63_poly-right##39 net@1314#14pmos@63_poly-right##40 9.871
R2097 net@1314#14pmos@63_poly-right##40 net@1314#14pmos@63_poly-right##41 9.871
R2098 net@1314#14pmos@63_poly-right##41 net@1314#14pmos@63_poly-right##42 9.871
R2099 net@1314#14pmos@63_poly-right##42 net@1314#14pmos@63_poly-right##43 9.871
R2100 net@1314#14pmos@63_poly-right##43 net@1314#14pmos@63_poly-right##44 9.871
R2101 net@1314#14pmos@63_poly-right##44 net@1314#14pmos@63_poly-right##45 9.871
R2102 net@1314#14pmos@63_poly-right##45 net@1314#14pmos@63_poly-right##46 9.871
R2103 net@1314#14pmos@63_poly-right##46 net@1314#14pmos@63_poly-right##47 9.871
R2104 net@1314#14pmos@63_poly-right##47 net@1314#14pmos@63_poly-right##48 9.871
R2105 net@1314#14pmos@63_poly-right##48 net@1314#14pmos@63_poly-right##49 9.871
R2106 net@1314#14pmos@63_poly-right##49 net@1314#14pmos@63_poly-right##50 9.871
R2107 net@1314#14pmos@63_poly-right##50 net@1314#14pmos@63_poly-right##51 9.871
R2108 net@1314#14pmos@63_poly-right##51 net@1314#14pmos@63_poly-right##52 9.871
R2109 net@1314#14pmos@63_poly-right##52 net@1314#14pmos@63_poly-right##53 9.871
R2110 net@1314#14pmos@63_poly-right##53 net@1314#14pmos@63_poly-right##54 9.871
R2111 net@1314#14pmos@63_poly-right##54 net@1314#14pmos@63_poly-right##55 9.871
R2112 net@1314#14pmos@63_poly-right##55 net@1314#9nmos@63_poly-left 9.871
R2113 net@1307#2contact@491_metal-1-polysilicon-1 net@1307 4.706
R2114 net@1307#12pmos@66_poly-right net@1307#12pmos@66_poly-right##0 9.864
R2115 net@1307#12pmos@66_poly-right##0 net@1307#12pmos@66_poly-right##1 9.864
R2116 net@1307#12pmos@66_poly-right##1 net@1307#12pmos@66_poly-right##2 9.864
R2117 net@1307#12pmos@66_poly-right##2 net@1307#12pmos@66_poly-right##3 9.864
R2118 net@1307#12pmos@66_poly-right##3 net@1307#12pmos@66_poly-right##4 9.864
R2119 net@1307#12pmos@66_poly-right##4 net@1307#12pmos@66_poly-right##5 9.864
R2120 net@1307#12pmos@66_poly-right##5 net@1307#12pmos@66_poly-right##6 9.864
R2121 net@1307#12pmos@66_poly-right##6 net@1307#12pmos@66_poly-right##7 9.864
R2122 net@1307#12pmos@66_poly-right##7 net@1307#12pmos@66_poly-right##8 9.864
R2123 net@1307#12pmos@66_poly-right##8 net@1307#12pmos@66_poly-right##9 9.864
R2124 net@1307#12pmos@66_poly-right##9 net@1307#12pmos@66_poly-right##10 9.864
R2125 net@1307#12pmos@66_poly-right##10 net@1307#12pmos@66_poly-right##11 9.864
R2126 net@1307#12pmos@66_poly-right##11 net@1307#12pmos@66_poly-right##12 9.864
R2127 net@1307#12pmos@66_poly-right##12 net@1307#12pmos@66_poly-right##13 9.864
R2128 net@1307#12pmos@66_poly-right##13 net@1307#12pmos@66_poly-right##14 9.864
R2129 net@1307#12pmos@66_poly-right##14 net@1307#12pmos@66_poly-right##15 9.864
R2130 net@1307#12pmos@66_poly-right##15 net@1307#12pmos@66_poly-right##16 9.864
R2131 net@1307#12pmos@66_poly-right##16 net@1307#12pmos@66_poly-right##17 9.864
R2132 net@1307#12pmos@66_poly-right##17 net@1307#12pmos@66_poly-right##18 9.864
R2133 net@1307#12pmos@66_poly-right##18 net@1307#12pmos@66_poly-right##19 9.864
R2134 net@1307#12pmos@66_poly-right##19 net@1307#12pmos@66_poly-right##20 9.864
R2135 net@1307#12pmos@66_poly-right##20 net@1307#12pmos@66_poly-right##21 9.864
R2136 net@1307#12pmos@66_poly-right##21 net@1307#12pmos@66_poly-right##22 9.864
R2137 net@1307#12pmos@66_poly-right##22 net@1307#12pmos@66_poly-right##23 9.864
R2138 net@1307#12pmos@66_poly-right##23 net@1307#12pmos@66_poly-right##24 9.864
R2139 net@1307#12pmos@66_poly-right##24 net@1307#12pmos@66_poly-right##25 9.864
R2140 net@1307#12pmos@66_poly-right##25 net@1307#12pmos@66_poly-right##26 9.864
R2141 net@1307#12pmos@66_poly-right##26 net@1307#12pmos@66_poly-right##27 9.864
R2142 net@1307#12pmos@66_poly-right##27 net@1307#12pmos@66_poly-right##28 9.864
R2143 net@1307#12pmos@66_poly-right##28 net@1307#12pmos@66_poly-right##29 9.864
R2144 net@1307#12pmos@66_poly-right##29 net@1307#12pmos@66_poly-right##30 9.864
R2145 net@1307#12pmos@66_poly-right##30 net@1307#12pmos@66_poly-right##31 9.864
R2146 net@1307#12pmos@66_poly-right##31 net@1307#12pmos@66_poly-right##32 9.864
R2147 net@1307#12pmos@66_poly-right##32 net@1307#12pmos@66_poly-right##33 9.864
R2148 net@1307#12pmos@66_poly-right##33 net@1307#12pmos@66_poly-right##34 9.864
R2149 net@1307#12pmos@66_poly-right##34 net@1307#12pmos@66_poly-right##35 9.864
R2150 net@1307#12pmos@66_poly-right##35 net@1307#12pmos@66_poly-right##36 9.864
R2151 net@1307#12pmos@66_poly-right##36 net@1307#12pmos@66_poly-right##37 9.864
R2152 net@1307#12pmos@66_poly-right##37 net@1307#12pmos@66_poly-right##38 9.864
R2153 net@1307#12pmos@66_poly-right##38 net@1307#12pmos@66_poly-right##39 9.864
R2154 net@1307#12pmos@66_poly-right##39 net@1307#12pmos@66_poly-right##40 9.864
R2155 net@1307#12pmos@66_poly-right##40 net@1307#12pmos@66_poly-right##41 9.864
R2156 net@1307#12pmos@66_poly-right##41 net@1307#12pmos@66_poly-right##42 9.864
R2157 net@1307#12pmos@66_poly-right##42 net@1307#12pmos@66_poly-right##43 9.864
R2158 net@1307#12pmos@66_poly-right##43 net@1307#12pmos@66_poly-right##44 9.864
R2159 net@1307#12pmos@66_poly-right##44 net@1307#12pmos@66_poly-right##45 9.864
R2160 net@1307#12pmos@66_poly-right##45 net@1307#12pmos@66_poly-right##46 9.864
R2161 net@1307#12pmos@66_poly-right##46 net@1307#12pmos@66_poly-right##47 9.864
R2162 net@1307#12pmos@66_poly-right##47 net@1307#12pmos@66_poly-right##48 9.864
R2163 net@1307#12pmos@66_poly-right##48 net@1307#12pmos@66_poly-right##49 9.864
R2164 net@1307#12pmos@66_poly-right##49 net@1307#12pmos@66_poly-right##50 9.864
R2165 net@1307#12pmos@66_poly-right##50 net@1307#12pmos@66_poly-right##51 9.864
R2166 net@1307#12pmos@66_poly-right##51 net@1307#12pmos@66_poly-right##52 9.864
R2167 net@1307#12pmos@66_poly-right##52 net@1307#12pmos@66_poly-right##53 9.864
R2168 net@1307#12pmos@66_poly-right##53 net@1307#5pin@345_polysilicon-1 9.864
R2169 XOR1_to_NAND2#22pmos@66_diff-top XOR1_to_NAND2#1contact@544_metal-1-metal-2 4.862
R2170 XOR1_to_NAND2#3pin@378_polysilicon-1 XOR1_to_NAND2#3pin@378_polysilicon-1##0 9.881
R2171 XOR1_to_NAND2#3pin@378_polysilicon-1##0 XOR1_to_NAND2#3pin@378_polysilicon-1##1 9.881
R2172 XOR1_to_NAND2#3pin@378_polysilicon-1##1 XOR1_to_NAND2#3pin@378_polysilicon-1##2 9.881
R2173 XOR1_to_NAND2#3pin@378_polysilicon-1##2 XOR1_to_NAND2#3pin@378_polysilicon-1##3 9.881
R2174 XOR1_to_NAND2#3pin@378_polysilicon-1##3 XOR1_to_NAND2#3pin@378_polysilicon-1##4 9.881
R2175 XOR1_to_NAND2#3pin@378_polysilicon-1##4 XOR1_to_NAND2#3pin@378_polysilicon-1##5 9.881
R2176 XOR1_to_NAND2#3pin@378_polysilicon-1##5 XOR1_to_NAND2#3pin@378_polysilicon-1##6 9.881
R2177 XOR1_to_NAND2#3pin@378_polysilicon-1##6 XOR1_to_NAND2#3pin@378_polysilicon-1##7 9.881
R2178 XOR1_to_NAND2#3pin@378_polysilicon-1##7 XOR1_to_NAND2#3pin@378_polysilicon-1##8 9.881
R2179 XOR1_to_NAND2#3pin@378_polysilicon-1##8 XOR1_to_NAND2#3pin@378_polysilicon-1##9 9.881
R2180 XOR1_to_NAND2#3pin@378_polysilicon-1##9 XOR1_to_NAND2#3pin@378_polysilicon-1##10 9.881
R2181 XOR1_to_NAND2#3pin@378_polysilicon-1##10 XOR1_to_NAND2#3pin@378_polysilicon-1##11 9.881
R2182 XOR1_to_NAND2#3pin@378_polysilicon-1##11 XOR1_to_NAND2#3pin@378_polysilicon-1##12 9.881
R2183 XOR1_to_NAND2#3pin@378_polysilicon-1##12 XOR1_to_NAND2#3pin@378_polysilicon-1##13 9.881
R2184 XOR1_to_NAND2#3pin@378_polysilicon-1##13 XOR1_to_NAND2#3pin@378_polysilicon-1##14 9.881
R2185 XOR1_to_NAND2#3pin@378_polysilicon-1##14 XOR1_to_NAND2#3pin@378_polysilicon-1##15 9.881
R2186 XOR1_to_NAND2#3pin@378_polysilicon-1##15 XOR1_to_NAND2#3pin@378_polysilicon-1##16 9.881
R2187 XOR1_to_NAND2#3pin@378_polysilicon-1##16 XOR1_to_NAND2#3pin@378_polysilicon-1##17 9.881
R2188 XOR1_to_NAND2#3pin@378_polysilicon-1##17 XOR1_to_NAND2#3pin@378_polysilicon-1##18 9.881
R2189 XOR1_to_NAND2#3pin@378_polysilicon-1##18 XOR1_to_NAND2#3pin@378_polysilicon-1##19 9.881
R2190 XOR1_to_NAND2#3pin@378_polysilicon-1##19 XOR1_to_NAND2#3pin@378_polysilicon-1##20 9.881
R2191 XOR1_to_NAND2#3pin@378_polysilicon-1##20 XOR1_to_NAND2#3pin@378_polysilicon-1##21 9.881
R2192 XOR1_to_NAND2#3pin@378_polysilicon-1##21 XOR1_to_NAND2#3pin@378_polysilicon-1##22 9.881
R2193 XOR1_to_NAND2#3pin@378_polysilicon-1##22 XOR1_to_NAND2#3pin@378_polysilicon-1##23 9.881
R2194 XOR1_to_NAND2#3pin@378_polysilicon-1##23 XOR1_to_NAND2#3pin@378_polysilicon-1##24 9.881
R2195 XOR1_to_NAND2#3pin@378_polysilicon-1##24 XOR1_to_NAND2#3pin@378_polysilicon-1##25 9.881
R2196 XOR1_to_NAND2#3pin@378_polysilicon-1##25 XOR1_to_NAND2#3pin@378_polysilicon-1##26 9.881
R2197 XOR1_to_NAND2#3pin@378_polysilicon-1##26 XOR1_to_NAND2#3pin@378_polysilicon-1##27 9.881
R2198 XOR1_to_NAND2#3pin@378_polysilicon-1##27 XOR1_to_NAND2#3pin@378_polysilicon-1##28 9.881
R2199 XOR1_to_NAND2#3pin@378_polysilicon-1##28 XOR1_to_NAND2#3pin@378_polysilicon-1##29 9.881
R2200 XOR1_to_NAND2#3pin@378_polysilicon-1##29 XOR1_to_NAND2#3pin@378_polysilicon-1##30 9.881
R2201 XOR1_to_NAND2#3pin@378_polysilicon-1##30 XOR1_to_NAND2#3pin@378_polysilicon-1##31 9.881
R2202 XOR1_to_NAND2#3pin@378_polysilicon-1##31 XOR1_to_NAND2#3pin@378_polysilicon-1##32 9.881
R2203 XOR1_to_NAND2#3pin@378_polysilicon-1##32 XOR1_to_NAND2#3pin@378_polysilicon-1##33 9.881
R2204 XOR1_to_NAND2#3pin@378_polysilicon-1##33 XOR1_to_NAND2#3pin@378_polysilicon-1##34 9.881
R2205 XOR1_to_NAND2#3pin@378_polysilicon-1##34 XOR1_to_NAND2#3pin@378_polysilicon-1##35 9.881
R2206 XOR1_to_NAND2#3pin@378_polysilicon-1##35 XOR1_to_NAND2#3pin@378_polysilicon-1##36 9.881
R2207 XOR1_to_NAND2#3pin@378_polysilicon-1##36 XOR1_to_NAND2#3pin@378_polysilicon-1##37 9.881
R2208 XOR1_to_NAND2#3pin@378_polysilicon-1##37 XOR1_to_NAND2#3pin@378_polysilicon-1##38 9.881
R2209 XOR1_to_NAND2#3pin@378_polysilicon-1##38 XOR1_to_NAND2#3pin@378_polysilicon-1##39 9.881
R2210 XOR1_to_NAND2#3pin@378_polysilicon-1##39 XOR1_to_NAND2#3pin@378_polysilicon-1##40 9.881
R2211 XOR1_to_NAND2#3pin@378_polysilicon-1##40 XOR1_to_NAND2#3pin@378_polysilicon-1##41 9.881
R2212 XOR1_to_NAND2#3pin@378_polysilicon-1##41 XOR1_to_NAND2#3pin@378_polysilicon-1##42 9.881
R2213 XOR1_to_NAND2#3pin@378_polysilicon-1##42 XOR1_to_NAND2#3pin@378_polysilicon-1##43 9.881
R2214 XOR1_to_NAND2#3pin@378_polysilicon-1##43 XOR1_to_NAND2#3pin@378_polysilicon-1##44 9.881
R2215 XOR1_to_NAND2#3pin@378_polysilicon-1##44 XOR1_to_NAND2#3pin@378_polysilicon-1##45 9.881
R2216 XOR1_to_NAND2#3pin@378_polysilicon-1##45 XOR1_to_NAND2#3pin@378_polysilicon-1##46 9.881
R2217 XOR1_to_NAND2#3pin@378_polysilicon-1##46 XOR1_to_NAND2#3pin@378_polysilicon-1##47 9.881
R2218 XOR1_to_NAND2#3pin@378_polysilicon-1##47 XOR1_to_NAND2#3pin@378_polysilicon-1##48 9.881
R2219 XOR1_to_NAND2#3pin@378_polysilicon-1##48 XOR1_to_NAND2#3pin@378_polysilicon-1##49 9.881
R2220 XOR1_to_NAND2#3pin@378_polysilicon-1##49 XOR1_to_NAND2#3pin@378_polysilicon-1##50 9.881
R2221 XOR1_to_NAND2#3pin@378_polysilicon-1##50 XOR1_to_NAND2#3pin@378_polysilicon-1##51 9.881
R2222 XOR1_to_NAND2#3pin@378_polysilicon-1##51 XOR1_to_NAND2#3pin@378_polysilicon-1##52 9.881
R2223 XOR1_to_NAND2#3pin@378_polysilicon-1##52 XOR1_to_NAND2#3pin@378_polysilicon-1##53 9.881
R2224 XOR1_to_NAND2#3pin@378_polysilicon-1##53 XOR1_to_NAND2#3pin@378_polysilicon-1##54 9.881
R2225 XOR1_to_NAND2#3pin@378_polysilicon-1##54 XOR1_to_NAND2#24nmos@72_poly-right 9.881
R2226 net@1211#5pmos@72_diff-top net@1211#2pin@367_metal-1 4.81
R2227 net@1211#1pin@377_polysilicon-1 net@1211#1pin@377_polysilicon-1##0 9.85
R2228 net@1211#1pin@377_polysilicon-1##0 net@1211#1pin@377_polysilicon-1##1 9.85
R2229 net@1211#1pin@377_polysilicon-1##1 net@1211#1pin@377_polysilicon-1##2 9.85
R2230 net@1211#1pin@377_polysilicon-1##2 net@1211#1pin@377_polysilicon-1##3 9.85
R2231 net@1211#1pin@377_polysilicon-1##3 net@1211#1pin@377_polysilicon-1##4 9.85
R2232 net@1211#1pin@377_polysilicon-1##4 net@1211#1pin@377_polysilicon-1##5 9.85
R2233 net@1211#1pin@377_polysilicon-1##5 net@1211#1pin@377_polysilicon-1##6 9.85
R2234 net@1211#1pin@377_polysilicon-1##6 net@1211#1pin@377_polysilicon-1##7 9.85
R2235 net@1211#1pin@377_polysilicon-1##7 net@1211#1pin@377_polysilicon-1##8 9.85
R2236 net@1211#1pin@377_polysilicon-1##8 net@1211#1pin@377_polysilicon-1##9 9.85
R2237 net@1211#1pin@377_polysilicon-1##9 net@1211#1pin@377_polysilicon-1##10 9.85
R2238 net@1211#1pin@377_polysilicon-1##10 net@1211#1pin@377_polysilicon-1##11 9.85
R2239 net@1211#1pin@377_polysilicon-1##11 net@1211#1pin@377_polysilicon-1##12 9.85
R2240 net@1211#1pin@377_polysilicon-1##12 net@1211#1pin@377_polysilicon-1##13 9.85
R2241 net@1211#1pin@377_polysilicon-1##13 net@1211#1pin@377_polysilicon-1##14 9.85
R2242 net@1211#1pin@377_polysilicon-1##14 net@1211#1pin@377_polysilicon-1##15 9.85
R2243 net@1211#1pin@377_polysilicon-1##15 net@1211#1pin@377_polysilicon-1##16 9.85
R2244 net@1211#1pin@377_polysilicon-1##16 net@1211#1pin@377_polysilicon-1##17 9.85
R2245 net@1211#1pin@377_polysilicon-1##17 net@1211#1pin@377_polysilicon-1##18 9.85
R2246 net@1211#1pin@377_polysilicon-1##18 net@1211#1pin@377_polysilicon-1##19 9.85
R2247 net@1211#1pin@377_polysilicon-1##19 net@1211#1pin@377_polysilicon-1##20 9.85
R2248 net@1211#1pin@377_polysilicon-1##20 net@1211#1pin@377_polysilicon-1##21 9.85
R2249 net@1211#1pin@377_polysilicon-1##21 net@1211#1pin@377_polysilicon-1##22 9.85
R2250 net@1211#1pin@377_polysilicon-1##22 net@1211#1pin@377_polysilicon-1##23 9.85
R2251 net@1211#1pin@377_polysilicon-1##23 net@1211#1pin@377_polysilicon-1##24 9.85
R2252 net@1211#1pin@377_polysilicon-1##24 net@1211#1pin@377_polysilicon-1##25 9.85
R2253 net@1211#1pin@377_polysilicon-1##25 net@1211#1pin@377_polysilicon-1##26 9.85
R2254 net@1211#1pin@377_polysilicon-1##26 net@1211#1pin@377_polysilicon-1##27 9.85
R2255 net@1211#1pin@377_polysilicon-1##27 net@1211#1pin@377_polysilicon-1##28 9.85
R2256 net@1211#1pin@377_polysilicon-1##28 net@1211#1pin@377_polysilicon-1##29 9.85
R2257 net@1211#1pin@377_polysilicon-1##29 net@1211#1pin@377_polysilicon-1##30 9.85
R2258 net@1211#1pin@377_polysilicon-1##30 net@1211#1pin@377_polysilicon-1##31 9.85
R2259 net@1211#1pin@377_polysilicon-1##31 net@1211#1pin@377_polysilicon-1##32 9.85
R2260 net@1211#1pin@377_polysilicon-1##32 net@1211#1pin@377_polysilicon-1##33 9.85
R2261 net@1211#1pin@377_polysilicon-1##33 net@1211#1pin@377_polysilicon-1##34 9.85
R2262 net@1211#1pin@377_polysilicon-1##34 net@1211#1pin@377_polysilicon-1##35 9.85
R2263 net@1211#1pin@377_polysilicon-1##35 net@1211#1pin@377_polysilicon-1##36 9.85
R2264 net@1211#1pin@377_polysilicon-1##36 net@1211#1pin@377_polysilicon-1##37 9.85
R2265 net@1211#1pin@377_polysilicon-1##37 net@1211#1pin@377_polysilicon-1##38 9.85
R2266 net@1211#1pin@377_polysilicon-1##38 net@1211#1pin@377_polysilicon-1##39 9.85
R2267 net@1211#1pin@377_polysilicon-1##39 net@1211#1pin@377_polysilicon-1##40 9.85
R2268 net@1211#1pin@377_polysilicon-1##40 net@1211#1pin@377_polysilicon-1##41 9.85
R2269 net@1211#1pin@377_polysilicon-1##41 net@1211#1pin@377_polysilicon-1##42 9.85
R2270 net@1211#1pin@377_polysilicon-1##42 net@1211#1pin@377_polysilicon-1##43 9.85
R2271 net@1211#1pin@377_polysilicon-1##43 net@1211#1pin@377_polysilicon-1##44 9.85
R2272 net@1211#1pin@377_polysilicon-1##44 net@1211#1pin@377_polysilicon-1##45 9.85
R2273 net@1211#1pin@377_polysilicon-1##45 net@1211#1pin@377_polysilicon-1##46 9.85
R2274 net@1211#1pin@377_polysilicon-1##46 net@1211#1pin@377_polysilicon-1##47 9.85
R2275 net@1211#1pin@377_polysilicon-1##47 net@1211#1pin@377_polysilicon-1##48 9.85
R2276 net@1211#1pin@377_polysilicon-1##48 net@1211#1pin@377_polysilicon-1##49 9.85
R2277 net@1211#1pin@377_polysilicon-1##49 net@1211#1pin@377_polysilicon-1##50 9.85
R2278 net@1211#1pin@377_polysilicon-1##50 net@1211#1pin@377_polysilicon-1##51 9.85
R2279 net@1211#1pin@377_polysilicon-1##51 net@1211#1pin@377_polysilicon-1##52 9.85
R2280 net@1211#1pin@377_polysilicon-1##52 net@1211#1pin@377_polysilicon-1##53 9.85
R2281 net@1211#1pin@377_polysilicon-1##53 net@1211#1pin@377_polysilicon-1##54 9.85
R2282 net@1211#1pin@377_polysilicon-1##54 net@1211#1pin@377_polysilicon-1##55 9.85
R2283 net@1211#1pin@377_polysilicon-1##55 net@1211#1pin@377_polysilicon-1##56 9.85
R2284 net@1211#1pin@377_polysilicon-1##56 net@1211#1pin@377_polysilicon-1##57 9.85
R2285 net@1211#1pin@377_polysilicon-1##57 net@1211#1pin@377_polysilicon-1##58 9.85
R2286 net@1211#1pin@377_polysilicon-1##58 net@1211#1pin@377_polysilicon-1##59 9.85
R2287 net@1211#1pin@377_polysilicon-1##59 net@1211#1pin@377_polysilicon-1##60 9.85
R2288 net@1211#1pin@377_polysilicon-1##60 net@1211#2pin@367_metal-1 9.85
R2289 Cin_to_XOR2___NAND2#34pmos@71_poly-right Cin_to_XOR2___NAND2#34pmos@71_poly-right##0 9.854
R2290 Cin_to_XOR2___NAND2#34pmos@71_poly-right##0 Cin_to_XOR2___NAND2#34pmos@71_poly-right##1 9.854
R2291 Cin_to_XOR2___NAND2#34pmos@71_poly-right##1 Cin_to_XOR2___NAND2#34pmos@71_poly-right##2 9.854
R2292 Cin_to_XOR2___NAND2#34pmos@71_poly-right##2 Cin_to_XOR2___NAND2#34pmos@71_poly-right##3 9.854
R2293 Cin_to_XOR2___NAND2#34pmos@71_poly-right##3 Cin_to_XOR2___NAND2#34pmos@71_poly-right##4 9.854
R2294 Cin_to_XOR2___NAND2#34pmos@71_poly-right##4 Cin_to_XOR2___NAND2#34pmos@71_poly-right##5 9.854
R2295 Cin_to_XOR2___NAND2#34pmos@71_poly-right##5 Cin_to_XOR2___NAND2#34pmos@71_poly-right##6 9.854
R2296 Cin_to_XOR2___NAND2#34pmos@71_poly-right##6 Cin_to_XOR2___NAND2#34pmos@71_poly-right##7 9.854
R2297 Cin_to_XOR2___NAND2#34pmos@71_poly-right##7 Cin_to_XOR2___NAND2#34pmos@71_poly-right##8 9.854
R2298 Cin_to_XOR2___NAND2#34pmos@71_poly-right##8 Cin_to_XOR2___NAND2#34pmos@71_poly-right##9 9.854
R2299 Cin_to_XOR2___NAND2#34pmos@71_poly-right##9 Cin_to_XOR2___NAND2#34pmos@71_poly-right##10 9.854
R2300 Cin_to_XOR2___NAND2#34pmos@71_poly-right##10 Cin_to_XOR2___NAND2#34pmos@71_poly-right##11 9.854
R2301 Cin_to_XOR2___NAND2#34pmos@71_poly-right##11 Cin_to_XOR2___NAND2#34pmos@71_poly-right##12 9.854
R2302 Cin_to_XOR2___NAND2#34pmos@71_poly-right##12 Cin_to_XOR2___NAND2#34pmos@71_poly-right##13 9.854
R2303 Cin_to_XOR2___NAND2#34pmos@71_poly-right##13 Cin_to_XOR2___NAND2#34pmos@71_poly-right##14 9.854
R2304 Cin_to_XOR2___NAND2#34pmos@71_poly-right##14 Cin_to_XOR2___NAND2#34pmos@71_poly-right##15 9.854
R2305 Cin_to_XOR2___NAND2#34pmos@71_poly-right##15 Cin_to_XOR2___NAND2#34pmos@71_poly-right##16 9.854
R2306 Cin_to_XOR2___NAND2#34pmos@71_poly-right##16 Cin_to_XOR2___NAND2#34pmos@71_poly-right##17 9.854
R2307 Cin_to_XOR2___NAND2#34pmos@71_poly-right##17 Cin_to_XOR2___NAND2#34pmos@71_poly-right##18 9.854
R2308 Cin_to_XOR2___NAND2#34pmos@71_poly-right##18 Cin_to_XOR2___NAND2#34pmos@71_poly-right##19 9.854
R2309 Cin_to_XOR2___NAND2#34pmos@71_poly-right##19 Cin_to_XOR2___NAND2#34pmos@71_poly-right##20 9.854
R2310 Cin_to_XOR2___NAND2#34pmos@71_poly-right##20 Cin_to_XOR2___NAND2#34pmos@71_poly-right##21 9.854
R2311 Cin_to_XOR2___NAND2#34pmos@71_poly-right##21 Cin_to_XOR2___NAND2#34pmos@71_poly-right##22 9.854
R2312 Cin_to_XOR2___NAND2#34pmos@71_poly-right##22 Cin_to_XOR2___NAND2#34pmos@71_poly-right##23 9.854
R2313 Cin_to_XOR2___NAND2#34pmos@71_poly-right##23 Cin_to_XOR2___NAND2#34pmos@71_poly-right##24 9.854
R2314 Cin_to_XOR2___NAND2#34pmos@71_poly-right##24 Cin_to_XOR2___NAND2#34pmos@71_poly-right##25 9.854
R2315 Cin_to_XOR2___NAND2#34pmos@71_poly-right##25 Cin_to_XOR2___NAND2#34pmos@71_poly-right##26 9.854
R2316 Cin_to_XOR2___NAND2#34pmos@71_poly-right##26 Cin_to_XOR2___NAND2#34pmos@71_poly-right##27 9.854
R2317 Cin_to_XOR2___NAND2#34pmos@71_poly-right##27 Cin_to_XOR2___NAND2#34pmos@71_poly-right##28 9.854
R2318 Cin_to_XOR2___NAND2#34pmos@71_poly-right##28 Cin_to_XOR2___NAND2#34pmos@71_poly-right##29 9.854
R2319 Cin_to_XOR2___NAND2#34pmos@71_poly-right##29 Cin_to_XOR2___NAND2#34pmos@71_poly-right##30 9.854
R2320 Cin_to_XOR2___NAND2#34pmos@71_poly-right##30 Cin_to_XOR2___NAND2#34pmos@71_poly-right##31 9.854
R2321 Cin_to_XOR2___NAND2#34pmos@71_poly-right##31 Cin_to_XOR2___NAND2#34pmos@71_poly-right##32 9.854
R2322 Cin_to_XOR2___NAND2#34pmos@71_poly-right##32 Cin_to_XOR2___NAND2#34pmos@71_poly-right##33 9.854
R2323 Cin_to_XOR2___NAND2#34pmos@71_poly-right##33 Cin_to_XOR2___NAND2#34pmos@71_poly-right##34 9.854
R2324 Cin_to_XOR2___NAND2#34pmos@71_poly-right##34 Cin_to_XOR2___NAND2#34pmos@71_poly-right##35 9.854
R2325 Cin_to_XOR2___NAND2#34pmos@71_poly-right##35 Cin_to_XOR2___NAND2#34pmos@71_poly-right##36 9.854
R2326 Cin_to_XOR2___NAND2#34pmos@71_poly-right##36 Cin_to_XOR2___NAND2#34pmos@71_poly-right##37 9.854
R2327 Cin_to_XOR2___NAND2#34pmos@71_poly-right##37 Cin_to_XOR2___NAND2#34pmos@71_poly-right##38 9.854
R2328 Cin_to_XOR2___NAND2#34pmos@71_poly-right##38 Cin_to_XOR2___NAND2#34pmos@71_poly-right##39 9.854
R2329 Cin_to_XOR2___NAND2#34pmos@71_poly-right##39 Cin_to_XOR2___NAND2#34pmos@71_poly-right##40 9.854
R2330 Cin_to_XOR2___NAND2#34pmos@71_poly-right##40 Cin_to_XOR2___NAND2#34pmos@71_poly-right##41 9.854
R2331 Cin_to_XOR2___NAND2#34pmos@71_poly-right##41 Cin_to_XOR2___NAND2#34pmos@71_poly-right##42 9.854
R2332 Cin_to_XOR2___NAND2#34pmos@71_poly-right##42 Cin_to_XOR2___NAND2#34pmos@71_poly-right##43 9.854
R2333 Cin_to_XOR2___NAND2#34pmos@71_poly-right##43 Cin_to_XOR2___NAND2#34pmos@71_poly-right##44 9.854
R2334 Cin_to_XOR2___NAND2#34pmos@71_poly-right##44 Cin_to_XOR2___NAND2#34pmos@71_poly-right##45 9.854
R2335 Cin_to_XOR2___NAND2#34pmos@71_poly-right##45 Cin_to_XOR2___NAND2#34pmos@71_poly-right##46 9.854
R2336 Cin_to_XOR2___NAND2#34pmos@71_poly-right##46 Cin_to_XOR2___NAND2#34pmos@71_poly-right##47 9.854
R2337 Cin_to_XOR2___NAND2#34pmos@71_poly-right##47 Cin_to_XOR2___NAND2#34pmos@71_poly-right##48 9.854
R2338 Cin_to_XOR2___NAND2#34pmos@71_poly-right##48 Cin_to_XOR2___NAND2#34pmos@71_poly-right##49 9.854
R2339 Cin_to_XOR2___NAND2#34pmos@71_poly-right##49 Cin_to_XOR2___NAND2#34pmos@71_poly-right##50 9.854
R2340 Cin_to_XOR2___NAND2#34pmos@71_poly-right##50 Cin_to_XOR2___NAND2#34pmos@71_poly-right##51 9.854
R2341 Cin_to_XOR2___NAND2#34pmos@71_poly-right##51 Cin_to_XOR2___NAND2#34pmos@71_poly-right##52 9.854
R2342 Cin_to_XOR2___NAND2#34pmos@71_poly-right##52 Cin_to_XOR2___NAND2#34pmos@71_poly-right##53 9.854
R2343 Cin_to_XOR2___NAND2#34pmos@71_poly-right##53 Cin_to_XOR2___NAND2#34pmos@71_poly-right##54 9.854
R2344 Cin_to_XOR2___NAND2#34pmos@71_poly-right##54 Cin_to_XOR2___NAND2#23pin@368_polysilicon-1 9.854
R2345 net@1221 net@1221#2contact@505_metal-1-metal-2 4.797
R2346 XOR1_to_NAND2#9pmos@67_poly-left XOR1_to_NAND2#9pmos@67_poly-left##0 9.871
R2347 XOR1_to_NAND2#9pmos@67_poly-left##0 XOR1_to_NAND2#9pmos@67_poly-left##1 9.871
R2348 XOR1_to_NAND2#9pmos@67_poly-left##1 XOR1_to_NAND2#9pmos@67_poly-left##2 9.871
R2349 XOR1_to_NAND2#9pmos@67_poly-left##2 XOR1_to_NAND2#9pmos@67_poly-left##3 9.871
R2350 XOR1_to_NAND2#9pmos@67_poly-left##3 XOR1_to_NAND2#9pmos@67_poly-left##4 9.871
R2351 XOR1_to_NAND2#9pmos@67_poly-left##4 XOR1_to_NAND2#9pmos@67_poly-left##5 9.871
R2352 XOR1_to_NAND2#9pmos@67_poly-left##5 XOR1_to_NAND2#9pmos@67_poly-left##6 9.871
R2353 XOR1_to_NAND2#9pmos@67_poly-left##6 XOR1_to_NAND2#9pmos@67_poly-left##7 9.871
R2354 XOR1_to_NAND2#9pmos@67_poly-left##7 XOR1_to_NAND2#9pmos@67_poly-left##8 9.871
R2355 XOR1_to_NAND2#9pmos@67_poly-left##8 XOR1_to_NAND2#9pmos@67_poly-left##9 9.871
R2356 XOR1_to_NAND2#9pmos@67_poly-left##9 XOR1_to_NAND2#9pmos@67_poly-left##10 9.871
R2357 XOR1_to_NAND2#9pmos@67_poly-left##10 XOR1_to_NAND2#9pmos@67_poly-left##11 9.871
R2358 XOR1_to_NAND2#9pmos@67_poly-left##11 XOR1_to_NAND2#9pmos@67_poly-left##12 9.871
R2359 XOR1_to_NAND2#9pmos@67_poly-left##12 XOR1_to_NAND2#9pmos@67_poly-left##13 9.871
R2360 XOR1_to_NAND2#9pmos@67_poly-left##13 XOR1_to_NAND2#9pmos@67_poly-left##14 9.871
R2361 XOR1_to_NAND2#9pmos@67_poly-left##14 XOR1_to_NAND2#9pmos@67_poly-left##15 9.871
R2362 XOR1_to_NAND2#9pmos@67_poly-left##15 XOR1_to_NAND2#9pmos@67_poly-left##16 9.871
R2363 XOR1_to_NAND2#9pmos@67_poly-left##16 XOR1_to_NAND2#9pmos@67_poly-left##17 9.871
R2364 XOR1_to_NAND2#9pmos@67_poly-left##17 XOR1_to_NAND2#9pmos@67_poly-left##18 9.871
R2365 XOR1_to_NAND2#9pmos@67_poly-left##18 XOR1_to_NAND2#9pmos@67_poly-left##19 9.871
R2366 XOR1_to_NAND2#9pmos@67_poly-left##19 XOR1_to_NAND2#9pmos@67_poly-left##20 9.871
R2367 XOR1_to_NAND2#9pmos@67_poly-left##20 XOR1_to_NAND2#9pmos@67_poly-left##21 9.871
R2368 XOR1_to_NAND2#9pmos@67_poly-left##21 XOR1_to_NAND2#9pmos@67_poly-left##22 9.871
R2369 XOR1_to_NAND2#9pmos@67_poly-left##22 XOR1_to_NAND2#9pmos@67_poly-left##23 9.871
R2370 XOR1_to_NAND2#9pmos@67_poly-left##23 XOR1_to_NAND2#9pmos@67_poly-left##24 9.871
R2371 XOR1_to_NAND2#9pmos@67_poly-left##24 XOR1_to_NAND2#9pmos@67_poly-left##25 9.871
R2372 XOR1_to_NAND2#9pmos@67_poly-left##25 XOR1_to_NAND2#9pmos@67_poly-left##26 9.871
R2373 XOR1_to_NAND2#9pmos@67_poly-left##26 XOR1_to_NAND2#9pmos@67_poly-left##27 9.871
R2374 XOR1_to_NAND2#9pmos@67_poly-left##27 XOR1_to_NAND2#9pmos@67_poly-left##28 9.871
R2375 XOR1_to_NAND2#9pmos@67_poly-left##28 XOR1_to_NAND2#9pmos@67_poly-left##29 9.871
R2376 XOR1_to_NAND2#9pmos@67_poly-left##29 XOR1_to_NAND2#9pmos@67_poly-left##30 9.871
R2377 XOR1_to_NAND2#9pmos@67_poly-left##30 XOR1_to_NAND2#9pmos@67_poly-left##31 9.871
R2378 XOR1_to_NAND2#9pmos@67_poly-left##31 XOR1_to_NAND2#9pmos@67_poly-left##32 9.871
R2379 XOR1_to_NAND2#9pmos@67_poly-left##32 XOR1_to_NAND2#9pmos@67_poly-left##33 9.871
R2380 XOR1_to_NAND2#9pmos@67_poly-left##33 XOR1_to_NAND2#9pmos@67_poly-left##34 9.871
R2381 XOR1_to_NAND2#9pmos@67_poly-left##34 XOR1_to_NAND2#9pmos@67_poly-left##35 9.871
R2382 XOR1_to_NAND2#9pmos@67_poly-left##35 XOR1_to_NAND2#9pmos@67_poly-left##36 9.871
R2383 XOR1_to_NAND2#9pmos@67_poly-left##36 XOR1_to_NAND2#9pmos@67_poly-left##37 9.871
R2384 XOR1_to_NAND2#9pmos@67_poly-left##37 XOR1_to_NAND2#9pmos@67_poly-left##38 9.871
R2385 XOR1_to_NAND2#9pmos@67_poly-left##38 XOR1_to_NAND2#9pmos@67_poly-left##39 9.871
R2386 XOR1_to_NAND2#9pmos@67_poly-left##39 XOR1_to_NAND2#9pmos@67_poly-left##40 9.871
R2387 XOR1_to_NAND2#9pmos@67_poly-left##40 XOR1_to_NAND2#9pmos@67_poly-left##41 9.871
R2388 XOR1_to_NAND2#9pmos@67_poly-left##41 XOR1_to_NAND2#9pmos@67_poly-left##42 9.871
R2389 XOR1_to_NAND2#9pmos@67_poly-left##42 XOR1_to_NAND2#9pmos@67_poly-left##43 9.871
R2390 XOR1_to_NAND2#9pmos@67_poly-left##43 XOR1_to_NAND2#9pmos@67_poly-left##44 9.871
R2391 XOR1_to_NAND2#9pmos@67_poly-left##44 XOR1_to_NAND2#9pmos@67_poly-left##45 9.871
R2392 XOR1_to_NAND2#9pmos@67_poly-left##45 XOR1_to_NAND2#9pmos@67_poly-left##46 9.871
R2393 XOR1_to_NAND2#9pmos@67_poly-left##46 XOR1_to_NAND2#9pmos@67_poly-left##47 9.871
R2394 XOR1_to_NAND2#9pmos@67_poly-left##47 XOR1_to_NAND2#9pmos@67_poly-left##48 9.871
R2395 XOR1_to_NAND2#9pmos@67_poly-left##48 XOR1_to_NAND2#9pmos@67_poly-left##49 9.871
R2396 XOR1_to_NAND2#9pmos@67_poly-left##49 XOR1_to_NAND2#9pmos@67_poly-left##50 9.871
R2397 XOR1_to_NAND2#9pmos@67_poly-left##50 XOR1_to_NAND2#9pmos@67_poly-left##51 9.871
R2398 XOR1_to_NAND2#9pmos@67_poly-left##51 XOR1_to_NAND2#9pmos@67_poly-left##52 9.871
R2399 XOR1_to_NAND2#9pmos@67_poly-left##52 XOR1_to_NAND2#9pmos@67_poly-left##53 9.871
R2400 XOR1_to_NAND2#9pmos@67_poly-left##53 XOR1_to_NAND2#9pmos@67_poly-left##54 9.871
R2401 XOR1_to_NAND2#9pmos@67_poly-left##54 XOR1_to_NAND2#9pmos@67_poly-left##55 9.871
R2402 XOR1_to_NAND2#9pmos@67_poly-left##55 XOR1_to_NAND2#26nmos@67_poly-right 9.871
R2403 net@1211#7pmos@68_poly-left net@1211#7pmos@68_poly-left##0 9.871
R2404 net@1211#7pmos@68_poly-left##0 net@1211#7pmos@68_poly-left##1 9.871
R2405 net@1211#7pmos@68_poly-left##1 net@1211#7pmos@68_poly-left##2 9.871
R2406 net@1211#7pmos@68_poly-left##2 net@1211#7pmos@68_poly-left##3 9.871
R2407 net@1211#7pmos@68_poly-left##3 net@1211#7pmos@68_poly-left##4 9.871
R2408 net@1211#7pmos@68_poly-left##4 net@1211#7pmos@68_poly-left##5 9.871
R2409 net@1211#7pmos@68_poly-left##5 net@1211#7pmos@68_poly-left##6 9.871
R2410 net@1211#7pmos@68_poly-left##6 net@1211#7pmos@68_poly-left##7 9.871
R2411 net@1211#7pmos@68_poly-left##7 net@1211#7pmos@68_poly-left##8 9.871
R2412 net@1211#7pmos@68_poly-left##8 net@1211#7pmos@68_poly-left##9 9.871
R2413 net@1211#7pmos@68_poly-left##9 net@1211#7pmos@68_poly-left##10 9.871
R2414 net@1211#7pmos@68_poly-left##10 net@1211#7pmos@68_poly-left##11 9.871
R2415 net@1211#7pmos@68_poly-left##11 net@1211#7pmos@68_poly-left##12 9.871
R2416 net@1211#7pmos@68_poly-left##12 net@1211#7pmos@68_poly-left##13 9.871
R2417 net@1211#7pmos@68_poly-left##13 net@1211#7pmos@68_poly-left##14 9.871
R2418 net@1211#7pmos@68_poly-left##14 net@1211#7pmos@68_poly-left##15 9.871
R2419 net@1211#7pmos@68_poly-left##15 net@1211#7pmos@68_poly-left##16 9.871
R2420 net@1211#7pmos@68_poly-left##16 net@1211#7pmos@68_poly-left##17 9.871
R2421 net@1211#7pmos@68_poly-left##17 net@1211#7pmos@68_poly-left##18 9.871
R2422 net@1211#7pmos@68_poly-left##18 net@1211#7pmos@68_poly-left##19 9.871
R2423 net@1211#7pmos@68_poly-left##19 net@1211#7pmos@68_poly-left##20 9.871
R2424 net@1211#7pmos@68_poly-left##20 net@1211#7pmos@68_poly-left##21 9.871
R2425 net@1211#7pmos@68_poly-left##21 net@1211#7pmos@68_poly-left##22 9.871
R2426 net@1211#7pmos@68_poly-left##22 net@1211#7pmos@68_poly-left##23 9.871
R2427 net@1211#7pmos@68_poly-left##23 net@1211#7pmos@68_poly-left##24 9.871
R2428 net@1211#7pmos@68_poly-left##24 net@1211#7pmos@68_poly-left##25 9.871
R2429 net@1211#7pmos@68_poly-left##25 net@1211#7pmos@68_poly-left##26 9.871
R2430 net@1211#7pmos@68_poly-left##26 net@1211#7pmos@68_poly-left##27 9.871
R2431 net@1211#7pmos@68_poly-left##27 net@1211#7pmos@68_poly-left##28 9.871
R2432 net@1211#7pmos@68_poly-left##28 net@1211#7pmos@68_poly-left##29 9.871
R2433 net@1211#7pmos@68_poly-left##29 net@1211#7pmos@68_poly-left##30 9.871
R2434 net@1211#7pmos@68_poly-left##30 net@1211#7pmos@68_poly-left##31 9.871
R2435 net@1211#7pmos@68_poly-left##31 net@1211#7pmos@68_poly-left##32 9.871
R2436 net@1211#7pmos@68_poly-left##32 net@1211#7pmos@68_poly-left##33 9.871
R2437 net@1211#7pmos@68_poly-left##33 net@1211#7pmos@68_poly-left##34 9.871
R2438 net@1211#7pmos@68_poly-left##34 net@1211#7pmos@68_poly-left##35 9.871
R2439 net@1211#7pmos@68_poly-left##35 net@1211#7pmos@68_poly-left##36 9.871
R2440 net@1211#7pmos@68_poly-left##36 net@1211#7pmos@68_poly-left##37 9.871
R2441 net@1211#7pmos@68_poly-left##37 net@1211#7pmos@68_poly-left##38 9.871
R2442 net@1211#7pmos@68_poly-left##38 net@1211#7pmos@68_poly-left##39 9.871
R2443 net@1211#7pmos@68_poly-left##39 net@1211#7pmos@68_poly-left##40 9.871
R2444 net@1211#7pmos@68_poly-left##40 net@1211#7pmos@68_poly-left##41 9.871
R2445 net@1211#7pmos@68_poly-left##41 net@1211#7pmos@68_poly-left##42 9.871
R2446 net@1211#7pmos@68_poly-left##42 net@1211#7pmos@68_poly-left##43 9.871
R2447 net@1211#7pmos@68_poly-left##43 net@1211#7pmos@68_poly-left##44 9.871
R2448 net@1211#7pmos@68_poly-left##44 net@1211#7pmos@68_poly-left##45 9.871
R2449 net@1211#7pmos@68_poly-left##45 net@1211#7pmos@68_poly-left##46 9.871
R2450 net@1211#7pmos@68_poly-left##46 net@1211#7pmos@68_poly-left##47 9.871
R2451 net@1211#7pmos@68_poly-left##47 net@1211#7pmos@68_poly-left##48 9.871
R2452 net@1211#7pmos@68_poly-left##48 net@1211#7pmos@68_poly-left##49 9.871
R2453 net@1211#7pmos@68_poly-left##49 net@1211#7pmos@68_poly-left##50 9.871
R2454 net@1211#7pmos@68_poly-left##50 net@1211#7pmos@68_poly-left##51 9.871
R2455 net@1211#7pmos@68_poly-left##51 net@1211#7pmos@68_poly-left##52 9.871
R2456 net@1211#7pmos@68_poly-left##52 net@1211#7pmos@68_poly-left##53 9.871
R2457 net@1211#7pmos@68_poly-left##53 net@1211#7pmos@68_poly-left##54 9.871
R2458 net@1211#7pmos@68_poly-left##54 net@1211#7pmos@68_poly-left##55 9.871
R2459 net@1211#7pmos@68_poly-left##55 net@1211#11nmos@68_poly-right 9.871
R2460 Cin_to_XOR2___NAND2#35pmos@69_poly-right Cin_to_XOR2___NAND2#35pmos@69_poly-right##0 9.871
R2461 Cin_to_XOR2___NAND2#35pmos@69_poly-right##0 Cin_to_XOR2___NAND2#35pmos@69_poly-right##1 9.871
R2462 Cin_to_XOR2___NAND2#35pmos@69_poly-right##1 Cin_to_XOR2___NAND2#35pmos@69_poly-right##2 9.871
R2463 Cin_to_XOR2___NAND2#35pmos@69_poly-right##2 Cin_to_XOR2___NAND2#35pmos@69_poly-right##3 9.871
R2464 Cin_to_XOR2___NAND2#35pmos@69_poly-right##3 Cin_to_XOR2___NAND2#35pmos@69_poly-right##4 9.871
R2465 Cin_to_XOR2___NAND2#35pmos@69_poly-right##4 Cin_to_XOR2___NAND2#35pmos@69_poly-right##5 9.871
R2466 Cin_to_XOR2___NAND2#35pmos@69_poly-right##5 Cin_to_XOR2___NAND2#35pmos@69_poly-right##6 9.871
R2467 Cin_to_XOR2___NAND2#35pmos@69_poly-right##6 Cin_to_XOR2___NAND2#35pmos@69_poly-right##7 9.871
R2468 Cin_to_XOR2___NAND2#35pmos@69_poly-right##7 Cin_to_XOR2___NAND2#35pmos@69_poly-right##8 9.871
R2469 Cin_to_XOR2___NAND2#35pmos@69_poly-right##8 Cin_to_XOR2___NAND2#35pmos@69_poly-right##9 9.871
R2470 Cin_to_XOR2___NAND2#35pmos@69_poly-right##9 Cin_to_XOR2___NAND2#35pmos@69_poly-right##10 9.871
R2471 Cin_to_XOR2___NAND2#35pmos@69_poly-right##10 Cin_to_XOR2___NAND2#35pmos@69_poly-right##11 9.871
R2472 Cin_to_XOR2___NAND2#35pmos@69_poly-right##11 Cin_to_XOR2___NAND2#35pmos@69_poly-right##12 9.871
R2473 Cin_to_XOR2___NAND2#35pmos@69_poly-right##12 Cin_to_XOR2___NAND2#35pmos@69_poly-right##13 9.871
R2474 Cin_to_XOR2___NAND2#35pmos@69_poly-right##13 Cin_to_XOR2___NAND2#35pmos@69_poly-right##14 9.871
R2475 Cin_to_XOR2___NAND2#35pmos@69_poly-right##14 Cin_to_XOR2___NAND2#35pmos@69_poly-right##15 9.871
R2476 Cin_to_XOR2___NAND2#35pmos@69_poly-right##15 Cin_to_XOR2___NAND2#35pmos@69_poly-right##16 9.871
R2477 Cin_to_XOR2___NAND2#35pmos@69_poly-right##16 Cin_to_XOR2___NAND2#35pmos@69_poly-right##17 9.871
R2478 Cin_to_XOR2___NAND2#35pmos@69_poly-right##17 Cin_to_XOR2___NAND2#35pmos@69_poly-right##18 9.871
R2479 Cin_to_XOR2___NAND2#35pmos@69_poly-right##18 Cin_to_XOR2___NAND2#35pmos@69_poly-right##19 9.871
R2480 Cin_to_XOR2___NAND2#35pmos@69_poly-right##19 Cin_to_XOR2___NAND2#35pmos@69_poly-right##20 9.871
R2481 Cin_to_XOR2___NAND2#35pmos@69_poly-right##20 Cin_to_XOR2___NAND2#35pmos@69_poly-right##21 9.871
R2482 Cin_to_XOR2___NAND2#35pmos@69_poly-right##21 Cin_to_XOR2___NAND2#35pmos@69_poly-right##22 9.871
R2483 Cin_to_XOR2___NAND2#35pmos@69_poly-right##22 Cin_to_XOR2___NAND2#35pmos@69_poly-right##23 9.871
R2484 Cin_to_XOR2___NAND2#35pmos@69_poly-right##23 Cin_to_XOR2___NAND2#35pmos@69_poly-right##24 9.871
R2485 Cin_to_XOR2___NAND2#35pmos@69_poly-right##24 Cin_to_XOR2___NAND2#35pmos@69_poly-right##25 9.871
R2486 Cin_to_XOR2___NAND2#35pmos@69_poly-right##25 Cin_to_XOR2___NAND2#35pmos@69_poly-right##26 9.871
R2487 Cin_to_XOR2___NAND2#35pmos@69_poly-right##26 Cin_to_XOR2___NAND2#35pmos@69_poly-right##27 9.871
R2488 Cin_to_XOR2___NAND2#35pmos@69_poly-right##27 Cin_to_XOR2___NAND2#35pmos@69_poly-right##28 9.871
R2489 Cin_to_XOR2___NAND2#35pmos@69_poly-right##28 Cin_to_XOR2___NAND2#35pmos@69_poly-right##29 9.871
R2490 Cin_to_XOR2___NAND2#35pmos@69_poly-right##29 Cin_to_XOR2___NAND2#35pmos@69_poly-right##30 9.871
R2491 Cin_to_XOR2___NAND2#35pmos@69_poly-right##30 Cin_to_XOR2___NAND2#35pmos@69_poly-right##31 9.871
R2492 Cin_to_XOR2___NAND2#35pmos@69_poly-right##31 Cin_to_XOR2___NAND2#35pmos@69_poly-right##32 9.871
R2493 Cin_to_XOR2___NAND2#35pmos@69_poly-right##32 Cin_to_XOR2___NAND2#35pmos@69_poly-right##33 9.871
R2494 Cin_to_XOR2___NAND2#35pmos@69_poly-right##33 Cin_to_XOR2___NAND2#35pmos@69_poly-right##34 9.871
R2495 Cin_to_XOR2___NAND2#35pmos@69_poly-right##34 Cin_to_XOR2___NAND2#35pmos@69_poly-right##35 9.871
R2496 Cin_to_XOR2___NAND2#35pmos@69_poly-right##35 Cin_to_XOR2___NAND2#35pmos@69_poly-right##36 9.871
R2497 Cin_to_XOR2___NAND2#35pmos@69_poly-right##36 Cin_to_XOR2___NAND2#35pmos@69_poly-right##37 9.871
R2498 Cin_to_XOR2___NAND2#35pmos@69_poly-right##37 Cin_to_XOR2___NAND2#35pmos@69_poly-right##38 9.871
R2499 Cin_to_XOR2___NAND2#35pmos@69_poly-right##38 Cin_to_XOR2___NAND2#35pmos@69_poly-right##39 9.871
R2500 Cin_to_XOR2___NAND2#35pmos@69_poly-right##39 Cin_to_XOR2___NAND2#35pmos@69_poly-right##40 9.871
R2501 Cin_to_XOR2___NAND2#35pmos@69_poly-right##40 Cin_to_XOR2___NAND2#35pmos@69_poly-right##41 9.871
R2502 Cin_to_XOR2___NAND2#35pmos@69_poly-right##41 Cin_to_XOR2___NAND2#35pmos@69_poly-right##42 9.871
R2503 Cin_to_XOR2___NAND2#35pmos@69_poly-right##42 Cin_to_XOR2___NAND2#35pmos@69_poly-right##43 9.871
R2504 Cin_to_XOR2___NAND2#35pmos@69_poly-right##43 Cin_to_XOR2___NAND2#35pmos@69_poly-right##44 9.871
R2505 Cin_to_XOR2___NAND2#35pmos@69_poly-right##44 Cin_to_XOR2___NAND2#35pmos@69_poly-right##45 9.871
R2506 Cin_to_XOR2___NAND2#35pmos@69_poly-right##45 Cin_to_XOR2___NAND2#35pmos@69_poly-right##46 9.871
R2507 Cin_to_XOR2___NAND2#35pmos@69_poly-right##46 Cin_to_XOR2___NAND2#35pmos@69_poly-right##47 9.871
R2508 Cin_to_XOR2___NAND2#35pmos@69_poly-right##47 Cin_to_XOR2___NAND2#35pmos@69_poly-right##48 9.871
R2509 Cin_to_XOR2___NAND2#35pmos@69_poly-right##48 Cin_to_XOR2___NAND2#35pmos@69_poly-right##49 9.871
R2510 Cin_to_XOR2___NAND2#35pmos@69_poly-right##49 Cin_to_XOR2___NAND2#35pmos@69_poly-right##50 9.871
R2511 Cin_to_XOR2___NAND2#35pmos@69_poly-right##50 Cin_to_XOR2___NAND2#35pmos@69_poly-right##51 9.871
R2512 Cin_to_XOR2___NAND2#35pmos@69_poly-right##51 Cin_to_XOR2___NAND2#35pmos@69_poly-right##52 9.871
R2513 Cin_to_XOR2___NAND2#35pmos@69_poly-right##52 Cin_to_XOR2___NAND2#35pmos@69_poly-right##53 9.871
R2514 Cin_to_XOR2___NAND2#35pmos@69_poly-right##53 Cin_to_XOR2___NAND2#35pmos@69_poly-right##54 9.871
R2515 Cin_to_XOR2___NAND2#35pmos@69_poly-right##54 Cin_to_XOR2___NAND2#35pmos@69_poly-right##55 9.871
R2516 Cin_to_XOR2___NAND2#35pmos@69_poly-right##55 Cin_to_XOR2___NAND2#26nmos@69_poly-left 9.871
R2517 net@1221#14pmos@70_poly-right net@1221#14pmos@70_poly-right##0 9.871
R2518 net@1221#14pmos@70_poly-right##0 net@1221#14pmos@70_poly-right##1 9.871
R2519 net@1221#14pmos@70_poly-right##1 net@1221#14pmos@70_poly-right##2 9.871
R2520 net@1221#14pmos@70_poly-right##2 net@1221#14pmos@70_poly-right##3 9.871
R2521 net@1221#14pmos@70_poly-right##3 net@1221#14pmos@70_poly-right##4 9.871
R2522 net@1221#14pmos@70_poly-right##4 net@1221#14pmos@70_poly-right##5 9.871
R2523 net@1221#14pmos@70_poly-right##5 net@1221#14pmos@70_poly-right##6 9.871
R2524 net@1221#14pmos@70_poly-right##6 net@1221#14pmos@70_poly-right##7 9.871
R2525 net@1221#14pmos@70_poly-right##7 net@1221#14pmos@70_poly-right##8 9.871
R2526 net@1221#14pmos@70_poly-right##8 net@1221#14pmos@70_poly-right##9 9.871
R2527 net@1221#14pmos@70_poly-right##9 net@1221#14pmos@70_poly-right##10 9.871
R2528 net@1221#14pmos@70_poly-right##10 net@1221#14pmos@70_poly-right##11 9.871
R2529 net@1221#14pmos@70_poly-right##11 net@1221#14pmos@70_poly-right##12 9.871
R2530 net@1221#14pmos@70_poly-right##12 net@1221#14pmos@70_poly-right##13 9.871
R2531 net@1221#14pmos@70_poly-right##13 net@1221#14pmos@70_poly-right##14 9.871
R2532 net@1221#14pmos@70_poly-right##14 net@1221#14pmos@70_poly-right##15 9.871
R2533 net@1221#14pmos@70_poly-right##15 net@1221#14pmos@70_poly-right##16 9.871
R2534 net@1221#14pmos@70_poly-right##16 net@1221#14pmos@70_poly-right##17 9.871
R2535 net@1221#14pmos@70_poly-right##17 net@1221#14pmos@70_poly-right##18 9.871
R2536 net@1221#14pmos@70_poly-right##18 net@1221#14pmos@70_poly-right##19 9.871
R2537 net@1221#14pmos@70_poly-right##19 net@1221#14pmos@70_poly-right##20 9.871
R2538 net@1221#14pmos@70_poly-right##20 net@1221#14pmos@70_poly-right##21 9.871
R2539 net@1221#14pmos@70_poly-right##21 net@1221#14pmos@70_poly-right##22 9.871
R2540 net@1221#14pmos@70_poly-right##22 net@1221#14pmos@70_poly-right##23 9.871
R2541 net@1221#14pmos@70_poly-right##23 net@1221#14pmos@70_poly-right##24 9.871
R2542 net@1221#14pmos@70_poly-right##24 net@1221#14pmos@70_poly-right##25 9.871
R2543 net@1221#14pmos@70_poly-right##25 net@1221#14pmos@70_poly-right##26 9.871
R2544 net@1221#14pmos@70_poly-right##26 net@1221#14pmos@70_poly-right##27 9.871
R2545 net@1221#14pmos@70_poly-right##27 net@1221#14pmos@70_poly-right##28 9.871
R2546 net@1221#14pmos@70_poly-right##28 net@1221#14pmos@70_poly-right##29 9.871
R2547 net@1221#14pmos@70_poly-right##29 net@1221#14pmos@70_poly-right##30 9.871
R2548 net@1221#14pmos@70_poly-right##30 net@1221#14pmos@70_poly-right##31 9.871
R2549 net@1221#14pmos@70_poly-right##31 net@1221#14pmos@70_poly-right##32 9.871
R2550 net@1221#14pmos@70_poly-right##32 net@1221#14pmos@70_poly-right##33 9.871
R2551 net@1221#14pmos@70_poly-right##33 net@1221#14pmos@70_poly-right##34 9.871
R2552 net@1221#14pmos@70_poly-right##34 net@1221#14pmos@70_poly-right##35 9.871
R2553 net@1221#14pmos@70_poly-right##35 net@1221#14pmos@70_poly-right##36 9.871
R2554 net@1221#14pmos@70_poly-right##36 net@1221#14pmos@70_poly-right##37 9.871
R2555 net@1221#14pmos@70_poly-right##37 net@1221#14pmos@70_poly-right##38 9.871
R2556 net@1221#14pmos@70_poly-right##38 net@1221#14pmos@70_poly-right##39 9.871
R2557 net@1221#14pmos@70_poly-right##39 net@1221#14pmos@70_poly-right##40 9.871
R2558 net@1221#14pmos@70_poly-right##40 net@1221#14pmos@70_poly-right##41 9.871
R2559 net@1221#14pmos@70_poly-right##41 net@1221#14pmos@70_poly-right##42 9.871
R2560 net@1221#14pmos@70_poly-right##42 net@1221#14pmos@70_poly-right##43 9.871
R2561 net@1221#14pmos@70_poly-right##43 net@1221#14pmos@70_poly-right##44 9.871
R2562 net@1221#14pmos@70_poly-right##44 net@1221#14pmos@70_poly-right##45 9.871
R2563 net@1221#14pmos@70_poly-right##45 net@1221#14pmos@70_poly-right##46 9.871
R2564 net@1221#14pmos@70_poly-right##46 net@1221#14pmos@70_poly-right##47 9.871
R2565 net@1221#14pmos@70_poly-right##47 net@1221#14pmos@70_poly-right##48 9.871
R2566 net@1221#14pmos@70_poly-right##48 net@1221#14pmos@70_poly-right##49 9.871
R2567 net@1221#14pmos@70_poly-right##49 net@1221#14pmos@70_poly-right##50 9.871
R2568 net@1221#14pmos@70_poly-right##50 net@1221#14pmos@70_poly-right##51 9.871
R2569 net@1221#14pmos@70_poly-right##51 net@1221#14pmos@70_poly-right##52 9.871
R2570 net@1221#14pmos@70_poly-right##52 net@1221#14pmos@70_poly-right##53 9.871
R2571 net@1221#14pmos@70_poly-right##53 net@1221#14pmos@70_poly-right##54 9.871
R2572 net@1221#14pmos@70_poly-right##54 net@1221#14pmos@70_poly-right##55 9.871
R2573 net@1221#14pmos@70_poly-right##55 net@1221#9nmos@70_poly-left 9.871
R2574 net@1220#2contact@530_metal-1-polysilicon-1 net@1220 4.654
R2575 net@1220#12pmos@73_poly-right net@1220#12pmos@73_poly-right##0 9.931
R2576 net@1220#12pmos@73_poly-right##0 net@1220#12pmos@73_poly-right##1 9.931
R2577 net@1220#12pmos@73_poly-right##1 net@1220#12pmos@73_poly-right##2 9.931
R2578 net@1220#12pmos@73_poly-right##2 net@1220#12pmos@73_poly-right##3 9.931
R2579 net@1220#12pmos@73_poly-right##3 net@1220#12pmos@73_poly-right##4 9.931
R2580 net@1220#12pmos@73_poly-right##4 net@1220#12pmos@73_poly-right##5 9.931
R2581 net@1220#12pmos@73_poly-right##5 net@1220#12pmos@73_poly-right##6 9.931
R2582 net@1220#12pmos@73_poly-right##6 net@1220#12pmos@73_poly-right##7 9.931
R2583 net@1220#12pmos@73_poly-right##7 net@1220#12pmos@73_poly-right##8 9.931
R2584 net@1220#12pmos@73_poly-right##8 net@1220#12pmos@73_poly-right##9 9.931
R2585 net@1220#12pmos@73_poly-right##9 net@1220#12pmos@73_poly-right##10 9.931
R2586 net@1220#12pmos@73_poly-right##10 net@1220#12pmos@73_poly-right##11 9.931
R2587 net@1220#12pmos@73_poly-right##11 net@1220#12pmos@73_poly-right##12 9.931
R2588 net@1220#12pmos@73_poly-right##12 net@1220#12pmos@73_poly-right##13 9.931
R2589 net@1220#12pmos@73_poly-right##13 net@1220#12pmos@73_poly-right##14 9.931
R2590 net@1220#12pmos@73_poly-right##14 net@1220#12pmos@73_poly-right##15 9.931
R2591 net@1220#12pmos@73_poly-right##15 net@1220#12pmos@73_poly-right##16 9.931
R2592 net@1220#12pmos@73_poly-right##16 net@1220#12pmos@73_poly-right##17 9.931
R2593 net@1220#12pmos@73_poly-right##17 net@1220#12pmos@73_poly-right##18 9.931
R2594 net@1220#12pmos@73_poly-right##18 net@1220#12pmos@73_poly-right##19 9.931
R2595 net@1220#12pmos@73_poly-right##19 net@1220#12pmos@73_poly-right##20 9.931
R2596 net@1220#12pmos@73_poly-right##20 net@1220#12pmos@73_poly-right##21 9.931
R2597 net@1220#12pmos@73_poly-right##21 net@1220#12pmos@73_poly-right##22 9.931
R2598 net@1220#12pmos@73_poly-right##22 net@1220#12pmos@73_poly-right##23 9.931
R2599 net@1220#12pmos@73_poly-right##23 net@1220#12pmos@73_poly-right##24 9.931
R2600 net@1220#12pmos@73_poly-right##24 net@1220#12pmos@73_poly-right##25 9.931
R2601 net@1220#12pmos@73_poly-right##25 net@1220#12pmos@73_poly-right##26 9.931
R2602 net@1220#12pmos@73_poly-right##26 net@1220#12pmos@73_poly-right##27 9.931
R2603 net@1220#12pmos@73_poly-right##27 net@1220#12pmos@73_poly-right##28 9.931
R2604 net@1220#12pmos@73_poly-right##28 net@1220#12pmos@73_poly-right##29 9.931
R2605 net@1220#12pmos@73_poly-right##29 net@1220#12pmos@73_poly-right##30 9.931
R2606 net@1220#12pmos@73_poly-right##30 net@1220#12pmos@73_poly-right##31 9.931
R2607 net@1220#12pmos@73_poly-right##31 net@1220#12pmos@73_poly-right##32 9.931
R2608 net@1220#12pmos@73_poly-right##32 net@1220#12pmos@73_poly-right##33 9.931
R2609 net@1220#12pmos@73_poly-right##33 net@1220#12pmos@73_poly-right##34 9.931
R2610 net@1220#12pmos@73_poly-right##34 net@1220#12pmos@73_poly-right##35 9.931
R2611 net@1220#12pmos@73_poly-right##35 net@1220#12pmos@73_poly-right##36 9.931
R2612 net@1220#12pmos@73_poly-right##36 net@1220#12pmos@73_poly-right##37 9.931
R2613 net@1220#12pmos@73_poly-right##37 net@1220#12pmos@73_poly-right##38 9.931
R2614 net@1220#12pmos@73_poly-right##38 net@1220#12pmos@73_poly-right##39 9.931
R2615 net@1220#12pmos@73_poly-right##39 net@1220#12pmos@73_poly-right##40 9.931
R2616 net@1220#12pmos@73_poly-right##40 net@1220#12pmos@73_poly-right##41 9.931
R2617 net@1220#12pmos@73_poly-right##41 net@1220#12pmos@73_poly-right##42 9.931
R2618 net@1220#12pmos@73_poly-right##42 net@1220#12pmos@73_poly-right##43 9.931
R2619 net@1220#12pmos@73_poly-right##43 net@1220#12pmos@73_poly-right##44 9.931
R2620 net@1220#12pmos@73_poly-right##44 net@1220#12pmos@73_poly-right##45 9.931
R2621 net@1220#12pmos@73_poly-right##45 net@1220#12pmos@73_poly-right##46 9.931
R2622 net@1220#12pmos@73_poly-right##46 net@1220#12pmos@73_poly-right##47 9.931
R2623 net@1220#12pmos@73_poly-right##47 net@1220#12pmos@73_poly-right##48 9.931
R2624 net@1220#12pmos@73_poly-right##48 net@1220#12pmos@73_poly-right##49 9.931
R2625 net@1220#12pmos@73_poly-right##49 net@1220#12pmos@73_poly-right##50 9.931
R2626 net@1220#12pmos@73_poly-right##50 net@1220#12pmos@73_poly-right##51 9.931
R2627 net@1220#12pmos@73_poly-right##51 net@1220#12pmos@73_poly-right##52 9.931
R2628 net@1220#12pmos@73_poly-right##52 net@1220#5pin@370_polysilicon-1 9.931
R2629 Sum1#4pmos@73_diff-top Sum1 4.823
R2630 XOR1_to_NAND2#14pin@382_polysilicon-1 XOR1_to_NAND2#14pin@382_polysilicon-1##0 9.854
R2631 XOR1_to_NAND2#14pin@382_polysilicon-1##0 XOR1_to_NAND2#14pin@382_polysilicon-1##1 9.854
R2632 XOR1_to_NAND2#14pin@382_polysilicon-1##1 XOR1_to_NAND2#14pin@382_polysilicon-1##2 9.854
R2633 XOR1_to_NAND2#14pin@382_polysilicon-1##2 XOR1_to_NAND2#14pin@382_polysilicon-1##3 9.854
R2634 XOR1_to_NAND2#14pin@382_polysilicon-1##3 XOR1_to_NAND2#14pin@382_polysilicon-1##4 9.854
R2635 XOR1_to_NAND2#14pin@382_polysilicon-1##4 XOR1_to_NAND2#14pin@382_polysilicon-1##5 9.854
R2636 XOR1_to_NAND2#14pin@382_polysilicon-1##5 XOR1_to_NAND2#14pin@382_polysilicon-1##6 9.854
R2637 XOR1_to_NAND2#14pin@382_polysilicon-1##6 XOR1_to_NAND2#14pin@382_polysilicon-1##7 9.854
R2638 XOR1_to_NAND2#14pin@382_polysilicon-1##7 XOR1_to_NAND2#14pin@382_polysilicon-1##8 9.854
R2639 XOR1_to_NAND2#14pin@382_polysilicon-1##8 XOR1_to_NAND2#14pin@382_polysilicon-1##9 9.854
R2640 XOR1_to_NAND2#14pin@382_polysilicon-1##9 XOR1_to_NAND2#14pin@382_polysilicon-1##10 9.854
R2641 XOR1_to_NAND2#14pin@382_polysilicon-1##10 XOR1_to_NAND2#14pin@382_polysilicon-1##11 9.854
R2642 XOR1_to_NAND2#14pin@382_polysilicon-1##11 XOR1_to_NAND2#14pin@382_polysilicon-1##12 9.854
R2643 XOR1_to_NAND2#14pin@382_polysilicon-1##12 XOR1_to_NAND2#14pin@382_polysilicon-1##13 9.854
R2644 XOR1_to_NAND2#14pin@382_polysilicon-1##13 XOR1_to_NAND2#14pin@382_polysilicon-1##14 9.854
R2645 XOR1_to_NAND2#14pin@382_polysilicon-1##14 XOR1_to_NAND2#14pin@382_polysilicon-1##15 9.854
R2646 XOR1_to_NAND2#14pin@382_polysilicon-1##15 XOR1_to_NAND2#14pin@382_polysilicon-1##16 9.854
R2647 XOR1_to_NAND2#14pin@382_polysilicon-1##16 XOR1_to_NAND2#14pin@382_polysilicon-1##17 9.854
R2648 XOR1_to_NAND2#14pin@382_polysilicon-1##17 XOR1_to_NAND2#14pin@382_polysilicon-1##18 9.854
R2649 XOR1_to_NAND2#14pin@382_polysilicon-1##18 XOR1_to_NAND2#14pin@382_polysilicon-1##19 9.854
R2650 XOR1_to_NAND2#14pin@382_polysilicon-1##19 XOR1_to_NAND2#14pin@382_polysilicon-1##20 9.854
R2651 XOR1_to_NAND2#14pin@382_polysilicon-1##20 XOR1_to_NAND2#14pin@382_polysilicon-1##21 9.854
R2652 XOR1_to_NAND2#14pin@382_polysilicon-1##21 XOR1_to_NAND2#14pin@382_polysilicon-1##22 9.854
R2653 XOR1_to_NAND2#14pin@382_polysilicon-1##22 XOR1_to_NAND2#14pin@382_polysilicon-1##23 9.854
R2654 XOR1_to_NAND2#14pin@382_polysilicon-1##23 XOR1_to_NAND2#14pin@382_polysilicon-1##24 9.854
R2655 XOR1_to_NAND2#14pin@382_polysilicon-1##24 XOR1_to_NAND2#14pin@382_polysilicon-1##25 9.854
R2656 XOR1_to_NAND2#14pin@382_polysilicon-1##25 XOR1_to_NAND2#14pin@382_polysilicon-1##26 9.854
R2657 XOR1_to_NAND2#14pin@382_polysilicon-1##26 XOR1_to_NAND2#14pin@382_polysilicon-1##27 9.854
R2658 XOR1_to_NAND2#14pin@382_polysilicon-1##27 XOR1_to_NAND2#14pin@382_polysilicon-1##28 9.854
R2659 XOR1_to_NAND2#14pin@382_polysilicon-1##28 XOR1_to_NAND2#14pin@382_polysilicon-1##29 9.854
R2660 XOR1_to_NAND2#14pin@382_polysilicon-1##29 XOR1_to_NAND2#14pin@382_polysilicon-1##30 9.854
R2661 XOR1_to_NAND2#14pin@382_polysilicon-1##30 XOR1_to_NAND2#14pin@382_polysilicon-1##31 9.854
R2662 XOR1_to_NAND2#14pin@382_polysilicon-1##31 XOR1_to_NAND2#14pin@382_polysilicon-1##32 9.854
R2663 XOR1_to_NAND2#14pin@382_polysilicon-1##32 XOR1_to_NAND2#14pin@382_polysilicon-1##33 9.854
R2664 XOR1_to_NAND2#14pin@382_polysilicon-1##33 XOR1_to_NAND2#14pin@382_polysilicon-1##34 9.854
R2665 XOR1_to_NAND2#14pin@382_polysilicon-1##34 XOR1_to_NAND2#14pin@382_polysilicon-1##35 9.854
R2666 XOR1_to_NAND2#14pin@382_polysilicon-1##35 XOR1_to_NAND2#14pin@382_polysilicon-1##36 9.854
R2667 XOR1_to_NAND2#14pin@382_polysilicon-1##36 XOR1_to_NAND2#14pin@382_polysilicon-1##37 9.854
R2668 XOR1_to_NAND2#14pin@382_polysilicon-1##37 XOR1_to_NAND2#14pin@382_polysilicon-1##38 9.854
R2669 XOR1_to_NAND2#14pin@382_polysilicon-1##38 XOR1_to_NAND2#14pin@382_polysilicon-1##39 9.854
R2670 XOR1_to_NAND2#14pin@382_polysilicon-1##39 XOR1_to_NAND2#14pin@382_polysilicon-1##40 9.854
R2671 XOR1_to_NAND2#14pin@382_polysilicon-1##40 XOR1_to_NAND2#14pin@382_polysilicon-1##41 9.854
R2672 XOR1_to_NAND2#14pin@382_polysilicon-1##41 XOR1_to_NAND2#14pin@382_polysilicon-1##42 9.854
R2673 XOR1_to_NAND2#14pin@382_polysilicon-1##42 XOR1_to_NAND2#14pin@382_polysilicon-1##43 9.854
R2674 XOR1_to_NAND2#14pin@382_polysilicon-1##43 XOR1_to_NAND2#14pin@382_polysilicon-1##44 9.854
R2675 XOR1_to_NAND2#14pin@382_polysilicon-1##44 XOR1_to_NAND2#14pin@382_polysilicon-1##45 9.854
R2676 XOR1_to_NAND2#14pin@382_polysilicon-1##45 XOR1_to_NAND2#14pin@382_polysilicon-1##46 9.854
R2677 XOR1_to_NAND2#14pin@382_polysilicon-1##46 XOR1_to_NAND2#14pin@382_polysilicon-1##47 9.854
R2678 XOR1_to_NAND2#14pin@382_polysilicon-1##47 XOR1_to_NAND2#14pin@382_polysilicon-1##48 9.854
R2679 XOR1_to_NAND2#14pin@382_polysilicon-1##48 XOR1_to_NAND2#14pin@382_polysilicon-1##49 9.854
R2680 XOR1_to_NAND2#14pin@382_polysilicon-1##49 XOR1_to_NAND2#14pin@382_polysilicon-1##50 9.854
R2681 XOR1_to_NAND2#14pin@382_polysilicon-1##50 XOR1_to_NAND2#14pin@382_polysilicon-1##51 9.854
R2682 XOR1_to_NAND2#14pin@382_polysilicon-1##51 XOR1_to_NAND2#14pin@382_polysilicon-1##52 9.854
R2683 XOR1_to_NAND2#14pin@382_polysilicon-1##52 XOR1_to_NAND2#14pin@382_polysilicon-1##53 9.854
R2684 XOR1_to_NAND2#14pin@382_polysilicon-1##53 XOR1_to_NAND2#14pin@382_polysilicon-1##54 9.854
R2685 XOR1_to_NAND2#14pin@382_polysilicon-1##54 XOR1_to_NAND2#27nmos@74_poly-right 9.854
R2686 Cin_to_XOR2___NAND2#37pmos@75_poly-right Cin_to_XOR2___NAND2#37pmos@75_poly-right##0 9.877
R2687 Cin_to_XOR2___NAND2#37pmos@75_poly-right##0 Cin_to_XOR2___NAND2#37pmos@75_poly-right##1 9.877
R2688 Cin_to_XOR2___NAND2#37pmos@75_poly-right##1 Cin_to_XOR2___NAND2#37pmos@75_poly-right##2 9.877
R2689 Cin_to_XOR2___NAND2#37pmos@75_poly-right##2 Cin_to_XOR2___NAND2#37pmos@75_poly-right##3 9.877
R2690 Cin_to_XOR2___NAND2#37pmos@75_poly-right##3 Cin_to_XOR2___NAND2#37pmos@75_poly-right##4 9.877
R2691 Cin_to_XOR2___NAND2#37pmos@75_poly-right##4 Cin_to_XOR2___NAND2#37pmos@75_poly-right##5 9.877
R2692 Cin_to_XOR2___NAND2#37pmos@75_poly-right##5 Cin_to_XOR2___NAND2#37pmos@75_poly-right##6 9.877
R2693 Cin_to_XOR2___NAND2#37pmos@75_poly-right##6 Cin_to_XOR2___NAND2#37pmos@75_poly-right##7 9.877
R2694 Cin_to_XOR2___NAND2#37pmos@75_poly-right##7 Cin_to_XOR2___NAND2#37pmos@75_poly-right##8 9.877
R2695 Cin_to_XOR2___NAND2#37pmos@75_poly-right##8 Cin_to_XOR2___NAND2#37pmos@75_poly-right##9 9.877
R2696 Cin_to_XOR2___NAND2#37pmos@75_poly-right##9 Cin_to_XOR2___NAND2#37pmos@75_poly-right##10 9.877
R2697 Cin_to_XOR2___NAND2#37pmos@75_poly-right##10 Cin_to_XOR2___NAND2#37pmos@75_poly-right##11 9.877
R2698 Cin_to_XOR2___NAND2#37pmos@75_poly-right##11 Cin_to_XOR2___NAND2#37pmos@75_poly-right##12 9.877
R2699 Cin_to_XOR2___NAND2#37pmos@75_poly-right##12 Cin_to_XOR2___NAND2#37pmos@75_poly-right##13 9.877
R2700 Cin_to_XOR2___NAND2#37pmos@75_poly-right##13 Cin_to_XOR2___NAND2#37pmos@75_poly-right##14 9.877
R2701 Cin_to_XOR2___NAND2#37pmos@75_poly-right##14 Cin_to_XOR2___NAND2#37pmos@75_poly-right##15 9.877
R2702 Cin_to_XOR2___NAND2#37pmos@75_poly-right##15 Cin_to_XOR2___NAND2#37pmos@75_poly-right##16 9.877
R2703 Cin_to_XOR2___NAND2#37pmos@75_poly-right##16 Cin_to_XOR2___NAND2#37pmos@75_poly-right##17 9.877
R2704 Cin_to_XOR2___NAND2#37pmos@75_poly-right##17 Cin_to_XOR2___NAND2#37pmos@75_poly-right##18 9.877
R2705 Cin_to_XOR2___NAND2#37pmos@75_poly-right##18 Cin_to_XOR2___NAND2#37pmos@75_poly-right##19 9.877
R2706 Cin_to_XOR2___NAND2#37pmos@75_poly-right##19 Cin_to_XOR2___NAND2#37pmos@75_poly-right##20 9.877
R2707 Cin_to_XOR2___NAND2#37pmos@75_poly-right##20 Cin_to_XOR2___NAND2#37pmos@75_poly-right##21 9.877
R2708 Cin_to_XOR2___NAND2#37pmos@75_poly-right##21 Cin_to_XOR2___NAND2#37pmos@75_poly-right##22 9.877
R2709 Cin_to_XOR2___NAND2#37pmos@75_poly-right##22 Cin_to_XOR2___NAND2#37pmos@75_poly-right##23 9.877
R2710 Cin_to_XOR2___NAND2#37pmos@75_poly-right##23 Cin_to_XOR2___NAND2#37pmos@75_poly-right##24 9.877
R2711 Cin_to_XOR2___NAND2#37pmos@75_poly-right##24 Cin_to_XOR2___NAND2#37pmos@75_poly-right##25 9.877
R2712 Cin_to_XOR2___NAND2#37pmos@75_poly-right##25 Cin_to_XOR2___NAND2#37pmos@75_poly-right##26 9.877
R2713 Cin_to_XOR2___NAND2#37pmos@75_poly-right##26 Cin_to_XOR2___NAND2#37pmos@75_poly-right##27 9.877
R2714 Cin_to_XOR2___NAND2#37pmos@75_poly-right##27 Cin_to_XOR2___NAND2#37pmos@75_poly-right##28 9.877
R2715 Cin_to_XOR2___NAND2#37pmos@75_poly-right##28 Cin_to_XOR2___NAND2#37pmos@75_poly-right##29 9.877
R2716 Cin_to_XOR2___NAND2#37pmos@75_poly-right##29 Cin_to_XOR2___NAND2#37pmos@75_poly-right##30 9.877
R2717 Cin_to_XOR2___NAND2#37pmos@75_poly-right##30 Cin_to_XOR2___NAND2#37pmos@75_poly-right##31 9.877
R2718 Cin_to_XOR2___NAND2#37pmos@75_poly-right##31 Cin_to_XOR2___NAND2#37pmos@75_poly-right##32 9.877
R2719 Cin_to_XOR2___NAND2#37pmos@75_poly-right##32 Cin_to_XOR2___NAND2#37pmos@75_poly-right##33 9.877
R2720 Cin_to_XOR2___NAND2#37pmos@75_poly-right##33 Cin_to_XOR2___NAND2#37pmos@75_poly-right##34 9.877
R2721 Cin_to_XOR2___NAND2#37pmos@75_poly-right##34 Cin_to_XOR2___NAND2#37pmos@75_poly-right##35 9.877
R2722 Cin_to_XOR2___NAND2#37pmos@75_poly-right##35 Cin_to_XOR2___NAND2#37pmos@75_poly-right##36 9.877
R2723 Cin_to_XOR2___NAND2#37pmos@75_poly-right##36 Cin_to_XOR2___NAND2#37pmos@75_poly-right##37 9.877
R2724 Cin_to_XOR2___NAND2#37pmos@75_poly-right##37 Cin_to_XOR2___NAND2#37pmos@75_poly-right##38 9.877
R2725 Cin_to_XOR2___NAND2#37pmos@75_poly-right##38 Cin_to_XOR2___NAND2#37pmos@75_poly-right##39 9.877
R2726 Cin_to_XOR2___NAND2#37pmos@75_poly-right##39 Cin_to_XOR2___NAND2#37pmos@75_poly-right##40 9.877
R2727 Cin_to_XOR2___NAND2#37pmos@75_poly-right##40 Cin_to_XOR2___NAND2#37pmos@75_poly-right##41 9.877
R2728 Cin_to_XOR2___NAND2#37pmos@75_poly-right##41 Cin_to_XOR2___NAND2#37pmos@75_poly-right##42 9.877
R2729 Cin_to_XOR2___NAND2#37pmos@75_poly-right##42 Cin_to_XOR2___NAND2#37pmos@75_poly-right##43 9.877
R2730 Cin_to_XOR2___NAND2#37pmos@75_poly-right##43 Cin_to_XOR2___NAND2#37pmos@75_poly-right##44 9.877
R2731 Cin_to_XOR2___NAND2#37pmos@75_poly-right##44 Cin_to_XOR2___NAND2#37pmos@75_poly-right##45 9.877
R2732 Cin_to_XOR2___NAND2#37pmos@75_poly-right##45 Cin_to_XOR2___NAND2#37pmos@75_poly-right##46 9.877
R2733 Cin_to_XOR2___NAND2#37pmos@75_poly-right##46 Cin_to_XOR2___NAND2#37pmos@75_poly-right##47 9.877
R2734 Cin_to_XOR2___NAND2#37pmos@75_poly-right##47 Cin_to_XOR2___NAND2#37pmos@75_poly-right##48 9.877
R2735 Cin_to_XOR2___NAND2#37pmos@75_poly-right##48 Cin_to_XOR2___NAND2#37pmos@75_poly-right##49 9.877
R2736 Cin_to_XOR2___NAND2#37pmos@75_poly-right##49 Cin_to_XOR2___NAND2#31pin@386_polysilicon-1 9.877
R2737 Cin_to_XOR2___NAND3#1contact@646_metal-1-metal-2 Cin_to_XOR2___NAND3#7nmos@75_diff-bottom 4.823
R2738 A1#11pin@389_polysilicon-1 A1#11pin@389_polysilicon-1##0 9.938
R2739 A1#11pin@389_polysilicon-1##0 A1#11pin@389_polysilicon-1##1 9.938
R2740 A1#11pin@389_polysilicon-1##1 A1#11pin@389_polysilicon-1##2 9.938
R2741 A1#11pin@389_polysilicon-1##2 A1#11pin@389_polysilicon-1##3 9.938
R2742 A1#11pin@389_polysilicon-1##3 A1#11pin@389_polysilicon-1##4 9.938
R2743 A1#11pin@389_polysilicon-1##4 A1#11pin@389_polysilicon-1##5 9.938
R2744 A1#11pin@389_polysilicon-1##5 A1#11pin@389_polysilicon-1##6 9.938
R2745 A1#11pin@389_polysilicon-1##6 A1#11pin@389_polysilicon-1##7 9.938
R2746 A1#11pin@389_polysilicon-1##7 A1#11pin@389_polysilicon-1##8 9.938
R2747 A1#11pin@389_polysilicon-1##8 A1#11pin@389_polysilicon-1##9 9.938
R2748 A1#11pin@389_polysilicon-1##9 A1#11pin@389_polysilicon-1##10 9.938
R2749 A1#11pin@389_polysilicon-1##10 A1#11pin@389_polysilicon-1##11 9.938
R2750 A1#11pin@389_polysilicon-1##11 A1#11pin@389_polysilicon-1##12 9.938
R2751 A1#11pin@389_polysilicon-1##12 A1#11pin@389_polysilicon-1##13 9.938
R2752 A1#11pin@389_polysilicon-1##13 A1#11pin@389_polysilicon-1##14 9.938
R2753 A1#11pin@389_polysilicon-1##14 A1#11pin@389_polysilicon-1##15 9.938
R2754 A1#11pin@389_polysilicon-1##15 A1#11pin@389_polysilicon-1##16 9.938
R2755 A1#11pin@389_polysilicon-1##16 A1#11pin@389_polysilicon-1##17 9.938
R2756 A1#11pin@389_polysilicon-1##17 A1#11pin@389_polysilicon-1##18 9.938
R2757 A1#11pin@389_polysilicon-1##18 A1#11pin@389_polysilicon-1##19 9.938
R2758 A1#11pin@389_polysilicon-1##19 A1#11pin@389_polysilicon-1##20 9.938
R2759 A1#11pin@389_polysilicon-1##20 A1#11pin@389_polysilicon-1##21 9.938
R2760 A1#11pin@389_polysilicon-1##21 A1#11pin@389_polysilicon-1##22 9.938
R2761 A1#11pin@389_polysilicon-1##22 A1#11pin@389_polysilicon-1##23 9.938
R2762 A1#11pin@389_polysilicon-1##23 A1#11pin@389_polysilicon-1##24 9.938
R2763 A1#11pin@389_polysilicon-1##24 A1#11pin@389_polysilicon-1##25 9.938
R2764 A1#11pin@389_polysilicon-1##25 A1#11pin@389_polysilicon-1##26 9.938
R2765 A1#11pin@389_polysilicon-1##26 A1#11pin@389_polysilicon-1##27 9.938
R2766 A1#11pin@389_polysilicon-1##27 A1#11pin@389_polysilicon-1##28 9.938
R2767 A1#11pin@389_polysilicon-1##28 A1#11pin@389_polysilicon-1##29 9.938
R2768 A1#11pin@389_polysilicon-1##29 A1#11pin@389_polysilicon-1##30 9.938
R2769 A1#11pin@389_polysilicon-1##30 A1#11pin@389_polysilicon-1##31 9.938
R2770 A1#11pin@389_polysilicon-1##31 A1#11pin@389_polysilicon-1##32 9.938
R2771 A1#11pin@389_polysilicon-1##32 A1#11pin@389_polysilicon-1##33 9.938
R2772 A1#11pin@389_polysilicon-1##33 A1#11pin@389_polysilicon-1##34 9.938
R2773 A1#11pin@389_polysilicon-1##34 A1#11pin@389_polysilicon-1##35 9.938
R2774 A1#11pin@389_polysilicon-1##35 A1#11pin@389_polysilicon-1##36 9.938
R2775 A1#11pin@389_polysilicon-1##36 A1#11pin@389_polysilicon-1##37 9.938
R2776 A1#11pin@389_polysilicon-1##37 A1#11pin@389_polysilicon-1##38 9.938
R2777 A1#11pin@389_polysilicon-1##38 A1#11pin@389_polysilicon-1##39 9.938
R2778 A1#11pin@389_polysilicon-1##39 A1#11pin@389_polysilicon-1##40 9.938
R2779 A1#11pin@389_polysilicon-1##40 A1#11pin@389_polysilicon-1##41 9.938
R2780 A1#11pin@389_polysilicon-1##41 A1#11pin@389_polysilicon-1##42 9.938
R2781 A1#11pin@389_polysilicon-1##42 A1#11pin@389_polysilicon-1##43 9.938
R2782 A1#11pin@389_polysilicon-1##43 A1#11pin@389_polysilicon-1##44 9.938
R2783 A1#11pin@389_polysilicon-1##44 A1#11pin@389_polysilicon-1##45 9.938
R2784 A1#11pin@389_polysilicon-1##45 A1#11pin@389_polysilicon-1##46 9.938
R2785 A1#11pin@389_polysilicon-1##46 A1#11pin@389_polysilicon-1##47 9.938
R2786 A1#11pin@389_polysilicon-1##47 A1#11pin@389_polysilicon-1##48 9.938
R2787 A1#11pin@389_polysilicon-1##48 A1#11pin@389_polysilicon-1##49 9.938
R2788 A1#11pin@389_polysilicon-1##49 A1#20nmos@76_poly-right 9.938
R2789 B1#21pmos@77_poly-right B1#21pmos@77_poly-right##0 9.869
R2790 B1#21pmos@77_poly-right##0 B1#21pmos@77_poly-right##1 9.869
R2791 B1#21pmos@77_poly-right##1 B1#21pmos@77_poly-right##2 9.869
R2792 B1#21pmos@77_poly-right##2 B1#21pmos@77_poly-right##3 9.869
R2793 B1#21pmos@77_poly-right##3 B1#21pmos@77_poly-right##4 9.869
R2794 B1#21pmos@77_poly-right##4 B1#21pmos@77_poly-right##5 9.869
R2795 B1#21pmos@77_poly-right##5 B1#21pmos@77_poly-right##6 9.869
R2796 B1#21pmos@77_poly-right##6 B1#21pmos@77_poly-right##7 9.869
R2797 B1#21pmos@77_poly-right##7 B1#21pmos@77_poly-right##8 9.869
R2798 B1#21pmos@77_poly-right##8 B1#21pmos@77_poly-right##9 9.869
R2799 B1#21pmos@77_poly-right##9 B1#21pmos@77_poly-right##10 9.869
R2800 B1#21pmos@77_poly-right##10 B1#21pmos@77_poly-right##11 9.869
R2801 B1#21pmos@77_poly-right##11 B1#21pmos@77_poly-right##12 9.869
R2802 B1#21pmos@77_poly-right##12 B1#21pmos@77_poly-right##13 9.869
R2803 B1#21pmos@77_poly-right##13 B1#21pmos@77_poly-right##14 9.869
R2804 B1#21pmos@77_poly-right##14 B1#21pmos@77_poly-right##15 9.869
R2805 B1#21pmos@77_poly-right##15 B1#21pmos@77_poly-right##16 9.869
R2806 B1#21pmos@77_poly-right##16 B1#21pmos@77_poly-right##17 9.869
R2807 B1#21pmos@77_poly-right##17 B1#21pmos@77_poly-right##18 9.869
R2808 B1#21pmos@77_poly-right##18 B1#21pmos@77_poly-right##19 9.869
R2809 B1#21pmos@77_poly-right##19 B1#21pmos@77_poly-right##20 9.869
R2810 B1#21pmos@77_poly-right##20 B1#21pmos@77_poly-right##21 9.869
R2811 B1#21pmos@77_poly-right##21 B1#21pmos@77_poly-right##22 9.869
R2812 B1#21pmos@77_poly-right##22 B1#21pmos@77_poly-right##23 9.869
R2813 B1#21pmos@77_poly-right##23 B1#21pmos@77_poly-right##24 9.869
R2814 B1#21pmos@77_poly-right##24 B1#21pmos@77_poly-right##25 9.869
R2815 B1#21pmos@77_poly-right##25 B1#21pmos@77_poly-right##26 9.869
R2816 B1#21pmos@77_poly-right##26 B1#21pmos@77_poly-right##27 9.869
R2817 B1#21pmos@77_poly-right##27 B1#21pmos@77_poly-right##28 9.869
R2818 B1#21pmos@77_poly-right##28 B1#21pmos@77_poly-right##29 9.869
R2819 B1#21pmos@77_poly-right##29 B1#21pmos@77_poly-right##30 9.869
R2820 B1#21pmos@77_poly-right##30 B1#21pmos@77_poly-right##31 9.869
R2821 B1#21pmos@77_poly-right##31 B1#21pmos@77_poly-right##32 9.869
R2822 B1#21pmos@77_poly-right##32 B1#21pmos@77_poly-right##33 9.869
R2823 B1#21pmos@77_poly-right##33 B1#21pmos@77_poly-right##34 9.869
R2824 B1#21pmos@77_poly-right##34 B1#21pmos@77_poly-right##35 9.869
R2825 B1#21pmos@77_poly-right##35 B1#21pmos@77_poly-right##36 9.869
R2826 B1#21pmos@77_poly-right##36 B1#21pmos@77_poly-right##37 9.869
R2827 B1#21pmos@77_poly-right##37 B1#21pmos@77_poly-right##38 9.869
R2828 B1#21pmos@77_poly-right##38 B1#21pmos@77_poly-right##39 9.869
R2829 B1#21pmos@77_poly-right##39 B1#21pmos@77_poly-right##40 9.869
R2830 B1#21pmos@77_poly-right##40 B1#21pmos@77_poly-right##41 9.869
R2831 B1#21pmos@77_poly-right##41 B1#21pmos@77_poly-right##42 9.869
R2832 B1#21pmos@77_poly-right##42 B1#21pmos@77_poly-right##43 9.869
R2833 B1#21pmos@77_poly-right##43 B1#21pmos@77_poly-right##44 9.869
R2834 B1#21pmos@77_poly-right##44 B1#21pmos@77_poly-right##45 9.869
R2835 B1#21pmos@77_poly-right##45 B1#21pmos@77_poly-right##46 9.869
R2836 B1#21pmos@77_poly-right##46 B1#21pmos@77_poly-right##47 9.869
R2837 B1#21pmos@77_poly-right##47 B1#11pin@393_polysilicon-1 9.869
R2838 NAND2_to_Nand4#9pin@395_polysilicon-1 NAND2_to_Nand4#9pin@395_polysilicon-1##0 9.938
R2839 NAND2_to_Nand4#9pin@395_polysilicon-1##0 NAND2_to_Nand4#9pin@395_polysilicon-1##1 9.938
R2840 NAND2_to_Nand4#9pin@395_polysilicon-1##1 NAND2_to_Nand4#9pin@395_polysilicon-1##2 9.938
R2841 NAND2_to_Nand4#9pin@395_polysilicon-1##2 NAND2_to_Nand4#9pin@395_polysilicon-1##3 9.938
R2842 NAND2_to_Nand4#9pin@395_polysilicon-1##3 NAND2_to_Nand4#9pin@395_polysilicon-1##4 9.938
R2843 NAND2_to_Nand4#9pin@395_polysilicon-1##4 NAND2_to_Nand4#9pin@395_polysilicon-1##5 9.938
R2844 NAND2_to_Nand4#9pin@395_polysilicon-1##5 NAND2_to_Nand4#9pin@395_polysilicon-1##6 9.938
R2845 NAND2_to_Nand4#9pin@395_polysilicon-1##6 NAND2_to_Nand4#9pin@395_polysilicon-1##7 9.938
R2846 NAND2_to_Nand4#9pin@395_polysilicon-1##7 NAND2_to_Nand4#9pin@395_polysilicon-1##8 9.938
R2847 NAND2_to_Nand4#9pin@395_polysilicon-1##8 NAND2_to_Nand4#9pin@395_polysilicon-1##9 9.938
R2848 NAND2_to_Nand4#9pin@395_polysilicon-1##9 NAND2_to_Nand4#9pin@395_polysilicon-1##10 9.938
R2849 NAND2_to_Nand4#9pin@395_polysilicon-1##10 NAND2_to_Nand4#9pin@395_polysilicon-1##11 9.938
R2850 NAND2_to_Nand4#9pin@395_polysilicon-1##11 NAND2_to_Nand4#9pin@395_polysilicon-1##12 9.938
R2851 NAND2_to_Nand4#9pin@395_polysilicon-1##12 NAND2_to_Nand4#9pin@395_polysilicon-1##13 9.938
R2852 NAND2_to_Nand4#9pin@395_polysilicon-1##13 NAND2_to_Nand4#9pin@395_polysilicon-1##14 9.938
R2853 NAND2_to_Nand4#9pin@395_polysilicon-1##14 NAND2_to_Nand4#9pin@395_polysilicon-1##15 9.938
R2854 NAND2_to_Nand4#9pin@395_polysilicon-1##15 NAND2_to_Nand4#9pin@395_polysilicon-1##16 9.938
R2855 NAND2_to_Nand4#9pin@395_polysilicon-1##16 NAND2_to_Nand4#9pin@395_polysilicon-1##17 9.938
R2856 NAND2_to_Nand4#9pin@395_polysilicon-1##17 NAND2_to_Nand4#9pin@395_polysilicon-1##18 9.938
R2857 NAND2_to_Nand4#9pin@395_polysilicon-1##18 NAND2_to_Nand4#9pin@395_polysilicon-1##19 9.938
R2858 NAND2_to_Nand4#9pin@395_polysilicon-1##19 NAND2_to_Nand4#9pin@395_polysilicon-1##20 9.938
R2859 NAND2_to_Nand4#9pin@395_polysilicon-1##20 NAND2_to_Nand4#9pin@395_polysilicon-1##21 9.938
R2860 NAND2_to_Nand4#9pin@395_polysilicon-1##21 NAND2_to_Nand4#9pin@395_polysilicon-1##22 9.938
R2861 NAND2_to_Nand4#9pin@395_polysilicon-1##22 NAND2_to_Nand4#9pin@395_polysilicon-1##23 9.938
R2862 NAND2_to_Nand4#9pin@395_polysilicon-1##23 NAND2_to_Nand4#9pin@395_polysilicon-1##24 9.938
R2863 NAND2_to_Nand4#9pin@395_polysilicon-1##24 NAND2_to_Nand4#9pin@395_polysilicon-1##25 9.938
R2864 NAND2_to_Nand4#9pin@395_polysilicon-1##25 NAND2_to_Nand4#9pin@395_polysilicon-1##26 9.938
R2865 NAND2_to_Nand4#9pin@395_polysilicon-1##26 NAND2_to_Nand4#9pin@395_polysilicon-1##27 9.938
R2866 NAND2_to_Nand4#9pin@395_polysilicon-1##27 NAND2_to_Nand4#9pin@395_polysilicon-1##28 9.938
R2867 NAND2_to_Nand4#9pin@395_polysilicon-1##28 NAND2_to_Nand4#9pin@395_polysilicon-1##29 9.938
R2868 NAND2_to_Nand4#9pin@395_polysilicon-1##29 NAND2_to_Nand4#9pin@395_polysilicon-1##30 9.938
R2869 NAND2_to_Nand4#9pin@395_polysilicon-1##30 NAND2_to_Nand4#9pin@395_polysilicon-1##31 9.938
R2870 NAND2_to_Nand4#9pin@395_polysilicon-1##31 NAND2_to_Nand4#9pin@395_polysilicon-1##32 9.938
R2871 NAND2_to_Nand4#9pin@395_polysilicon-1##32 NAND2_to_Nand4#9pin@395_polysilicon-1##33 9.938
R2872 NAND2_to_Nand4#9pin@395_polysilicon-1##33 NAND2_to_Nand4#9pin@395_polysilicon-1##34 9.938
R2873 NAND2_to_Nand4#9pin@395_polysilicon-1##34 NAND2_to_Nand4#9pin@395_polysilicon-1##35 9.938
R2874 NAND2_to_Nand4#9pin@395_polysilicon-1##35 NAND2_to_Nand4#9pin@395_polysilicon-1##36 9.938
R2875 NAND2_to_Nand4#9pin@395_polysilicon-1##36 NAND2_to_Nand4#9pin@395_polysilicon-1##37 9.938
R2876 NAND2_to_Nand4#9pin@395_polysilicon-1##37 NAND2_to_Nand4#9pin@395_polysilicon-1##38 9.938
R2877 NAND2_to_Nand4#9pin@395_polysilicon-1##38 NAND2_to_Nand4#9pin@395_polysilicon-1##39 9.938
R2878 NAND2_to_Nand4#9pin@395_polysilicon-1##39 NAND2_to_Nand4#9pin@395_polysilicon-1##40 9.938
R2879 NAND2_to_Nand4#9pin@395_polysilicon-1##40 NAND2_to_Nand4#9pin@395_polysilicon-1##41 9.938
R2880 NAND2_to_Nand4#9pin@395_polysilicon-1##41 NAND2_to_Nand4#9pin@395_polysilicon-1##42 9.938
R2881 NAND2_to_Nand4#9pin@395_polysilicon-1##42 NAND2_to_Nand4#9pin@395_polysilicon-1##43 9.938
R2882 NAND2_to_Nand4#9pin@395_polysilicon-1##43 NAND2_to_Nand4#9pin@395_polysilicon-1##44 9.938
R2883 NAND2_to_Nand4#9pin@395_polysilicon-1##44 NAND2_to_Nand4#9pin@395_polysilicon-1##45 9.938
R2884 NAND2_to_Nand4#9pin@395_polysilicon-1##45 NAND2_to_Nand4#9pin@395_polysilicon-1##46 9.938
R2885 NAND2_to_Nand4#9pin@395_polysilicon-1##46 NAND2_to_Nand4#9pin@395_polysilicon-1##47 9.938
R2886 NAND2_to_Nand4#9pin@395_polysilicon-1##47 NAND2_to_Nand4#9pin@395_polysilicon-1##48 9.938
R2887 NAND2_to_Nand4#9pin@395_polysilicon-1##48 NAND2_to_Nand4#9pin@395_polysilicon-1##49 9.938
R2888 NAND2_to_Nand4#9pin@395_polysilicon-1##49 NAND2_to_Nand4#11nmos@78_poly-right 9.938
R2889 Cin_to_XOR2___NAND3#17nmos@79_poly-right Cin_to_XOR2___NAND3#17nmos@79_poly-right##0 9.898
R2890 Cin_to_XOR2___NAND3#17nmos@79_poly-right##0 Cin_to_XOR2___NAND3#17nmos@79_poly-right##1 9.898
R2891 Cin_to_XOR2___NAND3#17nmos@79_poly-right##1 Cin_to_XOR2___NAND3#17nmos@79_poly-right##2 9.898
R2892 Cin_to_XOR2___NAND3#17nmos@79_poly-right##2 Cin_to_XOR2___NAND3#17nmos@79_poly-right##3 9.898
R2893 Cin_to_XOR2___NAND3#17nmos@79_poly-right##3 Cin_to_XOR2___NAND3#17nmos@79_poly-right##4 9.898
R2894 Cin_to_XOR2___NAND3#17nmos@79_poly-right##4 Cin_to_XOR2___NAND3#17nmos@79_poly-right##5 9.898
R2895 Cin_to_XOR2___NAND3#17nmos@79_poly-right##5 Cin_to_XOR2___NAND3#17nmos@79_poly-right##6 9.898
R2896 Cin_to_XOR2___NAND3#17nmos@79_poly-right##6 Cin_to_XOR2___NAND3#17nmos@79_poly-right##7 9.898
R2897 Cin_to_XOR2___NAND3#17nmos@79_poly-right##7 Cin_to_XOR2___NAND3#17nmos@79_poly-right##8 9.898
R2898 Cin_to_XOR2___NAND3#17nmos@79_poly-right##8 Cin_to_XOR2___NAND3#17nmos@79_poly-right##9 9.898
R2899 Cin_to_XOR2___NAND3#17nmos@79_poly-right##9 Cin_to_XOR2___NAND3#17nmos@79_poly-right##10 9.898
R2900 Cin_to_XOR2___NAND3#17nmos@79_poly-right##10 Cin_to_XOR2___NAND3#17nmos@79_poly-right##11 9.898
R2901 Cin_to_XOR2___NAND3#17nmos@79_poly-right##11 Cin_to_XOR2___NAND3#17nmos@79_poly-right##12 9.898
R2902 Cin_to_XOR2___NAND3#17nmos@79_poly-right##12 Cin_to_XOR2___NAND3#17nmos@79_poly-right##13 9.898
R2903 Cin_to_XOR2___NAND3#17nmos@79_poly-right##13 Cin_to_XOR2___NAND3#17nmos@79_poly-right##14 9.898
R2904 Cin_to_XOR2___NAND3#17nmos@79_poly-right##14 Cin_to_XOR2___NAND3#17nmos@79_poly-right##15 9.898
R2905 Cin_to_XOR2___NAND3#17nmos@79_poly-right##15 Cin_to_XOR2___NAND3#17nmos@79_poly-right##16 9.898
R2906 Cin_to_XOR2___NAND3#17nmos@79_poly-right##16 Cin_to_XOR2___NAND3#17nmos@79_poly-right##17 9.898
R2907 Cin_to_XOR2___NAND3#17nmos@79_poly-right##17 Cin_to_XOR2___NAND3#17nmos@79_poly-right##18 9.898
R2908 Cin_to_XOR2___NAND3#17nmos@79_poly-right##18 Cin_to_XOR2___NAND3#17nmos@79_poly-right##19 9.898
R2909 Cin_to_XOR2___NAND3#17nmos@79_poly-right##19 Cin_to_XOR2___NAND3#17nmos@79_poly-right##20 9.898
R2910 Cin_to_XOR2___NAND3#17nmos@79_poly-right##20 Cin_to_XOR2___NAND3#17nmos@79_poly-right##21 9.898
R2911 Cin_to_XOR2___NAND3#17nmos@79_poly-right##21 Cin_to_XOR2___NAND3#17nmos@79_poly-right##22 9.898
R2912 Cin_to_XOR2___NAND3#17nmos@79_poly-right##22 Cin_to_XOR2___NAND3#17nmos@79_poly-right##23 9.898
R2913 Cin_to_XOR2___NAND3#17nmos@79_poly-right##23 Cin_to_XOR2___NAND3#17nmos@79_poly-right##24 9.898
R2914 Cin_to_XOR2___NAND3#17nmos@79_poly-right##24 Cin_to_XOR2___NAND3#17nmos@79_poly-right##25 9.898
R2915 Cin_to_XOR2___NAND3#17nmos@79_poly-right##25 Cin_to_XOR2___NAND3#17nmos@79_poly-right##26 9.898
R2916 Cin_to_XOR2___NAND3#17nmos@79_poly-right##26 Cin_to_XOR2___NAND3#17nmos@79_poly-right##27 9.898
R2917 Cin_to_XOR2___NAND3#17nmos@79_poly-right##27 Cin_to_XOR2___NAND3#17nmos@79_poly-right##28 9.898
R2918 Cin_to_XOR2___NAND3#17nmos@79_poly-right##28 Cin_to_XOR2___NAND3#17nmos@79_poly-right##29 9.898
R2919 Cin_to_XOR2___NAND3#17nmos@79_poly-right##29 Cin_to_XOR2___NAND3#17nmos@79_poly-right##30 9.898
R2920 Cin_to_XOR2___NAND3#17nmos@79_poly-right##30 Cin_to_XOR2___NAND3#17nmos@79_poly-right##31 9.898
R2921 Cin_to_XOR2___NAND3#17nmos@79_poly-right##31 Cin_to_XOR2___NAND3#17nmos@79_poly-right##32 9.898
R2922 Cin_to_XOR2___NAND3#17nmos@79_poly-right##32 Cin_to_XOR2___NAND3#17nmos@79_poly-right##33 9.898
R2923 Cin_to_XOR2___NAND3#17nmos@79_poly-right##33 Cin_to_XOR2___NAND3#17nmos@79_poly-right##34 9.898
R2924 Cin_to_XOR2___NAND3#17nmos@79_poly-right##34 Cin_to_XOR2___NAND3#17nmos@79_poly-right##35 9.898
R2925 Cin_to_XOR2___NAND3#17nmos@79_poly-right##35 Cin_to_XOR2___NAND3#17nmos@79_poly-right##36 9.898
R2926 Cin_to_XOR2___NAND3#17nmos@79_poly-right##36 Cin_to_XOR2___NAND3#17nmos@79_poly-right##37 9.898
R2927 Cin_to_XOR2___NAND3#17nmos@79_poly-right##37 Cin_to_XOR2___NAND3#17nmos@79_poly-right##38 9.898
R2928 Cin_to_XOR2___NAND3#17nmos@79_poly-right##38 Cin_to_XOR2___NAND3#17nmos@79_poly-right##39 9.898
R2929 Cin_to_XOR2___NAND3#17nmos@79_poly-right##39 Cin_to_XOR2___NAND3#17nmos@79_poly-right##40 9.898
R2930 Cin_to_XOR2___NAND3#17nmos@79_poly-right##40 Cin_to_XOR2___NAND3#17nmos@79_poly-right##41 9.898
R2931 Cin_to_XOR2___NAND3#17nmos@79_poly-right##41 Cin_to_XOR2___NAND3#17nmos@79_poly-right##42 9.898
R2932 Cin_to_XOR2___NAND3#17nmos@79_poly-right##42 Cin_to_XOR2___NAND3#17nmos@79_poly-right##43 9.898
R2933 Cin_to_XOR2___NAND3#17nmos@79_poly-right##43 Cin_to_XOR2___NAND3#17nmos@79_poly-right##44 9.898
R2934 Cin_to_XOR2___NAND3#17nmos@79_poly-right##44 Cin_to_XOR2___NAND3#17nmos@79_poly-right##45 9.898
R2935 Cin_to_XOR2___NAND3#17nmos@79_poly-right##45 Cin_to_XOR2___NAND3#17nmos@79_poly-right##46 9.898
R2936 Cin_to_XOR2___NAND3#17nmos@79_poly-right##46 Cin_to_XOR2___NAND3#17nmos@79_poly-right##47 9.898
R2937 Cin_to_XOR2___NAND3#17nmos@79_poly-right##47 Cin_to_XOR2___NAND3#17nmos@79_poly-right##48 9.898
R2938 Cin_to_XOR2___NAND3#17nmos@79_poly-right##48 Cin_to_XOR2___NAND3#17nmos@79_poly-right##49 9.898
R2939 Cin_to_XOR2___NAND3#17nmos@79_poly-right##49 Cin_to_XOR2___NAND3#17nmos@79_poly-right##50 9.898
R2940 Cin_to_XOR2___NAND3#17nmos@79_poly-right##50 Cin_to_XOR2___NAND3#17nmos@79_poly-right##51 9.898
R2941 Cin_to_XOR2___NAND3#17nmos@79_poly-right##51 Cin_to_XOR2___NAND3#17nmos@79_poly-right##52 9.898
R2942 Cin_to_XOR2___NAND3#17nmos@79_poly-right##52 Cin_to_XOR2___NAND3#17nmos@79_poly-right##53 9.898
R2943 Cin_to_XOR2___NAND3#17nmos@79_poly-right##53 Cin_to_XOR2___NAND3#17nmos@79_poly-right##54 9.898
R2944 Cin_to_XOR2___NAND3#17nmos@79_poly-right##54 Cin_to_XOR2___NAND3#17nmos@79_poly-right##55 9.898
R2945 Cin_to_XOR2___NAND3#17nmos@79_poly-right##55 Cin_to_XOR2___NAND3#14pmos@79_poly-right 9.898
R2946 net@1352 net@1352#2nmos@79_diff-bottom 4.42
R2947 NAND2_to_Nand4 NAND2_to_Nand4#4nmos@77_diff-bottom 4.42
R2948 B1 B1##0 5.018
C216 B1##0 0 5.383fF
R2949 B1##0 B1#0pin@508_metal-2 5.018
R2950 net@1809 net@1809##0 9.92
R2951 net@1809##0 net@1809##1 9.92
R2952 net@1809##1 net@1809##2 9.92
R2953 net@1809##2 net@1809##3 9.92
R2954 net@1809##3 net@1809##4 9.92
R2955 net@1809##4 net@1809##5 9.92
R2956 net@1809##5 net@1809##6 9.92
R2957 net@1809##6 net@1809##7 9.92
R2958 net@1809##7 net@1809##8 9.92
R2959 net@1809##8 net@1809##9 9.92
R2960 net@1809##9 net@1809##10 9.92
R2961 net@1809##10 net@1809##11 9.92
R2962 net@1809##11 net@1809##12 9.92
R2963 net@1809##12 net@1809##13 9.92
R2964 net@1809##13 net@1809##14 9.92
R2965 net@1809##14 net@1809##15 9.92
R2966 net@1809##15 net@1809##16 9.92
R2967 net@1809##16 net@1809##17 9.92
R2968 net@1809##17 net@1809##18 9.92
R2969 net@1809##18 net@1809#1pin@546_polysilicon-1 9.92
R2970 net@1811 net@1811##0 9.92
R2971 net@1811##0 net@1811##1 9.92
R2972 net@1811##1 net@1811##2 9.92
R2973 net@1811##2 net@1811##3 9.92
R2974 net@1811##3 net@1811##4 9.92
R2975 net@1811##4 net@1811##5 9.92
R2976 net@1811##5 net@1811##6 9.92
R2977 net@1811##6 net@1811##7 9.92
R2978 net@1811##7 net@1811##8 9.92
R2979 net@1811##8 net@1811##9 9.92
R2980 net@1811##9 net@1811##10 9.92
R2981 net@1811##10 net@1811##11 9.92
R2982 net@1811##11 net@1811##12 9.92
R2983 net@1811##12 net@1811##13 9.92
R2984 net@1811##13 net@1811##14 9.92
R2985 net@1811##14 net@1811##15 9.92
R2986 net@1811##15 net@1811##16 9.92
R2987 net@1811##16 net@1811##17 9.92
R2988 net@1811##17 net@1811##18 9.92
R2989 net@1811##18 net@1811#1pin@571_polysilicon-1 9.92
R2990 XOR1_to_NAND3#3pin@572_polysilicon-1 XOR1_to_NAND3#3pin@572_polysilicon-1##0 6.2
R2991 XOR1_to_NAND3#3pin@572_polysilicon-1##0 XOR1_to_NAND3#4pmos@92_poly-right 6.2
R2992 XOR1_to_NAND3#3pin@572_polysilicon-1 XOR1_to_NAND3#3pin@572_polysilicon-1##0 8.138
R2993 XOR1_to_NAND3#3pin@572_polysilicon-1##0 XOR1_to_NAND3#3pin@572_polysilicon-1##1 8.138
R2994 XOR1_to_NAND3#3pin@572_polysilicon-1##1 XOR1_to_NAND3#3pin@572_polysilicon-1##2 8.138
R2995 XOR1_to_NAND3#3pin@572_polysilicon-1##2 XOR1_to_NAND3#1contact@656_metal-1-metal-2 8.138
R2996 Cin_to_XOR2___NAND3#22nmos@91_poly-right Cin_to_XOR2___NAND3#22nmos@91_poly-right##0 5.425
R2997 Cin_to_XOR2___NAND3#22nmos@91_poly-right##0 Cin_to_XOR2___NAND3#23pin@562_polysilicon-1 5.425
R2998 Cin_to_XOR2___NAND3 Cin_to_XOR2___NAND3##0 8.99
R2999 Cin_to_XOR2___NAND3##0 Cin_to_XOR2___NAND3##1 8.99
R3000 Cin_to_XOR2___NAND3##1 Cin_to_XOR2___NAND3##2 8.99
R3001 Cin_to_XOR2___NAND3##2 Cin_to_XOR2___NAND3##3 8.99
R3002 Cin_to_XOR2___NAND3##3 Cin_to_XOR2___NAND3#23pin@562_polysilicon-1 8.99
R3003 A2#3pin@547_polysilicon-1 A2#3pin@547_polysilicon-1##0 6.2
R3004 A2#3pin@547_polysilicon-1##0 A2#4pmos@85_poly-right 6.2
R3005 XOR1_to_NAND3#9pmos@87_poly-left XOR1_to_NAND3#9pmos@87_poly-left##0 8.138
R3006 XOR1_to_NAND3#9pmos@87_poly-left##0 XOR1_to_NAND3#9pmos@87_poly-left##1 8.138
R3007 XOR1_to_NAND3#9pmos@87_poly-left##1 XOR1_to_NAND3#9pmos@87_poly-left##2 8.138
R3008 XOR1_to_NAND3#9pmos@87_poly-left##2 XOR1_to_NAND3#10pin@559_polysilicon-1 8.138
R3009 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##0 9.843
R3010 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##0 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##1 9.843
R3011 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##1 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##2 9.843
R3012 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##2 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##3 9.843
R3013 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##3 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##4 9.843
R3014 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##4 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##5 9.843
R3015 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##5 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##6 9.843
R3016 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##6 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##7 9.843
R3017 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##7 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##8 9.843
R3018 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##8 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##9 9.843
R3019 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##9 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##10 9.843
R3020 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##10 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##11 9.843
R3021 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##11 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##12 9.843
R3022 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##12 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##13 9.843
R3023 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##13 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##14 9.843
R3024 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##14 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##15 9.843
R3025 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##15 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##16 9.843
R3026 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##16 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##17 9.843
R3027 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##17 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##18 9.843
R3028 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1##18 Cin_to_XOR2___NAND3#25pin@569_polysilicon-1 9.843
R3029 net@1820#4nmos@93_poly-right net@1820#4nmos@93_poly-right##0 9.3
R3030 net@1820#4nmos@93_poly-right##0 net@1820#4nmos@93_poly-right##1 9.3
R3031 net@1820#4nmos@93_poly-right##1 net@1820#5pin@564_polysilicon-1 9.3
R3032 net@1820#2contact@642_metal-1-polysilicon-1 net@1820#2contact@642_metal-1-polysilicon-1##0 8.99
R3033 net@1820#2contact@642_metal-1-polysilicon-1##0 net@1820#2contact@642_metal-1-polysilicon-1##1 8.99
R3034 net@1820#2contact@642_metal-1-polysilicon-1##1 net@1820#2contact@642_metal-1-polysilicon-1##2 8.99
R3035 net@1820#2contact@642_metal-1-polysilicon-1##2 net@1820#2contact@642_metal-1-polysilicon-1##3 8.99
R3036 net@1820#2contact@642_metal-1-polysilicon-1##3 net@1820#5pin@564_polysilicon-1 8.99
R3037 A2#3pin@547_polysilicon-1 A2#3pin@547_polysilicon-1##0 8.138
R3038 A2#3pin@547_polysilicon-1##0 A2#3pin@547_polysilicon-1##1 8.138
R3039 A2#3pin@547_polysilicon-1##1 A2#3pin@547_polysilicon-1##2 8.138
R3040 A2#3pin@547_polysilicon-1##2 A2#1pin@586_metal-2 8.138
R3041 XOR1_to_NAND3#1contact@656_metal-1-metal-2 XOR1_to_NAND3#1contact@656_metal-1-metal-2##0 6.717
R3042 XOR1_to_NAND3#1contact@656_metal-1-metal-2##0 XOR1_to_NAND3#1contact@656_metal-1-metal-2##1 6.717
R3043 XOR1_to_NAND3#1contact@656_metal-1-metal-2##1 XOR1_to_NAND3#12pin@560_polysilicon-1 6.717
R3044 XOR1_to_NAND3#10pin@559_polysilicon-1 XOR1_to_NAND3#10pin@559_polysilicon-1##0 7.75
R3045 XOR1_to_NAND3#10pin@559_polysilicon-1##0 XOR1_to_NAND3#10pin@559_polysilicon-1##1 7.75
R3046 XOR1_to_NAND3#10pin@559_polysilicon-1##1 XOR1_to_NAND3#12pin@560_polysilicon-1 7.75
R3047 Cin_to_XOR2___NAND3#25pin@569_polysilicon-1 Cin_to_XOR2___NAND3#25pin@569_polysilicon-1##0 9.743
R3048 Cin_to_XOR2___NAND3#25pin@569_polysilicon-1##0 Cin_to_XOR2___NAND3#25pin@569_polysilicon-1##1 9.743
R3049 Cin_to_XOR2___NAND3#25pin@569_polysilicon-1##1 Cin_to_XOR2___NAND3#25pin@569_polysilicon-1##2 9.743
R3050 Cin_to_XOR2___NAND3#25pin@569_polysilicon-1##2 Cin_to_XOR2___NAND3#25pin@569_polysilicon-1##3 9.743
R3051 Cin_to_XOR2___NAND3#25pin@569_polysilicon-1##3 Cin_to_XOR2___NAND3#25pin@569_polysilicon-1##4 9.743
R3052 Cin_to_XOR2___NAND3#25pin@569_polysilicon-1##4 Cin_to_XOR2___NAND3#25pin@569_polysilicon-1##5 9.743
R3053 Cin_to_XOR2___NAND3#25pin@569_polysilicon-1##5 Cin_to_XOR2___NAND3 9.743
R3054 net@1811#7pmos@88_poly-left net@1811#7pmos@88_poly-left##0 7.75
R3055 net@1811#7pmos@88_poly-left##0 net@1811 7.75
R3056 Cin_to_XOR2___NAND3#26nmos@89_poly-left Cin_to_XOR2___NAND3#26nmos@89_poly-left##0 6.2
R3057 Cin_to_XOR2___NAND3#26nmos@89_poly-left##0 Cin_to_XOR2___NAND3#24pin@552_polysilicon-1 6.2
R3058 net@1821#9nmos@90_poly-left net@1821#9nmos@90_poly-left##0 8.37
R3059 net@1821#9nmos@90_poly-left##0 net@1821#9nmos@90_poly-left##1 8.37
R3060 net@1821#9nmos@90_poly-left##1 net@1821#9nmos@90_poly-left##2 8.37
R3061 net@1821#9nmos@90_poly-left##2 net@1821#9nmos@90_poly-left##3 8.37
R3062 net@1821#9nmos@90_poly-left##3 net@1821#2contact@617_metal-1-metal-2 8.37
R3063 XOR1_to_NAND3 XOR1_to_NAND3##0 6.717
R3064 XOR1_to_NAND3##0 XOR1_to_NAND3##1 6.717
R3065 XOR1_to_NAND3##1 XOR1_to_NAND3#14pin@576_polysilicon-1 6.717
R3066 XOR1_to_NAND3#16pmos@94_poly-right XOR1_to_NAND3#16pmos@94_poly-right##0 6.2
R3067 XOR1_to_NAND3#16pmos@94_poly-right##0 XOR1_to_NAND3#14pin@576_polysilicon-1 6.2
R3068 Cin_to_XOR2___NAND3#31pin@580_polysilicon-1 Cin_to_XOR2___NAND3#31pin@580_polysilicon-1##0 9.688
R3069 Cin_to_XOR2___NAND3#31pin@580_polysilicon-1##0 Cin_to_XOR2___NAND3#31pin@580_polysilicon-1##1 9.688
R3070 Cin_to_XOR2___NAND3#31pin@580_polysilicon-1##1 Cin_to_XOR2___NAND3#31pin@580_polysilicon-1##2 9.688
R3071 Cin_to_XOR2___NAND3#31pin@580_polysilicon-1##2 Cin_to_XOR2___NAND3#28contact@655_metal-1-metal-2 9.688
R3072 Cin_to_XOR2___NAND3#28contact@655_metal-1-metal-2 Cin_to_XOR2___NAND3 4.953
R3073 A2#0contact@664_metal-1-metal-2 A2#0contact@664_metal-1-metal-2##0 6.717
R3074 A2#0contact@664_metal-1-metal-2##0 A2#0contact@664_metal-1-metal-2##1 6.717
R3075 A2#0contact@664_metal-1-metal-2##1 A2#10pin@583_polysilicon-1 6.717
R3076 A2#11pmos@96_poly-right A2#11pmos@96_poly-right##0 9.558
R3077 A2#11pmos@96_poly-right##0 A2#11pmos@96_poly-right##1 9.558
R3078 A2#11pmos@96_poly-right##1 A2#11pmos@96_poly-right##2 9.558
R3079 A2#11pmos@96_poly-right##2 A2#11pmos@96_poly-right##3 9.558
R3080 A2#11pmos@96_poly-right##3 A2#11pmos@96_poly-right##4 9.558
R3081 A2#11pmos@96_poly-right##4 A2#10pin@583_polysilicon-1 9.558
R3082 B2#10pin@587_polysilicon-1 B2#10pin@587_polysilicon-1##0 8.138
R3083 B2#10pin@587_polysilicon-1##0 B2#10pin@587_polysilicon-1##1 8.138
R3084 B2#10pin@587_polysilicon-1##1 B2#10pin@587_polysilicon-1##2 8.138
R3085 B2#10pin@587_polysilicon-1##2 B2#0contact@665_metal-1-metal-2 8.138
R3086 B2#11nmos@84_poly-right B2#11nmos@84_poly-right##0 5.425
R3087 B2#11nmos@84_poly-right##0 B2#12pin@537_polysilicon-1 5.425
R3088 NAND2_to_Nand5 NAND2_to_Nand5##0 6.717
R3089 NAND2_to_Nand5##0 NAND2_to_Nand5##1 6.717
R3090 NAND2_to_Nand5##1 NAND2_to_Nand5#9pin@589_polysilicon-1 6.717
R3091 NAND2_to_Nand5#10pmos@98_poly-right NAND2_to_Nand5#10pmos@98_poly-right##0 9.558
R3092 NAND2_to_Nand5#10pmos@98_poly-right##0 NAND2_to_Nand5#10pmos@98_poly-right##1 9.558
R3093 NAND2_to_Nand5#10pmos@98_poly-right##1 NAND2_to_Nand5#10pmos@98_poly-right##2 9.558
R3094 NAND2_to_Nand5#10pmos@98_poly-right##2 NAND2_to_Nand5#10pmos@98_poly-right##3 9.558
R3095 NAND2_to_Nand5#10pmos@98_poly-right##3 NAND2_to_Nand5#10pmos@98_poly-right##4 9.558
R3096 NAND2_to_Nand5#10pmos@98_poly-right##4 NAND2_to_Nand5#9pin@589_polysilicon-1 9.558
R3097 B2#1pin@588_metal-2 B2#1pin@588_metal-2##0 8.99
R3098 B2#1pin@588_metal-2##0 B2#1pin@588_metal-2##1 8.99
R3099 B2#1pin@588_metal-2##1 B2#1pin@588_metal-2##2 8.99
R3100 B2#1pin@588_metal-2##2 B2#1pin@588_metal-2##3 8.99
R3101 B2#1pin@588_metal-2##3 B2#12pin@537_polysilicon-1 8.99
R3102 NAND1_to_NAND5#11pmos@99_poly-right NAND1_to_NAND5#11pmos@99_poly-right##0 5.425
R3103 NAND1_to_NAND5#11pmos@99_poly-right##0 NAND1_to_NAND5#12pin@593_polysilicon-1 5.425
R3104 NAND1_to_NAND5#12pin@593_polysilicon-1 NAND1_to_NAND5#12pin@593_polysilicon-1##0 9.3
R3105 NAND1_to_NAND5#12pin@593_polysilicon-1##0 NAND1_to_NAND5#12pin@593_polysilicon-1##1 9.3
R3106 NAND1_to_NAND5#12pin@593_polysilicon-1##1 NAND1_to_NAND5 9.3
R3107 Cin_to_XOR2___NAND3#33nmos@95_poly-right Cin_to_XOR2___NAND3#33nmos@95_poly-right##0 8.636
R3108 Cin_to_XOR2___NAND3#33nmos@95_poly-right##0 Cin_to_XOR2___NAND3#33nmos@95_poly-right##1 8.636
R3109 Cin_to_XOR2___NAND3#33nmos@95_poly-right##1 Cin_to_XOR2___NAND3#33nmos@95_poly-right##2 8.636
R3110 Cin_to_XOR2___NAND3#33nmos@95_poly-right##2 Cin_to_XOR2___NAND3#33nmos@95_poly-right##3 8.636
R3111 Cin_to_XOR2___NAND3#33nmos@95_poly-right##3 Cin_to_XOR2___NAND3#33nmos@95_poly-right##4 8.636
R3112 Cin_to_XOR2___NAND3#33nmos@95_poly-right##4 Cin_to_XOR2___NAND3#33nmos@95_poly-right##5 8.636
R3113 Cin_to_XOR2___NAND3#33nmos@95_poly-right##5 Cin_to_XOR2___NAND3#31pin@580_polysilicon-1 8.636
R3114 B2#13nmos@97_poly-right B2#13nmos@97_poly-right##0 8.956
R3115 B2#13nmos@97_poly-right##0 B2#13nmos@97_poly-right##1 8.956
R3116 B2#13nmos@97_poly-right##1 B2#13nmos@97_poly-right##2 8.956
R3117 B2#13nmos@97_poly-right##2 B2#13nmos@97_poly-right##3 8.956
R3118 B2#13nmos@97_poly-right##3 B2#13nmos@97_poly-right##4 8.956
R3119 B2#13nmos@97_poly-right##4 B2#13nmos@97_poly-right##5 8.956
R3120 B2#13nmos@97_poly-right##5 B2#13nmos@97_poly-right##6 8.956
R3121 B2#13nmos@97_poly-right##6 B2#13nmos@97_poly-right##7 8.956
R3122 B2#13nmos@97_poly-right##7 B2#10pin@587_polysilicon-1 8.956
R3123 A2#12pmos@80_poly-left A2#12pmos@80_poly-left##0 8.138
R3124 A2#12pmos@80_poly-left##0 A2#12pmos@80_poly-left##1 8.138
R3125 A2#12pmos@80_poly-left##1 A2#12pmos@80_poly-left##2 8.138
R3126 A2#12pmos@80_poly-left##2 A2#13pin@534_polysilicon-1 8.138
R3127 B2#14pin@527_polysilicon-1 B2#14pin@527_polysilicon-1##0 9.843
R3128 B2#14pin@527_polysilicon-1##0 B2#14pin@527_polysilicon-1##1 9.843
R3129 B2#14pin@527_polysilicon-1##1 B2#14pin@527_polysilicon-1##2 9.843
R3130 B2#14pin@527_polysilicon-1##2 B2#14pin@527_polysilicon-1##3 9.843
R3131 B2#14pin@527_polysilicon-1##3 B2#14pin@527_polysilicon-1##4 9.843
R3132 B2#14pin@527_polysilicon-1##4 B2#14pin@527_polysilicon-1##5 9.843
R3133 B2#14pin@527_polysilicon-1##5 B2#14pin@527_polysilicon-1##6 9.843
R3134 B2#14pin@527_polysilicon-1##6 B2#14pin@527_polysilicon-1##7 9.843
R3135 B2#14pin@527_polysilicon-1##7 B2#14pin@527_polysilicon-1##8 9.843
R3136 B2#14pin@527_polysilicon-1##8 B2#14pin@527_polysilicon-1##9 9.843
R3137 B2#14pin@527_polysilicon-1##9 B2#14pin@527_polysilicon-1##10 9.843
R3138 B2#14pin@527_polysilicon-1##10 B2#14pin@527_polysilicon-1##11 9.843
R3139 B2#14pin@527_polysilicon-1##11 B2#14pin@527_polysilicon-1##12 9.843
R3140 B2#14pin@527_polysilicon-1##12 B2#14pin@527_polysilicon-1##13 9.843
R3141 B2#14pin@527_polysilicon-1##13 B2#14pin@527_polysilicon-1##14 9.843
R3142 B2#14pin@527_polysilicon-1##14 B2#14pin@527_polysilicon-1##15 9.843
R3143 B2#14pin@527_polysilicon-1##15 B2#14pin@527_polysilicon-1##16 9.843
R3144 B2#14pin@527_polysilicon-1##16 B2#14pin@527_polysilicon-1##17 9.843
R3145 B2#14pin@527_polysilicon-1##17 B2#14pin@527_polysilicon-1##18 9.843
R3146 B2#14pin@527_polysilicon-1##18 B2#15pin@544_polysilicon-1 9.843
R3147 net@1907#4nmos@86_poly-right net@1907#4nmos@86_poly-right##0 7.233
R3148 net@1907#4nmos@86_poly-right##0 net@1907#4nmos@86_poly-right##1 7.233
R3149 net@1907#4nmos@86_poly-right##1 net@1907#5pin@539_polysilicon-1 7.233
R3150 net@1907#2contact@603_metal-1-polysilicon-1 net@1907#2contact@603_metal-1-polysilicon-1##0 8.99
R3151 net@1907#2contact@603_metal-1-polysilicon-1##0 net@1907#2contact@603_metal-1-polysilicon-1##1 8.99
R3152 net@1907#2contact@603_metal-1-polysilicon-1##1 net@1907#2contact@603_metal-1-polysilicon-1##2 8.99
R3153 net@1907#2contact@603_metal-1-polysilicon-1##2 net@1907#2contact@603_metal-1-polysilicon-1##3 8.99
R3154 net@1907#2contact@603_metal-1-polysilicon-1##3 net@1907#5pin@539_polysilicon-1 8.99
R3155 A2#1pin@586_metal-2 A2#1pin@586_metal-2##0 6.717
R3156 A2#1pin@586_metal-2##0 A2#1pin@586_metal-2##1 6.717
R3157 A2#1pin@586_metal-2##1 A2#15pin@535_polysilicon-1 6.717
R3158 A2#13pin@534_polysilicon-1 A2#13pin@534_polysilicon-1##0 7.75
R3159 A2#13pin@534_polysilicon-1##0 A2#13pin@534_polysilicon-1##1 7.75
R3160 A2#13pin@534_polysilicon-1##1 A2#15pin@535_polysilicon-1 7.75
R3161 B2#15pin@544_polysilicon-1 B2#15pin@544_polysilicon-1##0 9.743
R3162 B2#15pin@544_polysilicon-1##0 B2#15pin@544_polysilicon-1##1 9.743
R3163 B2#15pin@544_polysilicon-1##1 B2#15pin@544_polysilicon-1##2 9.743
R3164 B2#15pin@544_polysilicon-1##2 B2#15pin@544_polysilicon-1##3 9.743
R3165 B2#15pin@544_polysilicon-1##3 B2#15pin@544_polysilicon-1##4 9.743
R3166 B2#15pin@544_polysilicon-1##4 B2#15pin@544_polysilicon-1##5 9.743
R3167 B2#15pin@544_polysilicon-1##5 B2#1pin@588_metal-2 9.743
R3168 net@1809#7pmos@81_poly-left net@1809#7pmos@81_poly-left##0 7.75
R3169 net@1809#7pmos@81_poly-left##0 net@1809 7.75
R3170 B2#16nmos@82_poly-left B2#16nmos@82_poly-left##0 6.2
R3171 B2#16nmos@82_poly-left##0 B2#14pin@527_polysilicon-1 6.2
R3172 net@1914#9nmos@83_poly-left net@1914#9nmos@83_poly-left##0 8.37
R3173 net@1914#9nmos@83_poly-left##0 net@1914#9nmos@83_poly-left##1 8.37
R3174 net@1914#9nmos@83_poly-left##1 net@1914#9nmos@83_poly-left##2 8.37
R3175 net@1914#9nmos@83_poly-left##2 net@1914#9nmos@83_poly-left##3 8.37
R3176 net@1914#9nmos@83_poly-left##3 net@1914#2contact@579_metal-1-metal-2 8.37
R3177 A2#3pin@547_polysilicon-1 A2#3pin@547_polysilicon-1##0 9.881
R3178 A2#3pin@547_polysilicon-1##0 A2#3pin@547_polysilicon-1##1 9.881
R3179 A2#3pin@547_polysilicon-1##1 A2#3pin@547_polysilicon-1##2 9.881
R3180 A2#3pin@547_polysilicon-1##2 A2#3pin@547_polysilicon-1##3 9.881
R3181 A2#3pin@547_polysilicon-1##3 A2#3pin@547_polysilicon-1##4 9.881
R3182 A2#3pin@547_polysilicon-1##4 A2#3pin@547_polysilicon-1##5 9.881
R3183 A2#3pin@547_polysilicon-1##5 A2#3pin@547_polysilicon-1##6 9.881
R3184 A2#3pin@547_polysilicon-1##6 A2#3pin@547_polysilicon-1##7 9.881
R3185 A2#3pin@547_polysilicon-1##7 A2#3pin@547_polysilicon-1##8 9.881
R3186 A2#3pin@547_polysilicon-1##8 A2#3pin@547_polysilicon-1##9 9.881
R3187 A2#3pin@547_polysilicon-1##9 A2#3pin@547_polysilicon-1##10 9.881
R3188 A2#3pin@547_polysilicon-1##10 A2#3pin@547_polysilicon-1##11 9.881
R3189 A2#3pin@547_polysilicon-1##11 A2#3pin@547_polysilicon-1##12 9.881
R3190 A2#3pin@547_polysilicon-1##12 A2#3pin@547_polysilicon-1##13 9.881
R3191 A2#3pin@547_polysilicon-1##13 A2#3pin@547_polysilicon-1##14 9.881
R3192 A2#3pin@547_polysilicon-1##14 A2#3pin@547_polysilicon-1##15 9.881
R3193 A2#3pin@547_polysilicon-1##15 A2#3pin@547_polysilicon-1##16 9.881
R3194 A2#3pin@547_polysilicon-1##16 A2#3pin@547_polysilicon-1##17 9.881
R3195 A2#3pin@547_polysilicon-1##17 A2#3pin@547_polysilicon-1##18 9.881
R3196 A2#3pin@547_polysilicon-1##18 A2#3pin@547_polysilicon-1##19 9.881
R3197 A2#3pin@547_polysilicon-1##19 A2#3pin@547_polysilicon-1##20 9.881
R3198 A2#3pin@547_polysilicon-1##20 A2#3pin@547_polysilicon-1##21 9.881
R3199 A2#3pin@547_polysilicon-1##21 A2#3pin@547_polysilicon-1##22 9.881
R3200 A2#3pin@547_polysilicon-1##22 A2#3pin@547_polysilicon-1##23 9.881
R3201 A2#3pin@547_polysilicon-1##23 A2#3pin@547_polysilicon-1##24 9.881
R3202 A2#3pin@547_polysilicon-1##24 A2#3pin@547_polysilicon-1##25 9.881
R3203 A2#3pin@547_polysilicon-1##25 A2#3pin@547_polysilicon-1##26 9.881
R3204 A2#3pin@547_polysilicon-1##26 A2#3pin@547_polysilicon-1##27 9.881
R3205 A2#3pin@547_polysilicon-1##27 A2#3pin@547_polysilicon-1##28 9.881
R3206 A2#3pin@547_polysilicon-1##28 A2#3pin@547_polysilicon-1##29 9.881
R3207 A2#3pin@547_polysilicon-1##29 A2#3pin@547_polysilicon-1##30 9.881
R3208 A2#3pin@547_polysilicon-1##30 A2#3pin@547_polysilicon-1##31 9.881
R3209 A2#3pin@547_polysilicon-1##31 A2#3pin@547_polysilicon-1##32 9.881
R3210 A2#3pin@547_polysilicon-1##32 A2#3pin@547_polysilicon-1##33 9.881
R3211 A2#3pin@547_polysilicon-1##33 A2#3pin@547_polysilicon-1##34 9.881
R3212 A2#3pin@547_polysilicon-1##34 A2#3pin@547_polysilicon-1##35 9.881
R3213 A2#3pin@547_polysilicon-1##35 A2#3pin@547_polysilicon-1##36 9.881
R3214 A2#3pin@547_polysilicon-1##36 A2#3pin@547_polysilicon-1##37 9.881
R3215 A2#3pin@547_polysilicon-1##37 A2#3pin@547_polysilicon-1##38 9.881
R3216 A2#3pin@547_polysilicon-1##38 A2#3pin@547_polysilicon-1##39 9.881
R3217 A2#3pin@547_polysilicon-1##39 A2#3pin@547_polysilicon-1##40 9.881
R3218 A2#3pin@547_polysilicon-1##40 A2#3pin@547_polysilicon-1##41 9.881
R3219 A2#3pin@547_polysilicon-1##41 A2#3pin@547_polysilicon-1##42 9.881
R3220 A2#3pin@547_polysilicon-1##42 A2#3pin@547_polysilicon-1##43 9.881
R3221 A2#3pin@547_polysilicon-1##43 A2#3pin@547_polysilicon-1##44 9.881
R3222 A2#3pin@547_polysilicon-1##44 A2#3pin@547_polysilicon-1##45 9.881
R3223 A2#3pin@547_polysilicon-1##45 A2#3pin@547_polysilicon-1##46 9.881
R3224 A2#3pin@547_polysilicon-1##46 A2#3pin@547_polysilicon-1##47 9.881
R3225 A2#3pin@547_polysilicon-1##47 A2#3pin@547_polysilicon-1##48 9.881
R3226 A2#3pin@547_polysilicon-1##48 A2#3pin@547_polysilicon-1##49 9.881
R3227 A2#3pin@547_polysilicon-1##49 A2#3pin@547_polysilicon-1##50 9.881
R3228 A2#3pin@547_polysilicon-1##50 A2#3pin@547_polysilicon-1##51 9.881
R3229 A2#3pin@547_polysilicon-1##51 A2#3pin@547_polysilicon-1##52 9.881
R3230 A2#3pin@547_polysilicon-1##52 A2#3pin@547_polysilicon-1##53 9.881
R3231 A2#3pin@547_polysilicon-1##53 A2#3pin@547_polysilicon-1##54 9.881
R3232 A2#3pin@547_polysilicon-1##54 A2#16nmos@85_poly-right 9.881
R3233 net@1809#5pmos@85_diff-top net@1809#2pin@536_metal-1 4.81
R3234 net@1809#1pin@546_polysilicon-1 net@1809#1pin@546_polysilicon-1##0 9.85
R3235 net@1809#1pin@546_polysilicon-1##0 net@1809#1pin@546_polysilicon-1##1 9.85
R3236 net@1809#1pin@546_polysilicon-1##1 net@1809#1pin@546_polysilicon-1##2 9.85
R3237 net@1809#1pin@546_polysilicon-1##2 net@1809#1pin@546_polysilicon-1##3 9.85
R3238 net@1809#1pin@546_polysilicon-1##3 net@1809#1pin@546_polysilicon-1##4 9.85
R3239 net@1809#1pin@546_polysilicon-1##4 net@1809#1pin@546_polysilicon-1##5 9.85
R3240 net@1809#1pin@546_polysilicon-1##5 net@1809#1pin@546_polysilicon-1##6 9.85
R3241 net@1809#1pin@546_polysilicon-1##6 net@1809#1pin@546_polysilicon-1##7 9.85
R3242 net@1809#1pin@546_polysilicon-1##7 net@1809#1pin@546_polysilicon-1##8 9.85
R3243 net@1809#1pin@546_polysilicon-1##8 net@1809#1pin@546_polysilicon-1##9 9.85
R3244 net@1809#1pin@546_polysilicon-1##9 net@1809#1pin@546_polysilicon-1##10 9.85
R3245 net@1809#1pin@546_polysilicon-1##10 net@1809#1pin@546_polysilicon-1##11 9.85
R3246 net@1809#1pin@546_polysilicon-1##11 net@1809#1pin@546_polysilicon-1##12 9.85
R3247 net@1809#1pin@546_polysilicon-1##12 net@1809#1pin@546_polysilicon-1##13 9.85
R3248 net@1809#1pin@546_polysilicon-1##13 net@1809#1pin@546_polysilicon-1##14 9.85
R3249 net@1809#1pin@546_polysilicon-1##14 net@1809#1pin@546_polysilicon-1##15 9.85
R3250 net@1809#1pin@546_polysilicon-1##15 net@1809#1pin@546_polysilicon-1##16 9.85
R3251 net@1809#1pin@546_polysilicon-1##16 net@1809#1pin@546_polysilicon-1##17 9.85
R3252 net@1809#1pin@546_polysilicon-1##17 net@1809#1pin@546_polysilicon-1##18 9.85
R3253 net@1809#1pin@546_polysilicon-1##18 net@1809#1pin@546_polysilicon-1##19 9.85
R3254 net@1809#1pin@546_polysilicon-1##19 net@1809#1pin@546_polysilicon-1##20 9.85
R3255 net@1809#1pin@546_polysilicon-1##20 net@1809#1pin@546_polysilicon-1##21 9.85
R3256 net@1809#1pin@546_polysilicon-1##21 net@1809#1pin@546_polysilicon-1##22 9.85
R3257 net@1809#1pin@546_polysilicon-1##22 net@1809#1pin@546_polysilicon-1##23 9.85
R3258 net@1809#1pin@546_polysilicon-1##23 net@1809#1pin@546_polysilicon-1##24 9.85
R3259 net@1809#1pin@546_polysilicon-1##24 net@1809#1pin@546_polysilicon-1##25 9.85
R3260 net@1809#1pin@546_polysilicon-1##25 net@1809#1pin@546_polysilicon-1##26 9.85
R3261 net@1809#1pin@546_polysilicon-1##26 net@1809#1pin@546_polysilicon-1##27 9.85
R3262 net@1809#1pin@546_polysilicon-1##27 net@1809#1pin@546_polysilicon-1##28 9.85
R3263 net@1809#1pin@546_polysilicon-1##28 net@1809#1pin@546_polysilicon-1##29 9.85
R3264 net@1809#1pin@546_polysilicon-1##29 net@1809#1pin@546_polysilicon-1##30 9.85
R3265 net@1809#1pin@546_polysilicon-1##30 net@1809#1pin@546_polysilicon-1##31 9.85
R3266 net@1809#1pin@546_polysilicon-1##31 net@1809#1pin@546_polysilicon-1##32 9.85
R3267 net@1809#1pin@546_polysilicon-1##32 net@1809#1pin@546_polysilicon-1##33 9.85
R3268 net@1809#1pin@546_polysilicon-1##33 net@1809#1pin@546_polysilicon-1##34 9.85
R3269 net@1809#1pin@546_polysilicon-1##34 net@1809#1pin@546_polysilicon-1##35 9.85
R3270 net@1809#1pin@546_polysilicon-1##35 net@1809#1pin@546_polysilicon-1##36 9.85
R3271 net@1809#1pin@546_polysilicon-1##36 net@1809#1pin@546_polysilicon-1##37 9.85
R3272 net@1809#1pin@546_polysilicon-1##37 net@1809#1pin@546_polysilicon-1##38 9.85
R3273 net@1809#1pin@546_polysilicon-1##38 net@1809#1pin@546_polysilicon-1##39 9.85
R3274 net@1809#1pin@546_polysilicon-1##39 net@1809#1pin@546_polysilicon-1##40 9.85
R3275 net@1809#1pin@546_polysilicon-1##40 net@1809#1pin@546_polysilicon-1##41 9.85
R3276 net@1809#1pin@546_polysilicon-1##41 net@1809#1pin@546_polysilicon-1##42 9.85
R3277 net@1809#1pin@546_polysilicon-1##42 net@1809#1pin@546_polysilicon-1##43 9.85
R3278 net@1809#1pin@546_polysilicon-1##43 net@1809#1pin@546_polysilicon-1##44 9.85
R3279 net@1809#1pin@546_polysilicon-1##44 net@1809#1pin@546_polysilicon-1##45 9.85
R3280 net@1809#1pin@546_polysilicon-1##45 net@1809#1pin@546_polysilicon-1##46 9.85
R3281 net@1809#1pin@546_polysilicon-1##46 net@1809#1pin@546_polysilicon-1##47 9.85
R3282 net@1809#1pin@546_polysilicon-1##47 net@1809#1pin@546_polysilicon-1##48 9.85
R3283 net@1809#1pin@546_polysilicon-1##48 net@1809#1pin@546_polysilicon-1##49 9.85
R3284 net@1809#1pin@546_polysilicon-1##49 net@1809#1pin@546_polysilicon-1##50 9.85
R3285 net@1809#1pin@546_polysilicon-1##50 net@1809#1pin@546_polysilicon-1##51 9.85
R3286 net@1809#1pin@546_polysilicon-1##51 net@1809#1pin@546_polysilicon-1##52 9.85
R3287 net@1809#1pin@546_polysilicon-1##52 net@1809#1pin@546_polysilicon-1##53 9.85
R3288 net@1809#1pin@546_polysilicon-1##53 net@1809#1pin@546_polysilicon-1##54 9.85
R3289 net@1809#1pin@546_polysilicon-1##54 net@1809#1pin@546_polysilicon-1##55 9.85
R3290 net@1809#1pin@546_polysilicon-1##55 net@1809#1pin@546_polysilicon-1##56 9.85
R3291 net@1809#1pin@546_polysilicon-1##56 net@1809#1pin@546_polysilicon-1##57 9.85
R3292 net@1809#1pin@546_polysilicon-1##57 net@1809#1pin@546_polysilicon-1##58 9.85
R3293 net@1809#1pin@546_polysilicon-1##58 net@1809#1pin@546_polysilicon-1##59 9.85
R3294 net@1809#1pin@546_polysilicon-1##59 net@1809#1pin@546_polysilicon-1##60 9.85
R3295 net@1809#1pin@546_polysilicon-1##60 net@1809#2pin@536_metal-1 9.85
R3296 B2#17pmos@84_poly-right B2#17pmos@84_poly-right##0 9.854
R3297 B2#17pmos@84_poly-right##0 B2#17pmos@84_poly-right##1 9.854
R3298 B2#17pmos@84_poly-right##1 B2#17pmos@84_poly-right##2 9.854
R3299 B2#17pmos@84_poly-right##2 B2#17pmos@84_poly-right##3 9.854
R3300 B2#17pmos@84_poly-right##3 B2#17pmos@84_poly-right##4 9.854
R3301 B2#17pmos@84_poly-right##4 B2#17pmos@84_poly-right##5 9.854
R3302 B2#17pmos@84_poly-right##5 B2#17pmos@84_poly-right##6 9.854
R3303 B2#17pmos@84_poly-right##6 B2#17pmos@84_poly-right##7 9.854
R3304 B2#17pmos@84_poly-right##7 B2#17pmos@84_poly-right##8 9.854
R3305 B2#17pmos@84_poly-right##8 B2#17pmos@84_poly-right##9 9.854
R3306 B2#17pmos@84_poly-right##9 B2#17pmos@84_poly-right##10 9.854
R3307 B2#17pmos@84_poly-right##10 B2#17pmos@84_poly-right##11 9.854
R3308 B2#17pmos@84_poly-right##11 B2#17pmos@84_poly-right##12 9.854
R3309 B2#17pmos@84_poly-right##12 B2#17pmos@84_poly-right##13 9.854
R3310 B2#17pmos@84_poly-right##13 B2#17pmos@84_poly-right##14 9.854
R3311 B2#17pmos@84_poly-right##14 B2#17pmos@84_poly-right##15 9.854
R3312 B2#17pmos@84_poly-right##15 B2#17pmos@84_poly-right##16 9.854
R3313 B2#17pmos@84_poly-right##16 B2#17pmos@84_poly-right##17 9.854
R3314 B2#17pmos@84_poly-right##17 B2#17pmos@84_poly-right##18 9.854
R3315 B2#17pmos@84_poly-right##18 B2#17pmos@84_poly-right##19 9.854
R3316 B2#17pmos@84_poly-right##19 B2#17pmos@84_poly-right##20 9.854
R3317 B2#17pmos@84_poly-right##20 B2#17pmos@84_poly-right##21 9.854
R3318 B2#17pmos@84_poly-right##21 B2#17pmos@84_poly-right##22 9.854
R3319 B2#17pmos@84_poly-right##22 B2#17pmos@84_poly-right##23 9.854
R3320 B2#17pmos@84_poly-right##23 B2#17pmos@84_poly-right##24 9.854
R3321 B2#17pmos@84_poly-right##24 B2#17pmos@84_poly-right##25 9.854
R3322 B2#17pmos@84_poly-right##25 B2#17pmos@84_poly-right##26 9.854
R3323 B2#17pmos@84_poly-right##26 B2#17pmos@84_poly-right##27 9.854
R3324 B2#17pmos@84_poly-right##27 B2#17pmos@84_poly-right##28 9.854
R3325 B2#17pmos@84_poly-right##28 B2#17pmos@84_poly-right##29 9.854
R3326 B2#17pmos@84_poly-right##29 B2#17pmos@84_poly-right##30 9.854
R3327 B2#17pmos@84_poly-right##30 B2#17pmos@84_poly-right##31 9.854
R3328 B2#17pmos@84_poly-right##31 B2#17pmos@84_poly-right##32 9.854
R3329 B2#17pmos@84_poly-right##32 B2#17pmos@84_poly-right##33 9.854
R3330 B2#17pmos@84_poly-right##33 B2#17pmos@84_poly-right##34 9.854
R3331 B2#17pmos@84_poly-right##34 B2#17pmos@84_poly-right##35 9.854
R3332 B2#17pmos@84_poly-right##35 B2#17pmos@84_poly-right##36 9.854
R3333 B2#17pmos@84_poly-right##36 B2#17pmos@84_poly-right##37 9.854
R3334 B2#17pmos@84_poly-right##37 B2#17pmos@84_poly-right##38 9.854
R3335 B2#17pmos@84_poly-right##38 B2#17pmos@84_poly-right##39 9.854
R3336 B2#17pmos@84_poly-right##39 B2#17pmos@84_poly-right##40 9.854
R3337 B2#17pmos@84_poly-right##40 B2#17pmos@84_poly-right##41 9.854
R3338 B2#17pmos@84_poly-right##41 B2#17pmos@84_poly-right##42 9.854
R3339 B2#17pmos@84_poly-right##42 B2#17pmos@84_poly-right##43 9.854
R3340 B2#17pmos@84_poly-right##43 B2#17pmos@84_poly-right##44 9.854
R3341 B2#17pmos@84_poly-right##44 B2#17pmos@84_poly-right##45 9.854
R3342 B2#17pmos@84_poly-right##45 B2#17pmos@84_poly-right##46 9.854
R3343 B2#17pmos@84_poly-right##46 B2#17pmos@84_poly-right##47 9.854
R3344 B2#17pmos@84_poly-right##47 B2#17pmos@84_poly-right##48 9.854
R3345 B2#17pmos@84_poly-right##48 B2#17pmos@84_poly-right##49 9.854
R3346 B2#17pmos@84_poly-right##49 B2#17pmos@84_poly-right##50 9.854
R3347 B2#17pmos@84_poly-right##50 B2#17pmos@84_poly-right##51 9.854
R3348 B2#17pmos@84_poly-right##51 B2#17pmos@84_poly-right##52 9.854
R3349 B2#17pmos@84_poly-right##52 B2#17pmos@84_poly-right##53 9.854
R3350 B2#17pmos@84_poly-right##53 B2#17pmos@84_poly-right##54 9.854
R3351 B2#17pmos@84_poly-right##54 B2#12pin@537_polysilicon-1 9.854
R3352 net@1914 net@1914#2contact@579_metal-1-metal-2 4.797
R3353 A2#17nmos@80_poly-right A2#17nmos@80_poly-right##0 9.871
R3354 A2#17nmos@80_poly-right##0 A2#17nmos@80_poly-right##1 9.871
R3355 A2#17nmos@80_poly-right##1 A2#17nmos@80_poly-right##2 9.871
R3356 A2#17nmos@80_poly-right##2 A2#17nmos@80_poly-right##3 9.871
R3357 A2#17nmos@80_poly-right##3 A2#17nmos@80_poly-right##4 9.871
R3358 A2#17nmos@80_poly-right##4 A2#17nmos@80_poly-right##5 9.871
R3359 A2#17nmos@80_poly-right##5 A2#17nmos@80_poly-right##6 9.871
R3360 A2#17nmos@80_poly-right##6 A2#17nmos@80_poly-right##7 9.871
R3361 A2#17nmos@80_poly-right##7 A2#17nmos@80_poly-right##8 9.871
R3362 A2#17nmos@80_poly-right##8 A2#17nmos@80_poly-right##9 9.871
R3363 A2#17nmos@80_poly-right##9 A2#17nmos@80_poly-right##10 9.871
R3364 A2#17nmos@80_poly-right##10 A2#17nmos@80_poly-right##11 9.871
R3365 A2#17nmos@80_poly-right##11 A2#17nmos@80_poly-right##12 9.871
R3366 A2#17nmos@80_poly-right##12 A2#17nmos@80_poly-right##13 9.871
R3367 A2#17nmos@80_poly-right##13 A2#17nmos@80_poly-right##14 9.871
R3368 A2#17nmos@80_poly-right##14 A2#17nmos@80_poly-right##15 9.871
R3369 A2#17nmos@80_poly-right##15 A2#17nmos@80_poly-right##16 9.871
R3370 A2#17nmos@80_poly-right##16 A2#17nmos@80_poly-right##17 9.871
R3371 A2#17nmos@80_poly-right##17 A2#17nmos@80_poly-right##18 9.871
R3372 A2#17nmos@80_poly-right##18 A2#17nmos@80_poly-right##19 9.871
R3373 A2#17nmos@80_poly-right##19 A2#17nmos@80_poly-right##20 9.871
R3374 A2#17nmos@80_poly-right##20 A2#17nmos@80_poly-right##21 9.871
R3375 A2#17nmos@80_poly-right##21 A2#17nmos@80_poly-right##22 9.871
R3376 A2#17nmos@80_poly-right##22 A2#17nmos@80_poly-right##23 9.871
R3377 A2#17nmos@80_poly-right##23 A2#17nmos@80_poly-right##24 9.871
R3378 A2#17nmos@80_poly-right##24 A2#17nmos@80_poly-right##25 9.871
R3379 A2#17nmos@80_poly-right##25 A2#17nmos@80_poly-right##26 9.871
R3380 A2#17nmos@80_poly-right##26 A2#17nmos@80_poly-right##27 9.871
R3381 A2#17nmos@80_poly-right##27 A2#17nmos@80_poly-right##28 9.871
R3382 A2#17nmos@80_poly-right##28 A2#17nmos@80_poly-right##29 9.871
R3383 A2#17nmos@80_poly-right##29 A2#17nmos@80_poly-right##30 9.871
R3384 A2#17nmos@80_poly-right##30 A2#17nmos@80_poly-right##31 9.871
R3385 A2#17nmos@80_poly-right##31 A2#17nmos@80_poly-right##32 9.871
R3386 A2#17nmos@80_poly-right##32 A2#17nmos@80_poly-right##33 9.871
R3387 A2#17nmos@80_poly-right##33 A2#17nmos@80_poly-right##34 9.871
R3388 A2#17nmos@80_poly-right##34 A2#17nmos@80_poly-right##35 9.871
R3389 A2#17nmos@80_poly-right##35 A2#17nmos@80_poly-right##36 9.871
R3390 A2#17nmos@80_poly-right##36 A2#17nmos@80_poly-right##37 9.871
R3391 A2#17nmos@80_poly-right##37 A2#17nmos@80_poly-right##38 9.871
R3392 A2#17nmos@80_poly-right##38 A2#17nmos@80_poly-right##39 9.871
R3393 A2#17nmos@80_poly-right##39 A2#17nmos@80_poly-right##40 9.871
R3394 A2#17nmos@80_poly-right##40 A2#17nmos@80_poly-right##41 9.871
R3395 A2#17nmos@80_poly-right##41 A2#17nmos@80_poly-right##42 9.871
R3396 A2#17nmos@80_poly-right##42 A2#17nmos@80_poly-right##43 9.871
R3397 A2#17nmos@80_poly-right##43 A2#17nmos@80_poly-right##44 9.871
R3398 A2#17nmos@80_poly-right##44 A2#17nmos@80_poly-right##45 9.871
R3399 A2#17nmos@80_poly-right##45 A2#17nmos@80_poly-right##46 9.871
R3400 A2#17nmos@80_poly-right##46 A2#17nmos@80_poly-right##47 9.871
R3401 A2#17nmos@80_poly-right##47 A2#17nmos@80_poly-right##48 9.871
R3402 A2#17nmos@80_poly-right##48 A2#17nmos@80_poly-right##49 9.871
R3403 A2#17nmos@80_poly-right##49 A2#17nmos@80_poly-right##50 9.871
R3404 A2#17nmos@80_poly-right##50 A2#17nmos@80_poly-right##51 9.871
R3405 A2#17nmos@80_poly-right##51 A2#17nmos@80_poly-right##52 9.871
R3406 A2#17nmos@80_poly-right##52 A2#17nmos@80_poly-right##53 9.871
R3407 A2#17nmos@80_poly-right##53 A2#17nmos@80_poly-right##54 9.871
R3408 A2#17nmos@80_poly-right##54 A2#17nmos@80_poly-right##55 9.871
R3409 A2#17nmos@80_poly-right##55 A2#12pmos@80_poly-left 9.871
R3410 net@1809#7pmos@81_poly-left net@1809#7pmos@81_poly-left##0 9.871
R3411 net@1809#7pmos@81_poly-left##0 net@1809#7pmos@81_poly-left##1 9.871
R3412 net@1809#7pmos@81_poly-left##1 net@1809#7pmos@81_poly-left##2 9.871
R3413 net@1809#7pmos@81_poly-left##2 net@1809#7pmos@81_poly-left##3 9.871
R3414 net@1809#7pmos@81_poly-left##3 net@1809#7pmos@81_poly-left##4 9.871
R3415 net@1809#7pmos@81_poly-left##4 net@1809#7pmos@81_poly-left##5 9.871
R3416 net@1809#7pmos@81_poly-left##5 net@1809#7pmos@81_poly-left##6 9.871
R3417 net@1809#7pmos@81_poly-left##6 net@1809#7pmos@81_poly-left##7 9.871
R3418 net@1809#7pmos@81_poly-left##7 net@1809#7pmos@81_poly-left##8 9.871
R3419 net@1809#7pmos@81_poly-left##8 net@1809#7pmos@81_poly-left##9 9.871
R3420 net@1809#7pmos@81_poly-left##9 net@1809#7pmos@81_poly-left##10 9.871
R3421 net@1809#7pmos@81_poly-left##10 net@1809#7pmos@81_poly-left##11 9.871
R3422 net@1809#7pmos@81_poly-left##11 net@1809#7pmos@81_poly-left##12 9.871
R3423 net@1809#7pmos@81_poly-left##12 net@1809#7pmos@81_poly-left##13 9.871
R3424 net@1809#7pmos@81_poly-left##13 net@1809#7pmos@81_poly-left##14 9.871
R3425 net@1809#7pmos@81_poly-left##14 net@1809#7pmos@81_poly-left##15 9.871
R3426 net@1809#7pmos@81_poly-left##15 net@1809#7pmos@81_poly-left##16 9.871
R3427 net@1809#7pmos@81_poly-left##16 net@1809#7pmos@81_poly-left##17 9.871
R3428 net@1809#7pmos@81_poly-left##17 net@1809#7pmos@81_poly-left##18 9.871
R3429 net@1809#7pmos@81_poly-left##18 net@1809#7pmos@81_poly-left##19 9.871
R3430 net@1809#7pmos@81_poly-left##19 net@1809#7pmos@81_poly-left##20 9.871
R3431 net@1809#7pmos@81_poly-left##20 net@1809#7pmos@81_poly-left##21 9.871
R3432 net@1809#7pmos@81_poly-left##21 net@1809#7pmos@81_poly-left##22 9.871
R3433 net@1809#7pmos@81_poly-left##22 net@1809#7pmos@81_poly-left##23 9.871
R3434 net@1809#7pmos@81_poly-left##23 net@1809#7pmos@81_poly-left##24 9.871
R3435 net@1809#7pmos@81_poly-left##24 net@1809#7pmos@81_poly-left##25 9.871
R3436 net@1809#7pmos@81_poly-left##25 net@1809#7pmos@81_poly-left##26 9.871
R3437 net@1809#7pmos@81_poly-left##26 net@1809#7pmos@81_poly-left##27 9.871
R3438 net@1809#7pmos@81_poly-left##27 net@1809#7pmos@81_poly-left##28 9.871
R3439 net@1809#7pmos@81_poly-left##28 net@1809#7pmos@81_poly-left##29 9.871
R3440 net@1809#7pmos@81_poly-left##29 net@1809#7pmos@81_poly-left##30 9.871
R3441 net@1809#7pmos@81_poly-left##30 net@1809#7pmos@81_poly-left##31 9.871
R3442 net@1809#7pmos@81_poly-left##31 net@1809#7pmos@81_poly-left##32 9.871
R3443 net@1809#7pmos@81_poly-left##32 net@1809#7pmos@81_poly-left##33 9.871
R3444 net@1809#7pmos@81_poly-left##33 net@1809#7pmos@81_poly-left##34 9.871
R3445 net@1809#7pmos@81_poly-left##34 net@1809#7pmos@81_poly-left##35 9.871
R3446 net@1809#7pmos@81_poly-left##35 net@1809#7pmos@81_poly-left##36 9.871
R3447 net@1809#7pmos@81_poly-left##36 net@1809#7pmos@81_poly-left##37 9.871
R3448 net@1809#7pmos@81_poly-left##37 net@1809#7pmos@81_poly-left##38 9.871
R3449 net@1809#7pmos@81_poly-left##38 net@1809#7pmos@81_poly-left##39 9.871
R3450 net@1809#7pmos@81_poly-left##39 net@1809#7pmos@81_poly-left##40 9.871
R3451 net@1809#7pmos@81_poly-left##40 net@1809#7pmos@81_poly-left##41 9.871
R3452 net@1809#7pmos@81_poly-left##41 net@1809#7pmos@81_poly-left##42 9.871
R3453 net@1809#7pmos@81_poly-left##42 net@1809#7pmos@81_poly-left##43 9.871
R3454 net@1809#7pmos@81_poly-left##43 net@1809#7pmos@81_poly-left##44 9.871
R3455 net@1809#7pmos@81_poly-left##44 net@1809#7pmos@81_poly-left##45 9.871
R3456 net@1809#7pmos@81_poly-left##45 net@1809#7pmos@81_poly-left##46 9.871
R3457 net@1809#7pmos@81_poly-left##46 net@1809#7pmos@81_poly-left##47 9.871
R3458 net@1809#7pmos@81_poly-left##47 net@1809#7pmos@81_poly-left##48 9.871
R3459 net@1809#7pmos@81_poly-left##48 net@1809#7pmos@81_poly-left##49 9.871
R3460 net@1809#7pmos@81_poly-left##49 net@1809#7pmos@81_poly-left##50 9.871
R3461 net@1809#7pmos@81_poly-left##50 net@1809#7pmos@81_poly-left##51 9.871
R3462 net@1809#7pmos@81_poly-left##51 net@1809#7pmos@81_poly-left##52 9.871
R3463 net@1809#7pmos@81_poly-left##52 net@1809#7pmos@81_poly-left##53 9.871
R3464 net@1809#7pmos@81_poly-left##53 net@1809#7pmos@81_poly-left##54 9.871
R3465 net@1809#7pmos@81_poly-left##54 net@1809#7pmos@81_poly-left##55 9.871
R3466 net@1809#7pmos@81_poly-left##55 net@1809#11nmos@81_poly-right 9.871
R3467 B2#18pmos@82_poly-right B2#18pmos@82_poly-right##0 9.871
R3468 B2#18pmos@82_poly-right##0 B2#18pmos@82_poly-right##1 9.871
R3469 B2#18pmos@82_poly-right##1 B2#18pmos@82_poly-right##2 9.871
R3470 B2#18pmos@82_poly-right##2 B2#18pmos@82_poly-right##3 9.871
R3471 B2#18pmos@82_poly-right##3 B2#18pmos@82_poly-right##4 9.871
R3472 B2#18pmos@82_poly-right##4 B2#18pmos@82_poly-right##5 9.871
R3473 B2#18pmos@82_poly-right##5 B2#18pmos@82_poly-right##6 9.871
R3474 B2#18pmos@82_poly-right##6 B2#18pmos@82_poly-right##7 9.871
R3475 B2#18pmos@82_poly-right##7 B2#18pmos@82_poly-right##8 9.871
R3476 B2#18pmos@82_poly-right##8 B2#18pmos@82_poly-right##9 9.871
R3477 B2#18pmos@82_poly-right##9 B2#18pmos@82_poly-right##10 9.871
R3478 B2#18pmos@82_poly-right##10 B2#18pmos@82_poly-right##11 9.871
R3479 B2#18pmos@82_poly-right##11 B2#18pmos@82_poly-right##12 9.871
R3480 B2#18pmos@82_poly-right##12 B2#18pmos@82_poly-right##13 9.871
R3481 B2#18pmos@82_poly-right##13 B2#18pmos@82_poly-right##14 9.871
R3482 B2#18pmos@82_poly-right##14 B2#18pmos@82_poly-right##15 9.871
R3483 B2#18pmos@82_poly-right##15 B2#18pmos@82_poly-right##16 9.871
R3484 B2#18pmos@82_poly-right##16 B2#18pmos@82_poly-right##17 9.871
R3485 B2#18pmos@82_poly-right##17 B2#18pmos@82_poly-right##18 9.871
R3486 B2#18pmos@82_poly-right##18 B2#18pmos@82_poly-right##19 9.871
R3487 B2#18pmos@82_poly-right##19 B2#18pmos@82_poly-right##20 9.871
R3488 B2#18pmos@82_poly-right##20 B2#18pmos@82_poly-right##21 9.871
R3489 B2#18pmos@82_poly-right##21 B2#18pmos@82_poly-right##22 9.871
R3490 B2#18pmos@82_poly-right##22 B2#18pmos@82_poly-right##23 9.871
R3491 B2#18pmos@82_poly-right##23 B2#18pmos@82_poly-right##24 9.871
R3492 B2#18pmos@82_poly-right##24 B2#18pmos@82_poly-right##25 9.871
R3493 B2#18pmos@82_poly-right##25 B2#18pmos@82_poly-right##26 9.871
R3494 B2#18pmos@82_poly-right##26 B2#18pmos@82_poly-right##27 9.871
R3495 B2#18pmos@82_poly-right##27 B2#18pmos@82_poly-right##28 9.871
R3496 B2#18pmos@82_poly-right##28 B2#18pmos@82_poly-right##29 9.871
R3497 B2#18pmos@82_poly-right##29 B2#18pmos@82_poly-right##30 9.871
R3498 B2#18pmos@82_poly-right##30 B2#18pmos@82_poly-right##31 9.871
R3499 B2#18pmos@82_poly-right##31 B2#18pmos@82_poly-right##32 9.871
R3500 B2#18pmos@82_poly-right##32 B2#18pmos@82_poly-right##33 9.871
R3501 B2#18pmos@82_poly-right##33 B2#18pmos@82_poly-right##34 9.871
R3502 B2#18pmos@82_poly-right##34 B2#18pmos@82_poly-right##35 9.871
R3503 B2#18pmos@82_poly-right##35 B2#18pmos@82_poly-right##36 9.871
R3504 B2#18pmos@82_poly-right##36 B2#18pmos@82_poly-right##37 9.871
R3505 B2#18pmos@82_poly-right##37 B2#18pmos@82_poly-right##38 9.871
R3506 B2#18pmos@82_poly-right##38 B2#18pmos@82_poly-right##39 9.871
R3507 B2#18pmos@82_poly-right##39 B2#18pmos@82_poly-right##40 9.871
R3508 B2#18pmos@82_poly-right##40 B2#18pmos@82_poly-right##41 9.871
R3509 B2#18pmos@82_poly-right##41 B2#18pmos@82_poly-right##42 9.871
R3510 B2#18pmos@82_poly-right##42 B2#18pmos@82_poly-right##43 9.871
R3511 B2#18pmos@82_poly-right##43 B2#18pmos@82_poly-right##44 9.871
R3512 B2#18pmos@82_poly-right##44 B2#18pmos@82_poly-right##45 9.871
R3513 B2#18pmos@82_poly-right##45 B2#18pmos@82_poly-right##46 9.871
R3514 B2#18pmos@82_poly-right##46 B2#18pmos@82_poly-right##47 9.871
R3515 B2#18pmos@82_poly-right##47 B2#18pmos@82_poly-right##48 9.871
R3516 B2#18pmos@82_poly-right##48 B2#18pmos@82_poly-right##49 9.871
R3517 B2#18pmos@82_poly-right##49 B2#18pmos@82_poly-right##50 9.871
R3518 B2#18pmos@82_poly-right##50 B2#18pmos@82_poly-right##51 9.871
R3519 B2#18pmos@82_poly-right##51 B2#18pmos@82_poly-right##52 9.871
R3520 B2#18pmos@82_poly-right##52 B2#18pmos@82_poly-right##53 9.871
R3521 B2#18pmos@82_poly-right##53 B2#18pmos@82_poly-right##54 9.871
R3522 B2#18pmos@82_poly-right##54 B2#18pmos@82_poly-right##55 9.871
R3523 B2#18pmos@82_poly-right##55 B2#16nmos@82_poly-left 9.871
R3524 net@1914#14pmos@83_poly-right net@1914#14pmos@83_poly-right##0 9.871
R3525 net@1914#14pmos@83_poly-right##0 net@1914#14pmos@83_poly-right##1 9.871
R3526 net@1914#14pmos@83_poly-right##1 net@1914#14pmos@83_poly-right##2 9.871
R3527 net@1914#14pmos@83_poly-right##2 net@1914#14pmos@83_poly-right##3 9.871
R3528 net@1914#14pmos@83_poly-right##3 net@1914#14pmos@83_poly-right##4 9.871
R3529 net@1914#14pmos@83_poly-right##4 net@1914#14pmos@83_poly-right##5 9.871
R3530 net@1914#14pmos@83_poly-right##5 net@1914#14pmos@83_poly-right##6 9.871
R3531 net@1914#14pmos@83_poly-right##6 net@1914#14pmos@83_poly-right##7 9.871
R3532 net@1914#14pmos@83_poly-right##7 net@1914#14pmos@83_poly-right##8 9.871
R3533 net@1914#14pmos@83_poly-right##8 net@1914#14pmos@83_poly-right##9 9.871
R3534 net@1914#14pmos@83_poly-right##9 net@1914#14pmos@83_poly-right##10 9.871
R3535 net@1914#14pmos@83_poly-right##10 net@1914#14pmos@83_poly-right##11 9.871
R3536 net@1914#14pmos@83_poly-right##11 net@1914#14pmos@83_poly-right##12 9.871
R3537 net@1914#14pmos@83_poly-right##12 net@1914#14pmos@83_poly-right##13 9.871
R3538 net@1914#14pmos@83_poly-right##13 net@1914#14pmos@83_poly-right##14 9.871
R3539 net@1914#14pmos@83_poly-right##14 net@1914#14pmos@83_poly-right##15 9.871
R3540 net@1914#14pmos@83_poly-right##15 net@1914#14pmos@83_poly-right##16 9.871
R3541 net@1914#14pmos@83_poly-right##16 net@1914#14pmos@83_poly-right##17 9.871
R3542 net@1914#14pmos@83_poly-right##17 net@1914#14pmos@83_poly-right##18 9.871
R3543 net@1914#14pmos@83_poly-right##18 net@1914#14pmos@83_poly-right##19 9.871
R3544 net@1914#14pmos@83_poly-right##19 net@1914#14pmos@83_poly-right##20 9.871
R3545 net@1914#14pmos@83_poly-right##20 net@1914#14pmos@83_poly-right##21 9.871
R3546 net@1914#14pmos@83_poly-right##21 net@1914#14pmos@83_poly-right##22 9.871
R3547 net@1914#14pmos@83_poly-right##22 net@1914#14pmos@83_poly-right##23 9.871
R3548 net@1914#14pmos@83_poly-right##23 net@1914#14pmos@83_poly-right##24 9.871
R3549 net@1914#14pmos@83_poly-right##24 net@1914#14pmos@83_poly-right##25 9.871
R3550 net@1914#14pmos@83_poly-right##25 net@1914#14pmos@83_poly-right##26 9.871
R3551 net@1914#14pmos@83_poly-right##26 net@1914#14pmos@83_poly-right##27 9.871
R3552 net@1914#14pmos@83_poly-right##27 net@1914#14pmos@83_poly-right##28 9.871
R3553 net@1914#14pmos@83_poly-right##28 net@1914#14pmos@83_poly-right##29 9.871
R3554 net@1914#14pmos@83_poly-right##29 net@1914#14pmos@83_poly-right##30 9.871
R3555 net@1914#14pmos@83_poly-right##30 net@1914#14pmos@83_poly-right##31 9.871
R3556 net@1914#14pmos@83_poly-right##31 net@1914#14pmos@83_poly-right##32 9.871
R3557 net@1914#14pmos@83_poly-right##32 net@1914#14pmos@83_poly-right##33 9.871
R3558 net@1914#14pmos@83_poly-right##33 net@1914#14pmos@83_poly-right##34 9.871
R3559 net@1914#14pmos@83_poly-right##34 net@1914#14pmos@83_poly-right##35 9.871
R3560 net@1914#14pmos@83_poly-right##35 net@1914#14pmos@83_poly-right##36 9.871
R3561 net@1914#14pmos@83_poly-right##36 net@1914#14pmos@83_poly-right##37 9.871
R3562 net@1914#14pmos@83_poly-right##37 net@1914#14pmos@83_poly-right##38 9.871
R3563 net@1914#14pmos@83_poly-right##38 net@1914#14pmos@83_poly-right##39 9.871
R3564 net@1914#14pmos@83_poly-right##39 net@1914#14pmos@83_poly-right##40 9.871
R3565 net@1914#14pmos@83_poly-right##40 net@1914#14pmos@83_poly-right##41 9.871
R3566 net@1914#14pmos@83_poly-right##41 net@1914#14pmos@83_poly-right##42 9.871
R3567 net@1914#14pmos@83_poly-right##42 net@1914#14pmos@83_poly-right##43 9.871
R3568 net@1914#14pmos@83_poly-right##43 net@1914#14pmos@83_poly-right##44 9.871
R3569 net@1914#14pmos@83_poly-right##44 net@1914#14pmos@83_poly-right##45 9.871
R3570 net@1914#14pmos@83_poly-right##45 net@1914#14pmos@83_poly-right##46 9.871
R3571 net@1914#14pmos@83_poly-right##46 net@1914#14pmos@83_poly-right##47 9.871
R3572 net@1914#14pmos@83_poly-right##47 net@1914#14pmos@83_poly-right##48 9.871
R3573 net@1914#14pmos@83_poly-right##48 net@1914#14pmos@83_poly-right##49 9.871
R3574 net@1914#14pmos@83_poly-right##49 net@1914#14pmos@83_poly-right##50 9.871
R3575 net@1914#14pmos@83_poly-right##50 net@1914#14pmos@83_poly-right##51 9.871
R3576 net@1914#14pmos@83_poly-right##51 net@1914#14pmos@83_poly-right##52 9.871
R3577 net@1914#14pmos@83_poly-right##52 net@1914#14pmos@83_poly-right##53 9.871
R3578 net@1914#14pmos@83_poly-right##53 net@1914#14pmos@83_poly-right##54 9.871
R3579 net@1914#14pmos@83_poly-right##54 net@1914#14pmos@83_poly-right##55 9.871
R3580 net@1914#14pmos@83_poly-right##55 net@1914#9nmos@83_poly-left 9.871
R3581 net@1907#2contact@603_metal-1-polysilicon-1 net@1907 4.706
R3582 net@1907#12pmos@86_poly-right net@1907#12pmos@86_poly-right##0 9.864
R3583 net@1907#12pmos@86_poly-right##0 net@1907#12pmos@86_poly-right##1 9.864
R3584 net@1907#12pmos@86_poly-right##1 net@1907#12pmos@86_poly-right##2 9.864
R3585 net@1907#12pmos@86_poly-right##2 net@1907#12pmos@86_poly-right##3 9.864
R3586 net@1907#12pmos@86_poly-right##3 net@1907#12pmos@86_poly-right##4 9.864
R3587 net@1907#12pmos@86_poly-right##4 net@1907#12pmos@86_poly-right##5 9.864
R3588 net@1907#12pmos@86_poly-right##5 net@1907#12pmos@86_poly-right##6 9.864
R3589 net@1907#12pmos@86_poly-right##6 net@1907#12pmos@86_poly-right##7 9.864
R3590 net@1907#12pmos@86_poly-right##7 net@1907#12pmos@86_poly-right##8 9.864
R3591 net@1907#12pmos@86_poly-right##8 net@1907#12pmos@86_poly-right##9 9.864
R3592 net@1907#12pmos@86_poly-right##9 net@1907#12pmos@86_poly-right##10 9.864
R3593 net@1907#12pmos@86_poly-right##10 net@1907#12pmos@86_poly-right##11 9.864
R3594 net@1907#12pmos@86_poly-right##11 net@1907#12pmos@86_poly-right##12 9.864
R3595 net@1907#12pmos@86_poly-right##12 net@1907#12pmos@86_poly-right##13 9.864
R3596 net@1907#12pmos@86_poly-right##13 net@1907#12pmos@86_poly-right##14 9.864
R3597 net@1907#12pmos@86_poly-right##14 net@1907#12pmos@86_poly-right##15 9.864
R3598 net@1907#12pmos@86_poly-right##15 net@1907#12pmos@86_poly-right##16 9.864
R3599 net@1907#12pmos@86_poly-right##16 net@1907#12pmos@86_poly-right##17 9.864
R3600 net@1907#12pmos@86_poly-right##17 net@1907#12pmos@86_poly-right##18 9.864
R3601 net@1907#12pmos@86_poly-right##18 net@1907#12pmos@86_poly-right##19 9.864
R3602 net@1907#12pmos@86_poly-right##19 net@1907#12pmos@86_poly-right##20 9.864
R3603 net@1907#12pmos@86_poly-right##20 net@1907#12pmos@86_poly-right##21 9.864
R3604 net@1907#12pmos@86_poly-right##21 net@1907#12pmos@86_poly-right##22 9.864
R3605 net@1907#12pmos@86_poly-right##22 net@1907#12pmos@86_poly-right##23 9.864
R3606 net@1907#12pmos@86_poly-right##23 net@1907#12pmos@86_poly-right##24 9.864
R3607 net@1907#12pmos@86_poly-right##24 net@1907#12pmos@86_poly-right##25 9.864
R3608 net@1907#12pmos@86_poly-right##25 net@1907#12pmos@86_poly-right##26 9.864
R3609 net@1907#12pmos@86_poly-right##26 net@1907#12pmos@86_poly-right##27 9.864
R3610 net@1907#12pmos@86_poly-right##27 net@1907#12pmos@86_poly-right##28 9.864
R3611 net@1907#12pmos@86_poly-right##28 net@1907#12pmos@86_poly-right##29 9.864
R3612 net@1907#12pmos@86_poly-right##29 net@1907#12pmos@86_poly-right##30 9.864
R3613 net@1907#12pmos@86_poly-right##30 net@1907#12pmos@86_poly-right##31 9.864
R3614 net@1907#12pmos@86_poly-right##31 net@1907#12pmos@86_poly-right##32 9.864
R3615 net@1907#12pmos@86_poly-right##32 net@1907#12pmos@86_poly-right##33 9.864
R3616 net@1907#12pmos@86_poly-right##33 net@1907#12pmos@86_poly-right##34 9.864
R3617 net@1907#12pmos@86_poly-right##34 net@1907#12pmos@86_poly-right##35 9.864
R3618 net@1907#12pmos@86_poly-right##35 net@1907#12pmos@86_poly-right##36 9.864
R3619 net@1907#12pmos@86_poly-right##36 net@1907#12pmos@86_poly-right##37 9.864
R3620 net@1907#12pmos@86_poly-right##37 net@1907#12pmos@86_poly-right##38 9.864
R3621 net@1907#12pmos@86_poly-right##38 net@1907#12pmos@86_poly-right##39 9.864
R3622 net@1907#12pmos@86_poly-right##39 net@1907#12pmos@86_poly-right##40 9.864
R3623 net@1907#12pmos@86_poly-right##40 net@1907#12pmos@86_poly-right##41 9.864
R3624 net@1907#12pmos@86_poly-right##41 net@1907#12pmos@86_poly-right##42 9.864
R3625 net@1907#12pmos@86_poly-right##42 net@1907#12pmos@86_poly-right##43 9.864
R3626 net@1907#12pmos@86_poly-right##43 net@1907#12pmos@86_poly-right##44 9.864
R3627 net@1907#12pmos@86_poly-right##44 net@1907#12pmos@86_poly-right##45 9.864
R3628 net@1907#12pmos@86_poly-right##45 net@1907#12pmos@86_poly-right##46 9.864
R3629 net@1907#12pmos@86_poly-right##46 net@1907#12pmos@86_poly-right##47 9.864
R3630 net@1907#12pmos@86_poly-right##47 net@1907#12pmos@86_poly-right##48 9.864
R3631 net@1907#12pmos@86_poly-right##48 net@1907#12pmos@86_poly-right##49 9.864
R3632 net@1907#12pmos@86_poly-right##49 net@1907#12pmos@86_poly-right##50 9.864
R3633 net@1907#12pmos@86_poly-right##50 net@1907#12pmos@86_poly-right##51 9.864
R3634 net@1907#12pmos@86_poly-right##51 net@1907#12pmos@86_poly-right##52 9.864
R3635 net@1907#12pmos@86_poly-right##52 net@1907#12pmos@86_poly-right##53 9.864
R3636 net@1907#12pmos@86_poly-right##53 net@1907#5pin@539_polysilicon-1 9.864
R3637 XOR1_to_NAND3#22pmos@86_diff-top XOR1_to_NAND3#1contact@656_metal-1-metal-2 4.862
R3638 XOR1_to_NAND3#3pin@572_polysilicon-1 XOR1_to_NAND3#3pin@572_polysilicon-1##0 9.881
R3639 XOR1_to_NAND3#3pin@572_polysilicon-1##0 XOR1_to_NAND3#3pin@572_polysilicon-1##1 9.881
R3640 XOR1_to_NAND3#3pin@572_polysilicon-1##1 XOR1_to_NAND3#3pin@572_polysilicon-1##2 9.881
R3641 XOR1_to_NAND3#3pin@572_polysilicon-1##2 XOR1_to_NAND3#3pin@572_polysilicon-1##3 9.881
R3642 XOR1_to_NAND3#3pin@572_polysilicon-1##3 XOR1_to_NAND3#3pin@572_polysilicon-1##4 9.881
R3643 XOR1_to_NAND3#3pin@572_polysilicon-1##4 XOR1_to_NAND3#3pin@572_polysilicon-1##5 9.881
R3644 XOR1_to_NAND3#3pin@572_polysilicon-1##5 XOR1_to_NAND3#3pin@572_polysilicon-1##6 9.881
R3645 XOR1_to_NAND3#3pin@572_polysilicon-1##6 XOR1_to_NAND3#3pin@572_polysilicon-1##7 9.881
R3646 XOR1_to_NAND3#3pin@572_polysilicon-1##7 XOR1_to_NAND3#3pin@572_polysilicon-1##8 9.881
R3647 XOR1_to_NAND3#3pin@572_polysilicon-1##8 XOR1_to_NAND3#3pin@572_polysilicon-1##9 9.881
R3648 XOR1_to_NAND3#3pin@572_polysilicon-1##9 XOR1_to_NAND3#3pin@572_polysilicon-1##10 9.881
R3649 XOR1_to_NAND3#3pin@572_polysilicon-1##10 XOR1_to_NAND3#3pin@572_polysilicon-1##11 9.881
R3650 XOR1_to_NAND3#3pin@572_polysilicon-1##11 XOR1_to_NAND3#3pin@572_polysilicon-1##12 9.881
R3651 XOR1_to_NAND3#3pin@572_polysilicon-1##12 XOR1_to_NAND3#3pin@572_polysilicon-1##13 9.881
R3652 XOR1_to_NAND3#3pin@572_polysilicon-1##13 XOR1_to_NAND3#3pin@572_polysilicon-1##14 9.881
R3653 XOR1_to_NAND3#3pin@572_polysilicon-1##14 XOR1_to_NAND3#3pin@572_polysilicon-1##15 9.881
R3654 XOR1_to_NAND3#3pin@572_polysilicon-1##15 XOR1_to_NAND3#3pin@572_polysilicon-1##16 9.881
R3655 XOR1_to_NAND3#3pin@572_polysilicon-1##16 XOR1_to_NAND3#3pin@572_polysilicon-1##17 9.881
R3656 XOR1_to_NAND3#3pin@572_polysilicon-1##17 XOR1_to_NAND3#3pin@572_polysilicon-1##18 9.881
R3657 XOR1_to_NAND3#3pin@572_polysilicon-1##18 XOR1_to_NAND3#3pin@572_polysilicon-1##19 9.881
R3658 XOR1_to_NAND3#3pin@572_polysilicon-1##19 XOR1_to_NAND3#3pin@572_polysilicon-1##20 9.881
R3659 XOR1_to_NAND3#3pin@572_polysilicon-1##20 XOR1_to_NAND3#3pin@572_polysilicon-1##21 9.881
R3660 XOR1_to_NAND3#3pin@572_polysilicon-1##21 XOR1_to_NAND3#3pin@572_polysilicon-1##22 9.881
R3661 XOR1_to_NAND3#3pin@572_polysilicon-1##22 XOR1_to_NAND3#3pin@572_polysilicon-1##23 9.881
R3662 XOR1_to_NAND3#3pin@572_polysilicon-1##23 XOR1_to_NAND3#3pin@572_polysilicon-1##24 9.881
R3663 XOR1_to_NAND3#3pin@572_polysilicon-1##24 XOR1_to_NAND3#3pin@572_polysilicon-1##25 9.881
R3664 XOR1_to_NAND3#3pin@572_polysilicon-1##25 XOR1_to_NAND3#3pin@572_polysilicon-1##26 9.881
R3665 XOR1_to_NAND3#3pin@572_polysilicon-1##26 XOR1_to_NAND3#3pin@572_polysilicon-1##27 9.881
R3666 XOR1_to_NAND3#3pin@572_polysilicon-1##27 XOR1_to_NAND3#3pin@572_polysilicon-1##28 9.881
R3667 XOR1_to_NAND3#3pin@572_polysilicon-1##28 XOR1_to_NAND3#3pin@572_polysilicon-1##29 9.881
R3668 XOR1_to_NAND3#3pin@572_polysilicon-1##29 XOR1_to_NAND3#3pin@572_polysilicon-1##30 9.881
R3669 XOR1_to_NAND3#3pin@572_polysilicon-1##30 XOR1_to_NAND3#3pin@572_polysilicon-1##31 9.881
R3670 XOR1_to_NAND3#3pin@572_polysilicon-1##31 XOR1_to_NAND3#3pin@572_polysilicon-1##32 9.881
R3671 XOR1_to_NAND3#3pin@572_polysilicon-1##32 XOR1_to_NAND3#3pin@572_polysilicon-1##33 9.881
R3672 XOR1_to_NAND3#3pin@572_polysilicon-1##33 XOR1_to_NAND3#3pin@572_polysilicon-1##34 9.881
R3673 XOR1_to_NAND3#3pin@572_polysilicon-1##34 XOR1_to_NAND3#3pin@572_polysilicon-1##35 9.881
R3674 XOR1_to_NAND3#3pin@572_polysilicon-1##35 XOR1_to_NAND3#3pin@572_polysilicon-1##36 9.881
R3675 XOR1_to_NAND3#3pin@572_polysilicon-1##36 XOR1_to_NAND3#3pin@572_polysilicon-1##37 9.881
R3676 XOR1_to_NAND3#3pin@572_polysilicon-1##37 XOR1_to_NAND3#3pin@572_polysilicon-1##38 9.881
R3677 XOR1_to_NAND3#3pin@572_polysilicon-1##38 XOR1_to_NAND3#3pin@572_polysilicon-1##39 9.881
R3678 XOR1_to_NAND3#3pin@572_polysilicon-1##39 XOR1_to_NAND3#3pin@572_polysilicon-1##40 9.881
R3679 XOR1_to_NAND3#3pin@572_polysilicon-1##40 XOR1_to_NAND3#3pin@572_polysilicon-1##41 9.881
R3680 XOR1_to_NAND3#3pin@572_polysilicon-1##41 XOR1_to_NAND3#3pin@572_polysilicon-1##42 9.881
R3681 XOR1_to_NAND3#3pin@572_polysilicon-1##42 XOR1_to_NAND3#3pin@572_polysilicon-1##43 9.881
R3682 XOR1_to_NAND3#3pin@572_polysilicon-1##43 XOR1_to_NAND3#3pin@572_polysilicon-1##44 9.881
R3683 XOR1_to_NAND3#3pin@572_polysilicon-1##44 XOR1_to_NAND3#3pin@572_polysilicon-1##45 9.881
R3684 XOR1_to_NAND3#3pin@572_polysilicon-1##45 XOR1_to_NAND3#3pin@572_polysilicon-1##46 9.881
R3685 XOR1_to_NAND3#3pin@572_polysilicon-1##46 XOR1_to_NAND3#3pin@572_polysilicon-1##47 9.881
R3686 XOR1_to_NAND3#3pin@572_polysilicon-1##47 XOR1_to_NAND3#3pin@572_polysilicon-1##48 9.881
R3687 XOR1_to_NAND3#3pin@572_polysilicon-1##48 XOR1_to_NAND3#3pin@572_polysilicon-1##49 9.881
R3688 XOR1_to_NAND3#3pin@572_polysilicon-1##49 XOR1_to_NAND3#3pin@572_polysilicon-1##50 9.881
R3689 XOR1_to_NAND3#3pin@572_polysilicon-1##50 XOR1_to_NAND3#3pin@572_polysilicon-1##51 9.881
R3690 XOR1_to_NAND3#3pin@572_polysilicon-1##51 XOR1_to_NAND3#3pin@572_polysilicon-1##52 9.881
R3691 XOR1_to_NAND3#3pin@572_polysilicon-1##52 XOR1_to_NAND3#3pin@572_polysilicon-1##53 9.881
R3692 XOR1_to_NAND3#3pin@572_polysilicon-1##53 XOR1_to_NAND3#3pin@572_polysilicon-1##54 9.881
R3693 XOR1_to_NAND3#3pin@572_polysilicon-1##54 XOR1_to_NAND3#24nmos@92_poly-right 9.881
R3694 net@1811#5pmos@92_diff-top net@1811#2pin@561_metal-1 4.81
R3695 net@1811#1pin@571_polysilicon-1 net@1811#1pin@571_polysilicon-1##0 9.85
R3696 net@1811#1pin@571_polysilicon-1##0 net@1811#1pin@571_polysilicon-1##1 9.85
R3697 net@1811#1pin@571_polysilicon-1##1 net@1811#1pin@571_polysilicon-1##2 9.85
R3698 net@1811#1pin@571_polysilicon-1##2 net@1811#1pin@571_polysilicon-1##3 9.85
R3699 net@1811#1pin@571_polysilicon-1##3 net@1811#1pin@571_polysilicon-1##4 9.85
R3700 net@1811#1pin@571_polysilicon-1##4 net@1811#1pin@571_polysilicon-1##5 9.85
R3701 net@1811#1pin@571_polysilicon-1##5 net@1811#1pin@571_polysilicon-1##6 9.85
R3702 net@1811#1pin@571_polysilicon-1##6 net@1811#1pin@571_polysilicon-1##7 9.85
R3703 net@1811#1pin@571_polysilicon-1##7 net@1811#1pin@571_polysilicon-1##8 9.85
R3704 net@1811#1pin@571_polysilicon-1##8 net@1811#1pin@571_polysilicon-1##9 9.85
R3705 net@1811#1pin@571_polysilicon-1##9 net@1811#1pin@571_polysilicon-1##10 9.85
R3706 net@1811#1pin@571_polysilicon-1##10 net@1811#1pin@571_polysilicon-1##11 9.85
R3707 net@1811#1pin@571_polysilicon-1##11 net@1811#1pin@571_polysilicon-1##12 9.85
R3708 net@1811#1pin@571_polysilicon-1##12 net@1811#1pin@571_polysilicon-1##13 9.85
R3709 net@1811#1pin@571_polysilicon-1##13 net@1811#1pin@571_polysilicon-1##14 9.85
R3710 net@1811#1pin@571_polysilicon-1##14 net@1811#1pin@571_polysilicon-1##15 9.85
R3711 net@1811#1pin@571_polysilicon-1##15 net@1811#1pin@571_polysilicon-1##16 9.85
R3712 net@1811#1pin@571_polysilicon-1##16 net@1811#1pin@571_polysilicon-1##17 9.85
R3713 net@1811#1pin@571_polysilicon-1##17 net@1811#1pin@571_polysilicon-1##18 9.85
R3714 net@1811#1pin@571_polysilicon-1##18 net@1811#1pin@571_polysilicon-1##19 9.85
R3715 net@1811#1pin@571_polysilicon-1##19 net@1811#1pin@571_polysilicon-1##20 9.85
R3716 net@1811#1pin@571_polysilicon-1##20 net@1811#1pin@571_polysilicon-1##21 9.85
R3717 net@1811#1pin@571_polysilicon-1##21 net@1811#1pin@571_polysilicon-1##22 9.85
R3718 net@1811#1pin@571_polysilicon-1##22 net@1811#1pin@571_polysilicon-1##23 9.85
R3719 net@1811#1pin@571_polysilicon-1##23 net@1811#1pin@571_polysilicon-1##24 9.85
R3720 net@1811#1pin@571_polysilicon-1##24 net@1811#1pin@571_polysilicon-1##25 9.85
R3721 net@1811#1pin@571_polysilicon-1##25 net@1811#1pin@571_polysilicon-1##26 9.85
R3722 net@1811#1pin@571_polysilicon-1##26 net@1811#1pin@571_polysilicon-1##27 9.85
R3723 net@1811#1pin@571_polysilicon-1##27 net@1811#1pin@571_polysilicon-1##28 9.85
R3724 net@1811#1pin@571_polysilicon-1##28 net@1811#1pin@571_polysilicon-1##29 9.85
R3725 net@1811#1pin@571_polysilicon-1##29 net@1811#1pin@571_polysilicon-1##30 9.85
R3726 net@1811#1pin@571_polysilicon-1##30 net@1811#1pin@571_polysilicon-1##31 9.85
R3727 net@1811#1pin@571_polysilicon-1##31 net@1811#1pin@571_polysilicon-1##32 9.85
R3728 net@1811#1pin@571_polysilicon-1##32 net@1811#1pin@571_polysilicon-1##33 9.85
R3729 net@1811#1pin@571_polysilicon-1##33 net@1811#1pin@571_polysilicon-1##34 9.85
R3730 net@1811#1pin@571_polysilicon-1##34 net@1811#1pin@571_polysilicon-1##35 9.85
R3731 net@1811#1pin@571_polysilicon-1##35 net@1811#1pin@571_polysilicon-1##36 9.85
R3732 net@1811#1pin@571_polysilicon-1##36 net@1811#1pin@571_polysilicon-1##37 9.85
R3733 net@1811#1pin@571_polysilicon-1##37 net@1811#1pin@571_polysilicon-1##38 9.85
R3734 net@1811#1pin@571_polysilicon-1##38 net@1811#1pin@571_polysilicon-1##39 9.85
R3735 net@1811#1pin@571_polysilicon-1##39 net@1811#1pin@571_polysilicon-1##40 9.85
R3736 net@1811#1pin@571_polysilicon-1##40 net@1811#1pin@571_polysilicon-1##41 9.85
R3737 net@1811#1pin@571_polysilicon-1##41 net@1811#1pin@571_polysilicon-1##42 9.85
R3738 net@1811#1pin@571_polysilicon-1##42 net@1811#1pin@571_polysilicon-1##43 9.85
R3739 net@1811#1pin@571_polysilicon-1##43 net@1811#1pin@571_polysilicon-1##44 9.85
R3740 net@1811#1pin@571_polysilicon-1##44 net@1811#1pin@571_polysilicon-1##45 9.85
R3741 net@1811#1pin@571_polysilicon-1##45 net@1811#1pin@571_polysilicon-1##46 9.85
R3742 net@1811#1pin@571_polysilicon-1##46 net@1811#1pin@571_polysilicon-1##47 9.85
R3743 net@1811#1pin@571_polysilicon-1##47 net@1811#1pin@571_polysilicon-1##48 9.85
R3744 net@1811#1pin@571_polysilicon-1##48 net@1811#1pin@571_polysilicon-1##49 9.85
R3745 net@1811#1pin@571_polysilicon-1##49 net@1811#1pin@571_polysilicon-1##50 9.85
R3746 net@1811#1pin@571_polysilicon-1##50 net@1811#1pin@571_polysilicon-1##51 9.85
R3747 net@1811#1pin@571_polysilicon-1##51 net@1811#1pin@571_polysilicon-1##52 9.85
R3748 net@1811#1pin@571_polysilicon-1##52 net@1811#1pin@571_polysilicon-1##53 9.85
R3749 net@1811#1pin@571_polysilicon-1##53 net@1811#1pin@571_polysilicon-1##54 9.85
R3750 net@1811#1pin@571_polysilicon-1##54 net@1811#1pin@571_polysilicon-1##55 9.85
R3751 net@1811#1pin@571_polysilicon-1##55 net@1811#1pin@571_polysilicon-1##56 9.85
R3752 net@1811#1pin@571_polysilicon-1##56 net@1811#1pin@571_polysilicon-1##57 9.85
R3753 net@1811#1pin@571_polysilicon-1##57 net@1811#1pin@571_polysilicon-1##58 9.85
R3754 net@1811#1pin@571_polysilicon-1##58 net@1811#1pin@571_polysilicon-1##59 9.85
R3755 net@1811#1pin@571_polysilicon-1##59 net@1811#1pin@571_polysilicon-1##60 9.85
R3756 net@1811#1pin@571_polysilicon-1##60 net@1811#2pin@561_metal-1 9.85
R3757 Cin_to_XOR2___NAND3#34pmos@91_poly-right Cin_to_XOR2___NAND3#34pmos@91_poly-right##0 9.854
R3758 Cin_to_XOR2___NAND3#34pmos@91_poly-right##0 Cin_to_XOR2___NAND3#34pmos@91_poly-right##1 9.854
R3759 Cin_to_XOR2___NAND3#34pmos@91_poly-right##1 Cin_to_XOR2___NAND3#34pmos@91_poly-right##2 9.854
R3760 Cin_to_XOR2___NAND3#34pmos@91_poly-right##2 Cin_to_XOR2___NAND3#34pmos@91_poly-right##3 9.854
R3761 Cin_to_XOR2___NAND3#34pmos@91_poly-right##3 Cin_to_XOR2___NAND3#34pmos@91_poly-right##4 9.854
R3762 Cin_to_XOR2___NAND3#34pmos@91_poly-right##4 Cin_to_XOR2___NAND3#34pmos@91_poly-right##5 9.854
R3763 Cin_to_XOR2___NAND3#34pmos@91_poly-right##5 Cin_to_XOR2___NAND3#34pmos@91_poly-right##6 9.854
R3764 Cin_to_XOR2___NAND3#34pmos@91_poly-right##6 Cin_to_XOR2___NAND3#34pmos@91_poly-right##7 9.854
R3765 Cin_to_XOR2___NAND3#34pmos@91_poly-right##7 Cin_to_XOR2___NAND3#34pmos@91_poly-right##8 9.854
R3766 Cin_to_XOR2___NAND3#34pmos@91_poly-right##8 Cin_to_XOR2___NAND3#34pmos@91_poly-right##9 9.854
R3767 Cin_to_XOR2___NAND3#34pmos@91_poly-right##9 Cin_to_XOR2___NAND3#34pmos@91_poly-right##10 9.854
R3768 Cin_to_XOR2___NAND3#34pmos@91_poly-right##10 Cin_to_XOR2___NAND3#34pmos@91_poly-right##11 9.854
R3769 Cin_to_XOR2___NAND3#34pmos@91_poly-right##11 Cin_to_XOR2___NAND3#34pmos@91_poly-right##12 9.854
R3770 Cin_to_XOR2___NAND3#34pmos@91_poly-right##12 Cin_to_XOR2___NAND3#34pmos@91_poly-right##13 9.854
R3771 Cin_to_XOR2___NAND3#34pmos@91_poly-right##13 Cin_to_XOR2___NAND3#34pmos@91_poly-right##14 9.854
R3772 Cin_to_XOR2___NAND3#34pmos@91_poly-right##14 Cin_to_XOR2___NAND3#34pmos@91_poly-right##15 9.854
R3773 Cin_to_XOR2___NAND3#34pmos@91_poly-right##15 Cin_to_XOR2___NAND3#34pmos@91_poly-right##16 9.854
R3774 Cin_to_XOR2___NAND3#34pmos@91_poly-right##16 Cin_to_XOR2___NAND3#34pmos@91_poly-right##17 9.854
R3775 Cin_to_XOR2___NAND3#34pmos@91_poly-right##17 Cin_to_XOR2___NAND3#34pmos@91_poly-right##18 9.854
R3776 Cin_to_XOR2___NAND3#34pmos@91_poly-right##18 Cin_to_XOR2___NAND3#34pmos@91_poly-right##19 9.854
R3777 Cin_to_XOR2___NAND3#34pmos@91_poly-right##19 Cin_to_XOR2___NAND3#34pmos@91_poly-right##20 9.854
R3778 Cin_to_XOR2___NAND3#34pmos@91_poly-right##20 Cin_to_XOR2___NAND3#34pmos@91_poly-right##21 9.854
R3779 Cin_to_XOR2___NAND3#34pmos@91_poly-right##21 Cin_to_XOR2___NAND3#34pmos@91_poly-right##22 9.854
R3780 Cin_to_XOR2___NAND3#34pmos@91_poly-right##22 Cin_to_XOR2___NAND3#34pmos@91_poly-right##23 9.854
R3781 Cin_to_XOR2___NAND3#34pmos@91_poly-right##23 Cin_to_XOR2___NAND3#34pmos@91_poly-right##24 9.854
R3782 Cin_to_XOR2___NAND3#34pmos@91_poly-right##24 Cin_to_XOR2___NAND3#34pmos@91_poly-right##25 9.854
R3783 Cin_to_XOR2___NAND3#34pmos@91_poly-right##25 Cin_to_XOR2___NAND3#34pmos@91_poly-right##26 9.854
R3784 Cin_to_XOR2___NAND3#34pmos@91_poly-right##26 Cin_to_XOR2___NAND3#34pmos@91_poly-right##27 9.854
R3785 Cin_to_XOR2___NAND3#34pmos@91_poly-right##27 Cin_to_XOR2___NAND3#34pmos@91_poly-right##28 9.854
R3786 Cin_to_XOR2___NAND3#34pmos@91_poly-right##28 Cin_to_XOR2___NAND3#34pmos@91_poly-right##29 9.854
R3787 Cin_to_XOR2___NAND3#34pmos@91_poly-right##29 Cin_to_XOR2___NAND3#34pmos@91_poly-right##30 9.854
R3788 Cin_to_XOR2___NAND3#34pmos@91_poly-right##30 Cin_to_XOR2___NAND3#34pmos@91_poly-right##31 9.854
R3789 Cin_to_XOR2___NAND3#34pmos@91_poly-right##31 Cin_to_XOR2___NAND3#34pmos@91_poly-right##32 9.854
R3790 Cin_to_XOR2___NAND3#34pmos@91_poly-right##32 Cin_to_XOR2___NAND3#34pmos@91_poly-right##33 9.854
R3791 Cin_to_XOR2___NAND3#34pmos@91_poly-right##33 Cin_to_XOR2___NAND3#34pmos@91_poly-right##34 9.854
R3792 Cin_to_XOR2___NAND3#34pmos@91_poly-right##34 Cin_to_XOR2___NAND3#34pmos@91_poly-right##35 9.854
R3793 Cin_to_XOR2___NAND3#34pmos@91_poly-right##35 Cin_to_XOR2___NAND3#34pmos@91_poly-right##36 9.854
R3794 Cin_to_XOR2___NAND3#34pmos@91_poly-right##36 Cin_to_XOR2___NAND3#34pmos@91_poly-right##37 9.854
R3795 Cin_to_XOR2___NAND3#34pmos@91_poly-right##37 Cin_to_XOR2___NAND3#34pmos@91_poly-right##38 9.854
R3796 Cin_to_XOR2___NAND3#34pmos@91_poly-right##38 Cin_to_XOR2___NAND3#34pmos@91_poly-right##39 9.854
R3797 Cin_to_XOR2___NAND3#34pmos@91_poly-right##39 Cin_to_XOR2___NAND3#34pmos@91_poly-right##40 9.854
R3798 Cin_to_XOR2___NAND3#34pmos@91_poly-right##40 Cin_to_XOR2___NAND3#34pmos@91_poly-right##41 9.854
R3799 Cin_to_XOR2___NAND3#34pmos@91_poly-right##41 Cin_to_XOR2___NAND3#34pmos@91_poly-right##42 9.854
R3800 Cin_to_XOR2___NAND3#34pmos@91_poly-right##42 Cin_to_XOR2___NAND3#34pmos@91_poly-right##43 9.854
R3801 Cin_to_XOR2___NAND3#34pmos@91_poly-right##43 Cin_to_XOR2___NAND3#34pmos@91_poly-right##44 9.854
R3802 Cin_to_XOR2___NAND3#34pmos@91_poly-right##44 Cin_to_XOR2___NAND3#34pmos@91_poly-right##45 9.854
R3803 Cin_to_XOR2___NAND3#34pmos@91_poly-right##45 Cin_to_XOR2___NAND3#34pmos@91_poly-right##46 9.854
R3804 Cin_to_XOR2___NAND3#34pmos@91_poly-right##46 Cin_to_XOR2___NAND3#34pmos@91_poly-right##47 9.854
R3805 Cin_to_XOR2___NAND3#34pmos@91_poly-right##47 Cin_to_XOR2___NAND3#34pmos@91_poly-right##48 9.854
R3806 Cin_to_XOR2___NAND3#34pmos@91_poly-right##48 Cin_to_XOR2___NAND3#34pmos@91_poly-right##49 9.854
R3807 Cin_to_XOR2___NAND3#34pmos@91_poly-right##49 Cin_to_XOR2___NAND3#34pmos@91_poly-right##50 9.854
R3808 Cin_to_XOR2___NAND3#34pmos@91_poly-right##50 Cin_to_XOR2___NAND3#34pmos@91_poly-right##51 9.854
R3809 Cin_to_XOR2___NAND3#34pmos@91_poly-right##51 Cin_to_XOR2___NAND3#34pmos@91_poly-right##52 9.854
R3810 Cin_to_XOR2___NAND3#34pmos@91_poly-right##52 Cin_to_XOR2___NAND3#34pmos@91_poly-right##53 9.854
R3811 Cin_to_XOR2___NAND3#34pmos@91_poly-right##53 Cin_to_XOR2___NAND3#34pmos@91_poly-right##54 9.854
R3812 Cin_to_XOR2___NAND3#34pmos@91_poly-right##54 Cin_to_XOR2___NAND3#23pin@562_polysilicon-1 9.854
R3813 net@1821 net@1821#2contact@617_metal-1-metal-2 4.797
R3814 XOR1_to_NAND3#9pmos@87_poly-left XOR1_to_NAND3#9pmos@87_poly-left##0 9.871
R3815 XOR1_to_NAND3#9pmos@87_poly-left##0 XOR1_to_NAND3#9pmos@87_poly-left##1 9.871
R3816 XOR1_to_NAND3#9pmos@87_poly-left##1 XOR1_to_NAND3#9pmos@87_poly-left##2 9.871
R3817 XOR1_to_NAND3#9pmos@87_poly-left##2 XOR1_to_NAND3#9pmos@87_poly-left##3 9.871
R3818 XOR1_to_NAND3#9pmos@87_poly-left##3 XOR1_to_NAND3#9pmos@87_poly-left##4 9.871
R3819 XOR1_to_NAND3#9pmos@87_poly-left##4 XOR1_to_NAND3#9pmos@87_poly-left##5 9.871
R3820 XOR1_to_NAND3#9pmos@87_poly-left##5 XOR1_to_NAND3#9pmos@87_poly-left##6 9.871
R3821 XOR1_to_NAND3#9pmos@87_poly-left##6 XOR1_to_NAND3#9pmos@87_poly-left##7 9.871
R3822 XOR1_to_NAND3#9pmos@87_poly-left##7 XOR1_to_NAND3#9pmos@87_poly-left##8 9.871
R3823 XOR1_to_NAND3#9pmos@87_poly-left##8 XOR1_to_NAND3#9pmos@87_poly-left##9 9.871
R3824 XOR1_to_NAND3#9pmos@87_poly-left##9 XOR1_to_NAND3#9pmos@87_poly-left##10 9.871
R3825 XOR1_to_NAND3#9pmos@87_poly-left##10 XOR1_to_NAND3#9pmos@87_poly-left##11 9.871
R3826 XOR1_to_NAND3#9pmos@87_poly-left##11 XOR1_to_NAND3#9pmos@87_poly-left##12 9.871
R3827 XOR1_to_NAND3#9pmos@87_poly-left##12 XOR1_to_NAND3#9pmos@87_poly-left##13 9.871
R3828 XOR1_to_NAND3#9pmos@87_poly-left##13 XOR1_to_NAND3#9pmos@87_poly-left##14 9.871
R3829 XOR1_to_NAND3#9pmos@87_poly-left##14 XOR1_to_NAND3#9pmos@87_poly-left##15 9.871
R3830 XOR1_to_NAND3#9pmos@87_poly-left##15 XOR1_to_NAND3#9pmos@87_poly-left##16 9.871
R3831 XOR1_to_NAND3#9pmos@87_poly-left##16 XOR1_to_NAND3#9pmos@87_poly-left##17 9.871
R3832 XOR1_to_NAND3#9pmos@87_poly-left##17 XOR1_to_NAND3#9pmos@87_poly-left##18 9.871
R3833 XOR1_to_NAND3#9pmos@87_poly-left##18 XOR1_to_NAND3#9pmos@87_poly-left##19 9.871
R3834 XOR1_to_NAND3#9pmos@87_poly-left##19 XOR1_to_NAND3#9pmos@87_poly-left##20 9.871
R3835 XOR1_to_NAND3#9pmos@87_poly-left##20 XOR1_to_NAND3#9pmos@87_poly-left##21 9.871
R3836 XOR1_to_NAND3#9pmos@87_poly-left##21 XOR1_to_NAND3#9pmos@87_poly-left##22 9.871
R3837 XOR1_to_NAND3#9pmos@87_poly-left##22 XOR1_to_NAND3#9pmos@87_poly-left##23 9.871
R3838 XOR1_to_NAND3#9pmos@87_poly-left##23 XOR1_to_NAND3#9pmos@87_poly-left##24 9.871
R3839 XOR1_to_NAND3#9pmos@87_poly-left##24 XOR1_to_NAND3#9pmos@87_poly-left##25 9.871
R3840 XOR1_to_NAND3#9pmos@87_poly-left##25 XOR1_to_NAND3#9pmos@87_poly-left##26 9.871
R3841 XOR1_to_NAND3#9pmos@87_poly-left##26 XOR1_to_NAND3#9pmos@87_poly-left##27 9.871
R3842 XOR1_to_NAND3#9pmos@87_poly-left##27 XOR1_to_NAND3#9pmos@87_poly-left##28 9.871
R3843 XOR1_to_NAND3#9pmos@87_poly-left##28 XOR1_to_NAND3#9pmos@87_poly-left##29 9.871
R3844 XOR1_to_NAND3#9pmos@87_poly-left##29 XOR1_to_NAND3#9pmos@87_poly-left##30 9.871
R3845 XOR1_to_NAND3#9pmos@87_poly-left##30 XOR1_to_NAND3#9pmos@87_poly-left##31 9.871
R3846 XOR1_to_NAND3#9pmos@87_poly-left##31 XOR1_to_NAND3#9pmos@87_poly-left##32 9.871
R3847 XOR1_to_NAND3#9pmos@87_poly-left##32 XOR1_to_NAND3#9pmos@87_poly-left##33 9.871
R3848 XOR1_to_NAND3#9pmos@87_poly-left##33 XOR1_to_NAND3#9pmos@87_poly-left##34 9.871
R3849 XOR1_to_NAND3#9pmos@87_poly-left##34 XOR1_to_NAND3#9pmos@87_poly-left##35 9.871
R3850 XOR1_to_NAND3#9pmos@87_poly-left##35 XOR1_to_NAND3#9pmos@87_poly-left##36 9.871
R3851 XOR1_to_NAND3#9pmos@87_poly-left##36 XOR1_to_NAND3#9pmos@87_poly-left##37 9.871
R3852 XOR1_to_NAND3#9pmos@87_poly-left##37 XOR1_to_NAND3#9pmos@87_poly-left##38 9.871
R3853 XOR1_to_NAND3#9pmos@87_poly-left##38 XOR1_to_NAND3#9pmos@87_poly-left##39 9.871
R3854 XOR1_to_NAND3#9pmos@87_poly-left##39 XOR1_to_NAND3#9pmos@87_poly-left##40 9.871
R3855 XOR1_to_NAND3#9pmos@87_poly-left##40 XOR1_to_NAND3#9pmos@87_poly-left##41 9.871
R3856 XOR1_to_NAND3#9pmos@87_poly-left##41 XOR1_to_NAND3#9pmos@87_poly-left##42 9.871
R3857 XOR1_to_NAND3#9pmos@87_poly-left##42 XOR1_to_NAND3#9pmos@87_poly-left##43 9.871
R3858 XOR1_to_NAND3#9pmos@87_poly-left##43 XOR1_to_NAND3#9pmos@87_poly-left##44 9.871
R3859 XOR1_to_NAND3#9pmos@87_poly-left##44 XOR1_to_NAND3#9pmos@87_poly-left##45 9.871
R3860 XOR1_to_NAND3#9pmos@87_poly-left##45 XOR1_to_NAND3#9pmos@87_poly-left##46 9.871
R3861 XOR1_to_NAND3#9pmos@87_poly-left##46 XOR1_to_NAND3#9pmos@87_poly-left##47 9.871
R3862 XOR1_to_NAND3#9pmos@87_poly-left##47 XOR1_to_NAND3#9pmos@87_poly-left##48 9.871
R3863 XOR1_to_NAND3#9pmos@87_poly-left##48 XOR1_to_NAND3#9pmos@87_poly-left##49 9.871
R3864 XOR1_to_NAND3#9pmos@87_poly-left##49 XOR1_to_NAND3#9pmos@87_poly-left##50 9.871
R3865 XOR1_to_NAND3#9pmos@87_poly-left##50 XOR1_to_NAND3#9pmos@87_poly-left##51 9.871
R3866 XOR1_to_NAND3#9pmos@87_poly-left##51 XOR1_to_NAND3#9pmos@87_poly-left##52 9.871
R3867 XOR1_to_NAND3#9pmos@87_poly-left##52 XOR1_to_NAND3#9pmos@87_poly-left##53 9.871
R3868 XOR1_to_NAND3#9pmos@87_poly-left##53 XOR1_to_NAND3#9pmos@87_poly-left##54 9.871
R3869 XOR1_to_NAND3#9pmos@87_poly-left##54 XOR1_to_NAND3#9pmos@87_poly-left##55 9.871
R3870 XOR1_to_NAND3#9pmos@87_poly-left##55 XOR1_to_NAND3#26nmos@87_poly-right 9.871
R3871 net@1811#7pmos@88_poly-left net@1811#7pmos@88_poly-left##0 9.871
R3872 net@1811#7pmos@88_poly-left##0 net@1811#7pmos@88_poly-left##1 9.871
R3873 net@1811#7pmos@88_poly-left##1 net@1811#7pmos@88_poly-left##2 9.871
R3874 net@1811#7pmos@88_poly-left##2 net@1811#7pmos@88_poly-left##3 9.871
R3875 net@1811#7pmos@88_poly-left##3 net@1811#7pmos@88_poly-left##4 9.871
R3876 net@1811#7pmos@88_poly-left##4 net@1811#7pmos@88_poly-left##5 9.871
R3877 net@1811#7pmos@88_poly-left##5 net@1811#7pmos@88_poly-left##6 9.871
R3878 net@1811#7pmos@88_poly-left##6 net@1811#7pmos@88_poly-left##7 9.871
R3879 net@1811#7pmos@88_poly-left##7 net@1811#7pmos@88_poly-left##8 9.871
R3880 net@1811#7pmos@88_poly-left##8 net@1811#7pmos@88_poly-left##9 9.871
R3881 net@1811#7pmos@88_poly-left##9 net@1811#7pmos@88_poly-left##10 9.871
R3882 net@1811#7pmos@88_poly-left##10 net@1811#7pmos@88_poly-left##11 9.871
R3883 net@1811#7pmos@88_poly-left##11 net@1811#7pmos@88_poly-left##12 9.871
R3884 net@1811#7pmos@88_poly-left##12 net@1811#7pmos@88_poly-left##13 9.871
R3885 net@1811#7pmos@88_poly-left##13 net@1811#7pmos@88_poly-left##14 9.871
R3886 net@1811#7pmos@88_poly-left##14 net@1811#7pmos@88_poly-left##15 9.871
R3887 net@1811#7pmos@88_poly-left##15 net@1811#7pmos@88_poly-left##16 9.871
R3888 net@1811#7pmos@88_poly-left##16 net@1811#7pmos@88_poly-left##17 9.871
R3889 net@1811#7pmos@88_poly-left##17 net@1811#7pmos@88_poly-left##18 9.871
R3890 net@1811#7pmos@88_poly-left##18 net@1811#7pmos@88_poly-left##19 9.871
R3891 net@1811#7pmos@88_poly-left##19 net@1811#7pmos@88_poly-left##20 9.871
R3892 net@1811#7pmos@88_poly-left##20 net@1811#7pmos@88_poly-left##21 9.871
R3893 net@1811#7pmos@88_poly-left##21 net@1811#7pmos@88_poly-left##22 9.871
R3894 net@1811#7pmos@88_poly-left##22 net@1811#7pmos@88_poly-left##23 9.871
R3895 net@1811#7pmos@88_poly-left##23 net@1811#7pmos@88_poly-left##24 9.871
R3896 net@1811#7pmos@88_poly-left##24 net@1811#7pmos@88_poly-left##25 9.871
R3897 net@1811#7pmos@88_poly-left##25 net@1811#7pmos@88_poly-left##26 9.871
R3898 net@1811#7pmos@88_poly-left##26 net@1811#7pmos@88_poly-left##27 9.871
R3899 net@1811#7pmos@88_poly-left##27 net@1811#7pmos@88_poly-left##28 9.871
R3900 net@1811#7pmos@88_poly-left##28 net@1811#7pmos@88_poly-left##29 9.871
R3901 net@1811#7pmos@88_poly-left##29 net@1811#7pmos@88_poly-left##30 9.871
R3902 net@1811#7pmos@88_poly-left##30 net@1811#7pmos@88_poly-left##31 9.871
R3903 net@1811#7pmos@88_poly-left##31 net@1811#7pmos@88_poly-left##32 9.871
R3904 net@1811#7pmos@88_poly-left##32 net@1811#7pmos@88_poly-left##33 9.871
R3905 net@1811#7pmos@88_poly-left##33 net@1811#7pmos@88_poly-left##34 9.871
R3906 net@1811#7pmos@88_poly-left##34 net@1811#7pmos@88_poly-left##35 9.871
R3907 net@1811#7pmos@88_poly-left##35 net@1811#7pmos@88_poly-left##36 9.871
R3908 net@1811#7pmos@88_poly-left##36 net@1811#7pmos@88_poly-left##37 9.871
R3909 net@1811#7pmos@88_poly-left##37 net@1811#7pmos@88_poly-left##38 9.871
R3910 net@1811#7pmos@88_poly-left##38 net@1811#7pmos@88_poly-left##39 9.871
R3911 net@1811#7pmos@88_poly-left##39 net@1811#7pmos@88_poly-left##40 9.871
R3912 net@1811#7pmos@88_poly-left##40 net@1811#7pmos@88_poly-left##41 9.871
R3913 net@1811#7pmos@88_poly-left##41 net@1811#7pmos@88_poly-left##42 9.871
R3914 net@1811#7pmos@88_poly-left##42 net@1811#7pmos@88_poly-left##43 9.871
R3915 net@1811#7pmos@88_poly-left##43 net@1811#7pmos@88_poly-left##44 9.871
R3916 net@1811#7pmos@88_poly-left##44 net@1811#7pmos@88_poly-left##45 9.871
R3917 net@1811#7pmos@88_poly-left##45 net@1811#7pmos@88_poly-left##46 9.871
R3918 net@1811#7pmos@88_poly-left##46 net@1811#7pmos@88_poly-left##47 9.871
R3919 net@1811#7pmos@88_poly-left##47 net@1811#7pmos@88_poly-left##48 9.871
R3920 net@1811#7pmos@88_poly-left##48 net@1811#7pmos@88_poly-left##49 9.871
R3921 net@1811#7pmos@88_poly-left##49 net@1811#7pmos@88_poly-left##50 9.871
R3922 net@1811#7pmos@88_poly-left##50 net@1811#7pmos@88_poly-left##51 9.871
R3923 net@1811#7pmos@88_poly-left##51 net@1811#7pmos@88_poly-left##52 9.871
R3924 net@1811#7pmos@88_poly-left##52 net@1811#7pmos@88_poly-left##53 9.871
R3925 net@1811#7pmos@88_poly-left##53 net@1811#7pmos@88_poly-left##54 9.871
R3926 net@1811#7pmos@88_poly-left##54 net@1811#7pmos@88_poly-left##55 9.871
R3927 net@1811#7pmos@88_poly-left##55 net@1811#11nmos@88_poly-right 9.871
R3928 Cin_to_XOR2___NAND3#35pmos@89_poly-right Cin_to_XOR2___NAND3#35pmos@89_poly-right##0 9.871
R3929 Cin_to_XOR2___NAND3#35pmos@89_poly-right##0 Cin_to_XOR2___NAND3#35pmos@89_poly-right##1 9.871
R3930 Cin_to_XOR2___NAND3#35pmos@89_poly-right##1 Cin_to_XOR2___NAND3#35pmos@89_poly-right##2 9.871
R3931 Cin_to_XOR2___NAND3#35pmos@89_poly-right##2 Cin_to_XOR2___NAND3#35pmos@89_poly-right##3 9.871
R3932 Cin_to_XOR2___NAND3#35pmos@89_poly-right##3 Cin_to_XOR2___NAND3#35pmos@89_poly-right##4 9.871
R3933 Cin_to_XOR2___NAND3#35pmos@89_poly-right##4 Cin_to_XOR2___NAND3#35pmos@89_poly-right##5 9.871
R3934 Cin_to_XOR2___NAND3#35pmos@89_poly-right##5 Cin_to_XOR2___NAND3#35pmos@89_poly-right##6 9.871
R3935 Cin_to_XOR2___NAND3#35pmos@89_poly-right##6 Cin_to_XOR2___NAND3#35pmos@89_poly-right##7 9.871
R3936 Cin_to_XOR2___NAND3#35pmos@89_poly-right##7 Cin_to_XOR2___NAND3#35pmos@89_poly-right##8 9.871
R3937 Cin_to_XOR2___NAND3#35pmos@89_poly-right##8 Cin_to_XOR2___NAND3#35pmos@89_poly-right##9 9.871
R3938 Cin_to_XOR2___NAND3#35pmos@89_poly-right##9 Cin_to_XOR2___NAND3#35pmos@89_poly-right##10 9.871
R3939 Cin_to_XOR2___NAND3#35pmos@89_poly-right##10 Cin_to_XOR2___NAND3#35pmos@89_poly-right##11 9.871
R3940 Cin_to_XOR2___NAND3#35pmos@89_poly-right##11 Cin_to_XOR2___NAND3#35pmos@89_poly-right##12 9.871
R3941 Cin_to_XOR2___NAND3#35pmos@89_poly-right##12 Cin_to_XOR2___NAND3#35pmos@89_poly-right##13 9.871
R3942 Cin_to_XOR2___NAND3#35pmos@89_poly-right##13 Cin_to_XOR2___NAND3#35pmos@89_poly-right##14 9.871
R3943 Cin_to_XOR2___NAND3#35pmos@89_poly-right##14 Cin_to_XOR2___NAND3#35pmos@89_poly-right##15 9.871
R3944 Cin_to_XOR2___NAND3#35pmos@89_poly-right##15 Cin_to_XOR2___NAND3#35pmos@89_poly-right##16 9.871
R3945 Cin_to_XOR2___NAND3#35pmos@89_poly-right##16 Cin_to_XOR2___NAND3#35pmos@89_poly-right##17 9.871
R3946 Cin_to_XOR2___NAND3#35pmos@89_poly-right##17 Cin_to_XOR2___NAND3#35pmos@89_poly-right##18 9.871
R3947 Cin_to_XOR2___NAND3#35pmos@89_poly-right##18 Cin_to_XOR2___NAND3#35pmos@89_poly-right##19 9.871
R3948 Cin_to_XOR2___NAND3#35pmos@89_poly-right##19 Cin_to_XOR2___NAND3#35pmos@89_poly-right##20 9.871
R3949 Cin_to_XOR2___NAND3#35pmos@89_poly-right##20 Cin_to_XOR2___NAND3#35pmos@89_poly-right##21 9.871
R3950 Cin_to_XOR2___NAND3#35pmos@89_poly-right##21 Cin_to_XOR2___NAND3#35pmos@89_poly-right##22 9.871
R3951 Cin_to_XOR2___NAND3#35pmos@89_poly-right##22 Cin_to_XOR2___NAND3#35pmos@89_poly-right##23 9.871
R3952 Cin_to_XOR2___NAND3#35pmos@89_poly-right##23 Cin_to_XOR2___NAND3#35pmos@89_poly-right##24 9.871
R3953 Cin_to_XOR2___NAND3#35pmos@89_poly-right##24 Cin_to_XOR2___NAND3#35pmos@89_poly-right##25 9.871
R3954 Cin_to_XOR2___NAND3#35pmos@89_poly-right##25 Cin_to_XOR2___NAND3#35pmos@89_poly-right##26 9.871
R3955 Cin_to_XOR2___NAND3#35pmos@89_poly-right##26 Cin_to_XOR2___NAND3#35pmos@89_poly-right##27 9.871
R3956 Cin_to_XOR2___NAND3#35pmos@89_poly-right##27 Cin_to_XOR2___NAND3#35pmos@89_poly-right##28 9.871
R3957 Cin_to_XOR2___NAND3#35pmos@89_poly-right##28 Cin_to_XOR2___NAND3#35pmos@89_poly-right##29 9.871
R3958 Cin_to_XOR2___NAND3#35pmos@89_poly-right##29 Cin_to_XOR2___NAND3#35pmos@89_poly-right##30 9.871
R3959 Cin_to_XOR2___NAND3#35pmos@89_poly-right##30 Cin_to_XOR2___NAND3#35pmos@89_poly-right##31 9.871
R3960 Cin_to_XOR2___NAND3#35pmos@89_poly-right##31 Cin_to_XOR2___NAND3#35pmos@89_poly-right##32 9.871
R3961 Cin_to_XOR2___NAND3#35pmos@89_poly-right##32 Cin_to_XOR2___NAND3#35pmos@89_poly-right##33 9.871
R3962 Cin_to_XOR2___NAND3#35pmos@89_poly-right##33 Cin_to_XOR2___NAND3#35pmos@89_poly-right##34 9.871
R3963 Cin_to_XOR2___NAND3#35pmos@89_poly-right##34 Cin_to_XOR2___NAND3#35pmos@89_poly-right##35 9.871
R3964 Cin_to_XOR2___NAND3#35pmos@89_poly-right##35 Cin_to_XOR2___NAND3#35pmos@89_poly-right##36 9.871
R3965 Cin_to_XOR2___NAND3#35pmos@89_poly-right##36 Cin_to_XOR2___NAND3#35pmos@89_poly-right##37 9.871
R3966 Cin_to_XOR2___NAND3#35pmos@89_poly-right##37 Cin_to_XOR2___NAND3#35pmos@89_poly-right##38 9.871
R3967 Cin_to_XOR2___NAND3#35pmos@89_poly-right##38 Cin_to_XOR2___NAND3#35pmos@89_poly-right##39 9.871
R3968 Cin_to_XOR2___NAND3#35pmos@89_poly-right##39 Cin_to_XOR2___NAND3#35pmos@89_poly-right##40 9.871
R3969 Cin_to_XOR2___NAND3#35pmos@89_poly-right##40 Cin_to_XOR2___NAND3#35pmos@89_poly-right##41 9.871
R3970 Cin_to_XOR2___NAND3#35pmos@89_poly-right##41 Cin_to_XOR2___NAND3#35pmos@89_poly-right##42 9.871
R3971 Cin_to_XOR2___NAND3#35pmos@89_poly-right##42 Cin_to_XOR2___NAND3#35pmos@89_poly-right##43 9.871
R3972 Cin_to_XOR2___NAND3#35pmos@89_poly-right##43 Cin_to_XOR2___NAND3#35pmos@89_poly-right##44 9.871
R3973 Cin_to_XOR2___NAND3#35pmos@89_poly-right##44 Cin_to_XOR2___NAND3#35pmos@89_poly-right##45 9.871
R3974 Cin_to_XOR2___NAND3#35pmos@89_poly-right##45 Cin_to_XOR2___NAND3#35pmos@89_poly-right##46 9.871
R3975 Cin_to_XOR2___NAND3#35pmos@89_poly-right##46 Cin_to_XOR2___NAND3#35pmos@89_poly-right##47 9.871
R3976 Cin_to_XOR2___NAND3#35pmos@89_poly-right##47 Cin_to_XOR2___NAND3#35pmos@89_poly-right##48 9.871
R3977 Cin_to_XOR2___NAND3#35pmos@89_poly-right##48 Cin_to_XOR2___NAND3#35pmos@89_poly-right##49 9.871
R3978 Cin_to_XOR2___NAND3#35pmos@89_poly-right##49 Cin_to_XOR2___NAND3#35pmos@89_poly-right##50 9.871
R3979 Cin_to_XOR2___NAND3#35pmos@89_poly-right##50 Cin_to_XOR2___NAND3#35pmos@89_poly-right##51 9.871
R3980 Cin_to_XOR2___NAND3#35pmos@89_poly-right##51 Cin_to_XOR2___NAND3#35pmos@89_poly-right##52 9.871
R3981 Cin_to_XOR2___NAND3#35pmos@89_poly-right##52 Cin_to_XOR2___NAND3#35pmos@89_poly-right##53 9.871
R3982 Cin_to_XOR2___NAND3#35pmos@89_poly-right##53 Cin_to_XOR2___NAND3#35pmos@89_poly-right##54 9.871
R3983 Cin_to_XOR2___NAND3#35pmos@89_poly-right##54 Cin_to_XOR2___NAND3#35pmos@89_poly-right##55 9.871
R3984 Cin_to_XOR2___NAND3#35pmos@89_poly-right##55 Cin_to_XOR2___NAND3#26nmos@89_poly-left 9.871
R3985 net@1821#14pmos@90_poly-right net@1821#14pmos@90_poly-right##0 9.871
R3986 net@1821#14pmos@90_poly-right##0 net@1821#14pmos@90_poly-right##1 9.871
R3987 net@1821#14pmos@90_poly-right##1 net@1821#14pmos@90_poly-right##2 9.871
R3988 net@1821#14pmos@90_poly-right##2 net@1821#14pmos@90_poly-right##3 9.871
R3989 net@1821#14pmos@90_poly-right##3 net@1821#14pmos@90_poly-right##4 9.871
R3990 net@1821#14pmos@90_poly-right##4 net@1821#14pmos@90_poly-right##5 9.871
R3991 net@1821#14pmos@90_poly-right##5 net@1821#14pmos@90_poly-right##6 9.871
R3992 net@1821#14pmos@90_poly-right##6 net@1821#14pmos@90_poly-right##7 9.871
R3993 net@1821#14pmos@90_poly-right##7 net@1821#14pmos@90_poly-right##8 9.871
R3994 net@1821#14pmos@90_poly-right##8 net@1821#14pmos@90_poly-right##9 9.871
R3995 net@1821#14pmos@90_poly-right##9 net@1821#14pmos@90_poly-right##10 9.871
R3996 net@1821#14pmos@90_poly-right##10 net@1821#14pmos@90_poly-right##11 9.871
R3997 net@1821#14pmos@90_poly-right##11 net@1821#14pmos@90_poly-right##12 9.871
R3998 net@1821#14pmos@90_poly-right##12 net@1821#14pmos@90_poly-right##13 9.871
R3999 net@1821#14pmos@90_poly-right##13 net@1821#14pmos@90_poly-right##14 9.871
R4000 net@1821#14pmos@90_poly-right##14 net@1821#14pmos@90_poly-right##15 9.871
R4001 net@1821#14pmos@90_poly-right##15 net@1821#14pmos@90_poly-right##16 9.871
R4002 net@1821#14pmos@90_poly-right##16 net@1821#14pmos@90_poly-right##17 9.871
R4003 net@1821#14pmos@90_poly-right##17 net@1821#14pmos@90_poly-right##18 9.871
R4004 net@1821#14pmos@90_poly-right##18 net@1821#14pmos@90_poly-right##19 9.871
R4005 net@1821#14pmos@90_poly-right##19 net@1821#14pmos@90_poly-right##20 9.871
R4006 net@1821#14pmos@90_poly-right##20 net@1821#14pmos@90_poly-right##21 9.871
R4007 net@1821#14pmos@90_poly-right##21 net@1821#14pmos@90_poly-right##22 9.871
R4008 net@1821#14pmos@90_poly-right##22 net@1821#14pmos@90_poly-right##23 9.871
R4009 net@1821#14pmos@90_poly-right##23 net@1821#14pmos@90_poly-right##24 9.871
R4010 net@1821#14pmos@90_poly-right##24 net@1821#14pmos@90_poly-right##25 9.871
R4011 net@1821#14pmos@90_poly-right##25 net@1821#14pmos@90_poly-right##26 9.871
R4012 net@1821#14pmos@90_poly-right##26 net@1821#14pmos@90_poly-right##27 9.871
R4013 net@1821#14pmos@90_poly-right##27 net@1821#14pmos@90_poly-right##28 9.871
R4014 net@1821#14pmos@90_poly-right##28 net@1821#14pmos@90_poly-right##29 9.871
R4015 net@1821#14pmos@90_poly-right##29 net@1821#14pmos@90_poly-right##30 9.871
R4016 net@1821#14pmos@90_poly-right##30 net@1821#14pmos@90_poly-right##31 9.871
R4017 net@1821#14pmos@90_poly-right##31 net@1821#14pmos@90_poly-right##32 9.871
R4018 net@1821#14pmos@90_poly-right##32 net@1821#14pmos@90_poly-right##33 9.871
R4019 net@1821#14pmos@90_poly-right##33 net@1821#14pmos@90_poly-right##34 9.871
R4020 net@1821#14pmos@90_poly-right##34 net@1821#14pmos@90_poly-right##35 9.871
R4021 net@1821#14pmos@90_poly-right##35 net@1821#14pmos@90_poly-right##36 9.871
R4022 net@1821#14pmos@90_poly-right##36 net@1821#14pmos@90_poly-right##37 9.871
R4023 net@1821#14pmos@90_poly-right##37 net@1821#14pmos@90_poly-right##38 9.871
R4024 net@1821#14pmos@90_poly-right##38 net@1821#14pmos@90_poly-right##39 9.871
R4025 net@1821#14pmos@90_poly-right##39 net@1821#14pmos@90_poly-right##40 9.871
R4026 net@1821#14pmos@90_poly-right##40 net@1821#14pmos@90_poly-right##41 9.871
R4027 net@1821#14pmos@90_poly-right##41 net@1821#14pmos@90_poly-right##42 9.871
R4028 net@1821#14pmos@90_poly-right##42 net@1821#14pmos@90_poly-right##43 9.871
R4029 net@1821#14pmos@90_poly-right##43 net@1821#14pmos@90_poly-right##44 9.871
R4030 net@1821#14pmos@90_poly-right##44 net@1821#14pmos@90_poly-right##45 9.871
R4031 net@1821#14pmos@90_poly-right##45 net@1821#14pmos@90_poly-right##46 9.871
R4032 net@1821#14pmos@90_poly-right##46 net@1821#14pmos@90_poly-right##47 9.871
R4033 net@1821#14pmos@90_poly-right##47 net@1821#14pmos@90_poly-right##48 9.871
R4034 net@1821#14pmos@90_poly-right##48 net@1821#14pmos@90_poly-right##49 9.871
R4035 net@1821#14pmos@90_poly-right##49 net@1821#14pmos@90_poly-right##50 9.871
R4036 net@1821#14pmos@90_poly-right##50 net@1821#14pmos@90_poly-right##51 9.871
R4037 net@1821#14pmos@90_poly-right##51 net@1821#14pmos@90_poly-right##52 9.871
R4038 net@1821#14pmos@90_poly-right##52 net@1821#14pmos@90_poly-right##53 9.871
R4039 net@1821#14pmos@90_poly-right##53 net@1821#14pmos@90_poly-right##54 9.871
R4040 net@1821#14pmos@90_poly-right##54 net@1821#14pmos@90_poly-right##55 9.871
R4041 net@1821#14pmos@90_poly-right##55 net@1821#9nmos@90_poly-left 9.871
R4042 net@1820#2contact@642_metal-1-polysilicon-1 net@1820 4.654
R4043 net@1820#12pmos@93_poly-right net@1820#12pmos@93_poly-right##0 9.931
R4044 net@1820#12pmos@93_poly-right##0 net@1820#12pmos@93_poly-right##1 9.931
R4045 net@1820#12pmos@93_poly-right##1 net@1820#12pmos@93_poly-right##2 9.931
R4046 net@1820#12pmos@93_poly-right##2 net@1820#12pmos@93_poly-right##3 9.931
R4047 net@1820#12pmos@93_poly-right##3 net@1820#12pmos@93_poly-right##4 9.931
R4048 net@1820#12pmos@93_poly-right##4 net@1820#12pmos@93_poly-right##5 9.931
R4049 net@1820#12pmos@93_poly-right##5 net@1820#12pmos@93_poly-right##6 9.931
R4050 net@1820#12pmos@93_poly-right##6 net@1820#12pmos@93_poly-right##7 9.931
R4051 net@1820#12pmos@93_poly-right##7 net@1820#12pmos@93_poly-right##8 9.931
R4052 net@1820#12pmos@93_poly-right##8 net@1820#12pmos@93_poly-right##9 9.931
R4053 net@1820#12pmos@93_poly-right##9 net@1820#12pmos@93_poly-right##10 9.931
R4054 net@1820#12pmos@93_poly-right##10 net@1820#12pmos@93_poly-right##11 9.931
R4055 net@1820#12pmos@93_poly-right##11 net@1820#12pmos@93_poly-right##12 9.931
R4056 net@1820#12pmos@93_poly-right##12 net@1820#12pmos@93_poly-right##13 9.931
R4057 net@1820#12pmos@93_poly-right##13 net@1820#12pmos@93_poly-right##14 9.931
R4058 net@1820#12pmos@93_poly-right##14 net@1820#12pmos@93_poly-right##15 9.931
R4059 net@1820#12pmos@93_poly-right##15 net@1820#12pmos@93_poly-right##16 9.931
R4060 net@1820#12pmos@93_poly-right##16 net@1820#12pmos@93_poly-right##17 9.931
R4061 net@1820#12pmos@93_poly-right##17 net@1820#12pmos@93_poly-right##18 9.931
R4062 net@1820#12pmos@93_poly-right##18 net@1820#12pmos@93_poly-right##19 9.931
R4063 net@1820#12pmos@93_poly-right##19 net@1820#12pmos@93_poly-right##20 9.931
R4064 net@1820#12pmos@93_poly-right##20 net@1820#12pmos@93_poly-right##21 9.931
R4065 net@1820#12pmos@93_poly-right##21 net@1820#12pmos@93_poly-right##22 9.931
R4066 net@1820#12pmos@93_poly-right##22 net@1820#12pmos@93_poly-right##23 9.931
R4067 net@1820#12pmos@93_poly-right##23 net@1820#12pmos@93_poly-right##24 9.931
R4068 net@1820#12pmos@93_poly-right##24 net@1820#12pmos@93_poly-right##25 9.931
R4069 net@1820#12pmos@93_poly-right##25 net@1820#12pmos@93_poly-right##26 9.931
R4070 net@1820#12pmos@93_poly-right##26 net@1820#12pmos@93_poly-right##27 9.931
R4071 net@1820#12pmos@93_poly-right##27 net@1820#12pmos@93_poly-right##28 9.931
R4072 net@1820#12pmos@93_poly-right##28 net@1820#12pmos@93_poly-right##29 9.931
R4073 net@1820#12pmos@93_poly-right##29 net@1820#12pmos@93_poly-right##30 9.931
R4074 net@1820#12pmos@93_poly-right##30 net@1820#12pmos@93_poly-right##31 9.931
R4075 net@1820#12pmos@93_poly-right##31 net@1820#12pmos@93_poly-right##32 9.931
R4076 net@1820#12pmos@93_poly-right##32 net@1820#12pmos@93_poly-right##33 9.931
R4077 net@1820#12pmos@93_poly-right##33 net@1820#12pmos@93_poly-right##34 9.931
R4078 net@1820#12pmos@93_poly-right##34 net@1820#12pmos@93_poly-right##35 9.931
R4079 net@1820#12pmos@93_poly-right##35 net@1820#12pmos@93_poly-right##36 9.931
R4080 net@1820#12pmos@93_poly-right##36 net@1820#12pmos@93_poly-right##37 9.931
R4081 net@1820#12pmos@93_poly-right##37 net@1820#12pmos@93_poly-right##38 9.931
R4082 net@1820#12pmos@93_poly-right##38 net@1820#12pmos@93_poly-right##39 9.931
R4083 net@1820#12pmos@93_poly-right##39 net@1820#12pmos@93_poly-right##40 9.931
R4084 net@1820#12pmos@93_poly-right##40 net@1820#12pmos@93_poly-right##41 9.931
R4085 net@1820#12pmos@93_poly-right##41 net@1820#12pmos@93_poly-right##42 9.931
R4086 net@1820#12pmos@93_poly-right##42 net@1820#12pmos@93_poly-right##43 9.931
R4087 net@1820#12pmos@93_poly-right##43 net@1820#12pmos@93_poly-right##44 9.931
R4088 net@1820#12pmos@93_poly-right##44 net@1820#12pmos@93_poly-right##45 9.931
R4089 net@1820#12pmos@93_poly-right##45 net@1820#12pmos@93_poly-right##46 9.931
R4090 net@1820#12pmos@93_poly-right##46 net@1820#12pmos@93_poly-right##47 9.931
R4091 net@1820#12pmos@93_poly-right##47 net@1820#12pmos@93_poly-right##48 9.931
R4092 net@1820#12pmos@93_poly-right##48 net@1820#12pmos@93_poly-right##49 9.931
R4093 net@1820#12pmos@93_poly-right##49 net@1820#12pmos@93_poly-right##50 9.931
R4094 net@1820#12pmos@93_poly-right##50 net@1820#12pmos@93_poly-right##51 9.931
R4095 net@1820#12pmos@93_poly-right##51 net@1820#12pmos@93_poly-right##52 9.931
R4096 net@1820#12pmos@93_poly-right##52 net@1820#5pin@564_polysilicon-1 9.931
R4097 Sum2#4pmos@93_diff-top Sum2 4.823
R4098 XOR1_to_NAND3#14pin@576_polysilicon-1 XOR1_to_NAND3#14pin@576_polysilicon-1##0 9.854
R4099 XOR1_to_NAND3#14pin@576_polysilicon-1##0 XOR1_to_NAND3#14pin@576_polysilicon-1##1 9.854
R4100 XOR1_to_NAND3#14pin@576_polysilicon-1##1 XOR1_to_NAND3#14pin@576_polysilicon-1##2 9.854
R4101 XOR1_to_NAND3#14pin@576_polysilicon-1##2 XOR1_to_NAND3#14pin@576_polysilicon-1##3 9.854
R4102 XOR1_to_NAND3#14pin@576_polysilicon-1##3 XOR1_to_NAND3#14pin@576_polysilicon-1##4 9.854
R4103 XOR1_to_NAND3#14pin@576_polysilicon-1##4 XOR1_to_NAND3#14pin@576_polysilicon-1##5 9.854
R4104 XOR1_to_NAND3#14pin@576_polysilicon-1##5 XOR1_to_NAND3#14pin@576_polysilicon-1##6 9.854
R4105 XOR1_to_NAND3#14pin@576_polysilicon-1##6 XOR1_to_NAND3#14pin@576_polysilicon-1##7 9.854
R4106 XOR1_to_NAND3#14pin@576_polysilicon-1##7 XOR1_to_NAND3#14pin@576_polysilicon-1##8 9.854
R4107 XOR1_to_NAND3#14pin@576_polysilicon-1##8 XOR1_to_NAND3#14pin@576_polysilicon-1##9 9.854
R4108 XOR1_to_NAND3#14pin@576_polysilicon-1##9 XOR1_to_NAND3#14pin@576_polysilicon-1##10 9.854
R4109 XOR1_to_NAND3#14pin@576_polysilicon-1##10 XOR1_to_NAND3#14pin@576_polysilicon-1##11 9.854
R4110 XOR1_to_NAND3#14pin@576_polysilicon-1##11 XOR1_to_NAND3#14pin@576_polysilicon-1##12 9.854
R4111 XOR1_to_NAND3#14pin@576_polysilicon-1##12 XOR1_to_NAND3#14pin@576_polysilicon-1##13 9.854
R4112 XOR1_to_NAND3#14pin@576_polysilicon-1##13 XOR1_to_NAND3#14pin@576_polysilicon-1##14 9.854
R4113 XOR1_to_NAND3#14pin@576_polysilicon-1##14 XOR1_to_NAND3#14pin@576_polysilicon-1##15 9.854
R4114 XOR1_to_NAND3#14pin@576_polysilicon-1##15 XOR1_to_NAND3#14pin@576_polysilicon-1##16 9.854
R4115 XOR1_to_NAND3#14pin@576_polysilicon-1##16 XOR1_to_NAND3#14pin@576_polysilicon-1##17 9.854
R4116 XOR1_to_NAND3#14pin@576_polysilicon-1##17 XOR1_to_NAND3#14pin@576_polysilicon-1##18 9.854
R4117 XOR1_to_NAND3#14pin@576_polysilicon-1##18 XOR1_to_NAND3#14pin@576_polysilicon-1##19 9.854
R4118 XOR1_to_NAND3#14pin@576_polysilicon-1##19 XOR1_to_NAND3#14pin@576_polysilicon-1##20 9.854
R4119 XOR1_to_NAND3#14pin@576_polysilicon-1##20 XOR1_to_NAND3#14pin@576_polysilicon-1##21 9.854
R4120 XOR1_to_NAND3#14pin@576_polysilicon-1##21 XOR1_to_NAND3#14pin@576_polysilicon-1##22 9.854
R4121 XOR1_to_NAND3#14pin@576_polysilicon-1##22 XOR1_to_NAND3#14pin@576_polysilicon-1##23 9.854
R4122 XOR1_to_NAND3#14pin@576_polysilicon-1##23 XOR1_to_NAND3#14pin@576_polysilicon-1##24 9.854
R4123 XOR1_to_NAND3#14pin@576_polysilicon-1##24 XOR1_to_NAND3#14pin@576_polysilicon-1##25 9.854
R4124 XOR1_to_NAND3#14pin@576_polysilicon-1##25 XOR1_to_NAND3#14pin@576_polysilicon-1##26 9.854
R4125 XOR1_to_NAND3#14pin@576_polysilicon-1##26 XOR1_to_NAND3#14pin@576_polysilicon-1##27 9.854
R4126 XOR1_to_NAND3#14pin@576_polysilicon-1##27 XOR1_to_NAND3#14pin@576_polysilicon-1##28 9.854
R4127 XOR1_to_NAND3#14pin@576_polysilicon-1##28 XOR1_to_NAND3#14pin@576_polysilicon-1##29 9.854
R4128 XOR1_to_NAND3#14pin@576_polysilicon-1##29 XOR1_to_NAND3#14pin@576_polysilicon-1##30 9.854
R4129 XOR1_to_NAND3#14pin@576_polysilicon-1##30 XOR1_to_NAND3#14pin@576_polysilicon-1##31 9.854
R4130 XOR1_to_NAND3#14pin@576_polysilicon-1##31 XOR1_to_NAND3#14pin@576_polysilicon-1##32 9.854
R4131 XOR1_to_NAND3#14pin@576_polysilicon-1##32 XOR1_to_NAND3#14pin@576_polysilicon-1##33 9.854
R4132 XOR1_to_NAND3#14pin@576_polysilicon-1##33 XOR1_to_NAND3#14pin@576_polysilicon-1##34 9.854
R4133 XOR1_to_NAND3#14pin@576_polysilicon-1##34 XOR1_to_NAND3#14pin@576_polysilicon-1##35 9.854
R4134 XOR1_to_NAND3#14pin@576_polysilicon-1##35 XOR1_to_NAND3#14pin@576_polysilicon-1##36 9.854
R4135 XOR1_to_NAND3#14pin@576_polysilicon-1##36 XOR1_to_NAND3#14pin@576_polysilicon-1##37 9.854
R4136 XOR1_to_NAND3#14pin@576_polysilicon-1##37 XOR1_to_NAND3#14pin@576_polysilicon-1##38 9.854
R4137 XOR1_to_NAND3#14pin@576_polysilicon-1##38 XOR1_to_NAND3#14pin@576_polysilicon-1##39 9.854
R4138 XOR1_to_NAND3#14pin@576_polysilicon-1##39 XOR1_to_NAND3#14pin@576_polysilicon-1##40 9.854
R4139 XOR1_to_NAND3#14pin@576_polysilicon-1##40 XOR1_to_NAND3#14pin@576_polysilicon-1##41 9.854
R4140 XOR1_to_NAND3#14pin@576_polysilicon-1##41 XOR1_to_NAND3#14pin@576_polysilicon-1##42 9.854
R4141 XOR1_to_NAND3#14pin@576_polysilicon-1##42 XOR1_to_NAND3#14pin@576_polysilicon-1##43 9.854
R4142 XOR1_to_NAND3#14pin@576_polysilicon-1##43 XOR1_to_NAND3#14pin@576_polysilicon-1##44 9.854
R4143 XOR1_to_NAND3#14pin@576_polysilicon-1##44 XOR1_to_NAND3#14pin@576_polysilicon-1##45 9.854
R4144 XOR1_to_NAND3#14pin@576_polysilicon-1##45 XOR1_to_NAND3#14pin@576_polysilicon-1##46 9.854
R4145 XOR1_to_NAND3#14pin@576_polysilicon-1##46 XOR1_to_NAND3#14pin@576_polysilicon-1##47 9.854
R4146 XOR1_to_NAND3#14pin@576_polysilicon-1##47 XOR1_to_NAND3#14pin@576_polysilicon-1##48 9.854
R4147 XOR1_to_NAND3#14pin@576_polysilicon-1##48 XOR1_to_NAND3#14pin@576_polysilicon-1##49 9.854
R4148 XOR1_to_NAND3#14pin@576_polysilicon-1##49 XOR1_to_NAND3#14pin@576_polysilicon-1##50 9.854
R4149 XOR1_to_NAND3#14pin@576_polysilicon-1##50 XOR1_to_NAND3#14pin@576_polysilicon-1##51 9.854
R4150 XOR1_to_NAND3#14pin@576_polysilicon-1##51 XOR1_to_NAND3#14pin@576_polysilicon-1##52 9.854
R4151 XOR1_to_NAND3#14pin@576_polysilicon-1##52 XOR1_to_NAND3#14pin@576_polysilicon-1##53 9.854
R4152 XOR1_to_NAND3#14pin@576_polysilicon-1##53 XOR1_to_NAND3#14pin@576_polysilicon-1##54 9.854
R4153 XOR1_to_NAND3#14pin@576_polysilicon-1##54 XOR1_to_NAND3#27nmos@94_poly-right 9.854
R4154 Cin_to_XOR2___NAND3#37pmos@95_poly-right Cin_to_XOR2___NAND3#37pmos@95_poly-right##0 9.877
R4155 Cin_to_XOR2___NAND3#37pmos@95_poly-right##0 Cin_to_XOR2___NAND3#37pmos@95_poly-right##1 9.877
R4156 Cin_to_XOR2___NAND3#37pmos@95_poly-right##1 Cin_to_XOR2___NAND3#37pmos@95_poly-right##2 9.877
R4157 Cin_to_XOR2___NAND3#37pmos@95_poly-right##2 Cin_to_XOR2___NAND3#37pmos@95_poly-right##3 9.877
R4158 Cin_to_XOR2___NAND3#37pmos@95_poly-right##3 Cin_to_XOR2___NAND3#37pmos@95_poly-right##4 9.877
R4159 Cin_to_XOR2___NAND3#37pmos@95_poly-right##4 Cin_to_XOR2___NAND3#37pmos@95_poly-right##5 9.877
R4160 Cin_to_XOR2___NAND3#37pmos@95_poly-right##5 Cin_to_XOR2___NAND3#37pmos@95_poly-right##6 9.877
R4161 Cin_to_XOR2___NAND3#37pmos@95_poly-right##6 Cin_to_XOR2___NAND3#37pmos@95_poly-right##7 9.877
R4162 Cin_to_XOR2___NAND3#37pmos@95_poly-right##7 Cin_to_XOR2___NAND3#37pmos@95_poly-right##8 9.877
R4163 Cin_to_XOR2___NAND3#37pmos@95_poly-right##8 Cin_to_XOR2___NAND3#37pmos@95_poly-right##9 9.877
R4164 Cin_to_XOR2___NAND3#37pmos@95_poly-right##9 Cin_to_XOR2___NAND3#37pmos@95_poly-right##10 9.877
R4165 Cin_to_XOR2___NAND3#37pmos@95_poly-right##10 Cin_to_XOR2___NAND3#37pmos@95_poly-right##11 9.877
R4166 Cin_to_XOR2___NAND3#37pmos@95_poly-right##11 Cin_to_XOR2___NAND3#37pmos@95_poly-right##12 9.877
R4167 Cin_to_XOR2___NAND3#37pmos@95_poly-right##12 Cin_to_XOR2___NAND3#37pmos@95_poly-right##13 9.877
R4168 Cin_to_XOR2___NAND3#37pmos@95_poly-right##13 Cin_to_XOR2___NAND3#37pmos@95_poly-right##14 9.877
R4169 Cin_to_XOR2___NAND3#37pmos@95_poly-right##14 Cin_to_XOR2___NAND3#37pmos@95_poly-right##15 9.877
R4170 Cin_to_XOR2___NAND3#37pmos@95_poly-right##15 Cin_to_XOR2___NAND3#37pmos@95_poly-right##16 9.877
R4171 Cin_to_XOR2___NAND3#37pmos@95_poly-right##16 Cin_to_XOR2___NAND3#37pmos@95_poly-right##17 9.877
R4172 Cin_to_XOR2___NAND3#37pmos@95_poly-right##17 Cin_to_XOR2___NAND3#37pmos@95_poly-right##18 9.877
R4173 Cin_to_XOR2___NAND3#37pmos@95_poly-right##18 Cin_to_XOR2___NAND3#37pmos@95_poly-right##19 9.877
R4174 Cin_to_XOR2___NAND3#37pmos@95_poly-right##19 Cin_to_XOR2___NAND3#37pmos@95_poly-right##20 9.877
R4175 Cin_to_XOR2___NAND3#37pmos@95_poly-right##20 Cin_to_XOR2___NAND3#37pmos@95_poly-right##21 9.877
R4176 Cin_to_XOR2___NAND3#37pmos@95_poly-right##21 Cin_to_XOR2___NAND3#37pmos@95_poly-right##22 9.877
R4177 Cin_to_XOR2___NAND3#37pmos@95_poly-right##22 Cin_to_XOR2___NAND3#37pmos@95_poly-right##23 9.877
R4178 Cin_to_XOR2___NAND3#37pmos@95_poly-right##23 Cin_to_XOR2___NAND3#37pmos@95_poly-right##24 9.877
R4179 Cin_to_XOR2___NAND3#37pmos@95_poly-right##24 Cin_to_XOR2___NAND3#37pmos@95_poly-right##25 9.877
R4180 Cin_to_XOR2___NAND3#37pmos@95_poly-right##25 Cin_to_XOR2___NAND3#37pmos@95_poly-right##26 9.877
R4181 Cin_to_XOR2___NAND3#37pmos@95_poly-right##26 Cin_to_XOR2___NAND3#37pmos@95_poly-right##27 9.877
R4182 Cin_to_XOR2___NAND3#37pmos@95_poly-right##27 Cin_to_XOR2___NAND3#37pmos@95_poly-right##28 9.877
R4183 Cin_to_XOR2___NAND3#37pmos@95_poly-right##28 Cin_to_XOR2___NAND3#37pmos@95_poly-right##29 9.877
R4184 Cin_to_XOR2___NAND3#37pmos@95_poly-right##29 Cin_to_XOR2___NAND3#37pmos@95_poly-right##30 9.877
R4185 Cin_to_XOR2___NAND3#37pmos@95_poly-right##30 Cin_to_XOR2___NAND3#37pmos@95_poly-right##31 9.877
R4186 Cin_to_XOR2___NAND3#37pmos@95_poly-right##31 Cin_to_XOR2___NAND3#37pmos@95_poly-right##32 9.877
R4187 Cin_to_XOR2___NAND3#37pmos@95_poly-right##32 Cin_to_XOR2___NAND3#37pmos@95_poly-right##33 9.877
R4188 Cin_to_XOR2___NAND3#37pmos@95_poly-right##33 Cin_to_XOR2___NAND3#37pmos@95_poly-right##34 9.877
R4189 Cin_to_XOR2___NAND3#37pmos@95_poly-right##34 Cin_to_XOR2___NAND3#37pmos@95_poly-right##35 9.877
R4190 Cin_to_XOR2___NAND3#37pmos@95_poly-right##35 Cin_to_XOR2___NAND3#37pmos@95_poly-right##36 9.877
R4191 Cin_to_XOR2___NAND3#37pmos@95_poly-right##36 Cin_to_XOR2___NAND3#37pmos@95_poly-right##37 9.877
R4192 Cin_to_XOR2___NAND3#37pmos@95_poly-right##37 Cin_to_XOR2___NAND3#37pmos@95_poly-right##38 9.877
R4193 Cin_to_XOR2___NAND3#37pmos@95_poly-right##38 Cin_to_XOR2___NAND3#37pmos@95_poly-right##39 9.877
R4194 Cin_to_XOR2___NAND3#37pmos@95_poly-right##39 Cin_to_XOR2___NAND3#37pmos@95_poly-right##40 9.877
R4195 Cin_to_XOR2___NAND3#37pmos@95_poly-right##40 Cin_to_XOR2___NAND3#37pmos@95_poly-right##41 9.877
R4196 Cin_to_XOR2___NAND3#37pmos@95_poly-right##41 Cin_to_XOR2___NAND3#37pmos@95_poly-right##42 9.877
R4197 Cin_to_XOR2___NAND3#37pmos@95_poly-right##42 Cin_to_XOR2___NAND3#37pmos@95_poly-right##43 9.877
R4198 Cin_to_XOR2___NAND3#37pmos@95_poly-right##43 Cin_to_XOR2___NAND3#37pmos@95_poly-right##44 9.877
R4199 Cin_to_XOR2___NAND3#37pmos@95_poly-right##44 Cin_to_XOR2___NAND3#37pmos@95_poly-right##45 9.877
R4200 Cin_to_XOR2___NAND3#37pmos@95_poly-right##45 Cin_to_XOR2___NAND3#37pmos@95_poly-right##46 9.877
R4201 Cin_to_XOR2___NAND3#37pmos@95_poly-right##46 Cin_to_XOR2___NAND3#37pmos@95_poly-right##47 9.877
R4202 Cin_to_XOR2___NAND3#37pmos@95_poly-right##47 Cin_to_XOR2___NAND3#37pmos@95_poly-right##48 9.877
R4203 Cin_to_XOR2___NAND3#37pmos@95_poly-right##48 Cin_to_XOR2___NAND3#37pmos@95_poly-right##49 9.877
R4204 Cin_to_XOR2___NAND3#37pmos@95_poly-right##49 Cin_to_XOR2___NAND3#31pin@580_polysilicon-1 9.877
R4205 NAND1_to_NAND5 NAND1_to_NAND5#4nmos@95_diff-bottom 4.823
R4206 A2#10pin@583_polysilicon-1 A2#10pin@583_polysilicon-1##0 9.938
R4207 A2#10pin@583_polysilicon-1##0 A2#10pin@583_polysilicon-1##1 9.938
R4208 A2#10pin@583_polysilicon-1##1 A2#10pin@583_polysilicon-1##2 9.938
R4209 A2#10pin@583_polysilicon-1##2 A2#10pin@583_polysilicon-1##3 9.938
R4210 A2#10pin@583_polysilicon-1##3 A2#10pin@583_polysilicon-1##4 9.938
R4211 A2#10pin@583_polysilicon-1##4 A2#10pin@583_polysilicon-1##5 9.938
R4212 A2#10pin@583_polysilicon-1##5 A2#10pin@583_polysilicon-1##6 9.938
R4213 A2#10pin@583_polysilicon-1##6 A2#10pin@583_polysilicon-1##7 9.938
R4214 A2#10pin@583_polysilicon-1##7 A2#10pin@583_polysilicon-1##8 9.938
R4215 A2#10pin@583_polysilicon-1##8 A2#10pin@583_polysilicon-1##9 9.938
R4216 A2#10pin@583_polysilicon-1##9 A2#10pin@583_polysilicon-1##10 9.938
R4217 A2#10pin@583_polysilicon-1##10 A2#10pin@583_polysilicon-1##11 9.938
R4218 A2#10pin@583_polysilicon-1##11 A2#10pin@583_polysilicon-1##12 9.938
R4219 A2#10pin@583_polysilicon-1##12 A2#10pin@583_polysilicon-1##13 9.938
R4220 A2#10pin@583_polysilicon-1##13 A2#10pin@583_polysilicon-1##14 9.938
R4221 A2#10pin@583_polysilicon-1##14 A2#10pin@583_polysilicon-1##15 9.938
R4222 A2#10pin@583_polysilicon-1##15 A2#10pin@583_polysilicon-1##16 9.938
R4223 A2#10pin@583_polysilicon-1##16 A2#10pin@583_polysilicon-1##17 9.938
R4224 A2#10pin@583_polysilicon-1##17 A2#10pin@583_polysilicon-1##18 9.938
R4225 A2#10pin@583_polysilicon-1##18 A2#10pin@583_polysilicon-1##19 9.938
R4226 A2#10pin@583_polysilicon-1##19 A2#10pin@583_polysilicon-1##20 9.938
R4227 A2#10pin@583_polysilicon-1##20 A2#10pin@583_polysilicon-1##21 9.938
R4228 A2#10pin@583_polysilicon-1##21 A2#10pin@583_polysilicon-1##22 9.938
R4229 A2#10pin@583_polysilicon-1##22 A2#10pin@583_polysilicon-1##23 9.938
R4230 A2#10pin@583_polysilicon-1##23 A2#10pin@583_polysilicon-1##24 9.938
R4231 A2#10pin@583_polysilicon-1##24 A2#10pin@583_polysilicon-1##25 9.938
R4232 A2#10pin@583_polysilicon-1##25 A2#10pin@583_polysilicon-1##26 9.938
R4233 A2#10pin@583_polysilicon-1##26 A2#10pin@583_polysilicon-1##27 9.938
R4234 A2#10pin@583_polysilicon-1##27 A2#10pin@583_polysilicon-1##28 9.938
R4235 A2#10pin@583_polysilicon-1##28 A2#10pin@583_polysilicon-1##29 9.938
R4236 A2#10pin@583_polysilicon-1##29 A2#10pin@583_polysilicon-1##30 9.938
R4237 A2#10pin@583_polysilicon-1##30 A2#10pin@583_polysilicon-1##31 9.938
R4238 A2#10pin@583_polysilicon-1##31 A2#10pin@583_polysilicon-1##32 9.938
R4239 A2#10pin@583_polysilicon-1##32 A2#10pin@583_polysilicon-1##33 9.938
R4240 A2#10pin@583_polysilicon-1##33 A2#10pin@583_polysilicon-1##34 9.938
R4241 A2#10pin@583_polysilicon-1##34 A2#10pin@583_polysilicon-1##35 9.938
R4242 A2#10pin@583_polysilicon-1##35 A2#10pin@583_polysilicon-1##36 9.938
R4243 A2#10pin@583_polysilicon-1##36 A2#10pin@583_polysilicon-1##37 9.938
R4244 A2#10pin@583_polysilicon-1##37 A2#10pin@583_polysilicon-1##38 9.938
R4245 A2#10pin@583_polysilicon-1##38 A2#10pin@583_polysilicon-1##39 9.938
R4246 A2#10pin@583_polysilicon-1##39 A2#10pin@583_polysilicon-1##40 9.938
R4247 A2#10pin@583_polysilicon-1##40 A2#10pin@583_polysilicon-1##41 9.938
R4248 A2#10pin@583_polysilicon-1##41 A2#10pin@583_polysilicon-1##42 9.938
R4249 A2#10pin@583_polysilicon-1##42 A2#10pin@583_polysilicon-1##43 9.938
R4250 A2#10pin@583_polysilicon-1##43 A2#10pin@583_polysilicon-1##44 9.938
R4251 A2#10pin@583_polysilicon-1##44 A2#10pin@583_polysilicon-1##45 9.938
R4252 A2#10pin@583_polysilicon-1##45 A2#10pin@583_polysilicon-1##46 9.938
R4253 A2#10pin@583_polysilicon-1##46 A2#10pin@583_polysilicon-1##47 9.938
R4254 A2#10pin@583_polysilicon-1##47 A2#10pin@583_polysilicon-1##48 9.938
R4255 A2#10pin@583_polysilicon-1##48 A2#10pin@583_polysilicon-1##49 9.938
R4256 A2#10pin@583_polysilicon-1##49 A2#19nmos@96_poly-right 9.938
R4257 B2#20pmos@97_poly-right B2#20pmos@97_poly-right##0 9.869
R4258 B2#20pmos@97_poly-right##0 B2#20pmos@97_poly-right##1 9.869
R4259 B2#20pmos@97_poly-right##1 B2#20pmos@97_poly-right##2 9.869
R4260 B2#20pmos@97_poly-right##2 B2#20pmos@97_poly-right##3 9.869
R4261 B2#20pmos@97_poly-right##3 B2#20pmos@97_poly-right##4 9.869
R4262 B2#20pmos@97_poly-right##4 B2#20pmos@97_poly-right##5 9.869
R4263 B2#20pmos@97_poly-right##5 B2#20pmos@97_poly-right##6 9.869
R4264 B2#20pmos@97_poly-right##6 B2#20pmos@97_poly-right##7 9.869
R4265 B2#20pmos@97_poly-right##7 B2#20pmos@97_poly-right##8 9.869
R4266 B2#20pmos@97_poly-right##8 B2#20pmos@97_poly-right##9 9.869
R4267 B2#20pmos@97_poly-right##9 B2#20pmos@97_poly-right##10 9.869
R4268 B2#20pmos@97_poly-right##10 B2#20pmos@97_poly-right##11 9.869
R4269 B2#20pmos@97_poly-right##11 B2#20pmos@97_poly-right##12 9.869
R4270 B2#20pmos@97_poly-right##12 B2#20pmos@97_poly-right##13 9.869
R4271 B2#20pmos@97_poly-right##13 B2#20pmos@97_poly-right##14 9.869
R4272 B2#20pmos@97_poly-right##14 B2#20pmos@97_poly-right##15 9.869
R4273 B2#20pmos@97_poly-right##15 B2#20pmos@97_poly-right##16 9.869
R4274 B2#20pmos@97_poly-right##16 B2#20pmos@97_poly-right##17 9.869
R4275 B2#20pmos@97_poly-right##17 B2#20pmos@97_poly-right##18 9.869
R4276 B2#20pmos@97_poly-right##18 B2#20pmos@97_poly-right##19 9.869
R4277 B2#20pmos@97_poly-right##19 B2#20pmos@97_poly-right##20 9.869
R4278 B2#20pmos@97_poly-right##20 B2#20pmos@97_poly-right##21 9.869
R4279 B2#20pmos@97_poly-right##21 B2#20pmos@97_poly-right##22 9.869
R4280 B2#20pmos@97_poly-right##22 B2#20pmos@97_poly-right##23 9.869
R4281 B2#20pmos@97_poly-right##23 B2#20pmos@97_poly-right##24 9.869
R4282 B2#20pmos@97_poly-right##24 B2#20pmos@97_poly-right##25 9.869
R4283 B2#20pmos@97_poly-right##25 B2#20pmos@97_poly-right##26 9.869
R4284 B2#20pmos@97_poly-right##26 B2#20pmos@97_poly-right##27 9.869
R4285 B2#20pmos@97_poly-right##27 B2#20pmos@97_poly-right##28 9.869
R4286 B2#20pmos@97_poly-right##28 B2#20pmos@97_poly-right##29 9.869
R4287 B2#20pmos@97_poly-right##29 B2#20pmos@97_poly-right##30 9.869
R4288 B2#20pmos@97_poly-right##30 B2#20pmos@97_poly-right##31 9.869
R4289 B2#20pmos@97_poly-right##31 B2#20pmos@97_poly-right##32 9.869
R4290 B2#20pmos@97_poly-right##32 B2#20pmos@97_poly-right##33 9.869
R4291 B2#20pmos@97_poly-right##33 B2#20pmos@97_poly-right##34 9.869
R4292 B2#20pmos@97_poly-right##34 B2#20pmos@97_poly-right##35 9.869
R4293 B2#20pmos@97_poly-right##35 B2#20pmos@97_poly-right##36 9.869
R4294 B2#20pmos@97_poly-right##36 B2#20pmos@97_poly-right##37 9.869
R4295 B2#20pmos@97_poly-right##37 B2#20pmos@97_poly-right##38 9.869
R4296 B2#20pmos@97_poly-right##38 B2#20pmos@97_poly-right##39 9.869
R4297 B2#20pmos@97_poly-right##39 B2#20pmos@97_poly-right##40 9.869
R4298 B2#20pmos@97_poly-right##40 B2#20pmos@97_poly-right##41 9.869
R4299 B2#20pmos@97_poly-right##41 B2#20pmos@97_poly-right##42 9.869
R4300 B2#20pmos@97_poly-right##42 B2#20pmos@97_poly-right##43 9.869
R4301 B2#20pmos@97_poly-right##43 B2#20pmos@97_poly-right##44 9.869
R4302 B2#20pmos@97_poly-right##44 B2#20pmos@97_poly-right##45 9.869
R4303 B2#20pmos@97_poly-right##45 B2#20pmos@97_poly-right##46 9.869
R4304 B2#20pmos@97_poly-right##46 B2#20pmos@97_poly-right##47 9.869
R4305 B2#20pmos@97_poly-right##47 B2#10pin@587_polysilicon-1 9.869
R4306 NAND2_to_Nand5#9pin@589_polysilicon-1 NAND2_to_Nand5#9pin@589_polysilicon-1##0 9.938
R4307 NAND2_to_Nand5#9pin@589_polysilicon-1##0 NAND2_to_Nand5#9pin@589_polysilicon-1##1 9.938
R4308 NAND2_to_Nand5#9pin@589_polysilicon-1##1 NAND2_to_Nand5#9pin@589_polysilicon-1##2 9.938
R4309 NAND2_to_Nand5#9pin@589_polysilicon-1##2 NAND2_to_Nand5#9pin@589_polysilicon-1##3 9.938
R4310 NAND2_to_Nand5#9pin@589_polysilicon-1##3 NAND2_to_Nand5#9pin@589_polysilicon-1##4 9.938
R4311 NAND2_to_Nand5#9pin@589_polysilicon-1##4 NAND2_to_Nand5#9pin@589_polysilicon-1##5 9.938
R4312 NAND2_to_Nand5#9pin@589_polysilicon-1##5 NAND2_to_Nand5#9pin@589_polysilicon-1##6 9.938
R4313 NAND2_to_Nand5#9pin@589_polysilicon-1##6 NAND2_to_Nand5#9pin@589_polysilicon-1##7 9.938
R4314 NAND2_to_Nand5#9pin@589_polysilicon-1##7 NAND2_to_Nand5#9pin@589_polysilicon-1##8 9.938
R4315 NAND2_to_Nand5#9pin@589_polysilicon-1##8 NAND2_to_Nand5#9pin@589_polysilicon-1##9 9.938
R4316 NAND2_to_Nand5#9pin@589_polysilicon-1##9 NAND2_to_Nand5#9pin@589_polysilicon-1##10 9.938
R4317 NAND2_to_Nand5#9pin@589_polysilicon-1##10 NAND2_to_Nand5#9pin@589_polysilicon-1##11 9.938
R4318 NAND2_to_Nand5#9pin@589_polysilicon-1##11 NAND2_to_Nand5#9pin@589_polysilicon-1##12 9.938
R4319 NAND2_to_Nand5#9pin@589_polysilicon-1##12 NAND2_to_Nand5#9pin@589_polysilicon-1##13 9.938
R4320 NAND2_to_Nand5#9pin@589_polysilicon-1##13 NAND2_to_Nand5#9pin@589_polysilicon-1##14 9.938
R4321 NAND2_to_Nand5#9pin@589_polysilicon-1##14 NAND2_to_Nand5#9pin@589_polysilicon-1##15 9.938
R4322 NAND2_to_Nand5#9pin@589_polysilicon-1##15 NAND2_to_Nand5#9pin@589_polysilicon-1##16 9.938
R4323 NAND2_to_Nand5#9pin@589_polysilicon-1##16 NAND2_to_Nand5#9pin@589_polysilicon-1##17 9.938
R4324 NAND2_to_Nand5#9pin@589_polysilicon-1##17 NAND2_to_Nand5#9pin@589_polysilicon-1##18 9.938
R4325 NAND2_to_Nand5#9pin@589_polysilicon-1##18 NAND2_to_Nand5#9pin@589_polysilicon-1##19 9.938
R4326 NAND2_to_Nand5#9pin@589_polysilicon-1##19 NAND2_to_Nand5#9pin@589_polysilicon-1##20 9.938
R4327 NAND2_to_Nand5#9pin@589_polysilicon-1##20 NAND2_to_Nand5#9pin@589_polysilicon-1##21 9.938
R4328 NAND2_to_Nand5#9pin@589_polysilicon-1##21 NAND2_to_Nand5#9pin@589_polysilicon-1##22 9.938
R4329 NAND2_to_Nand5#9pin@589_polysilicon-1##22 NAND2_to_Nand5#9pin@589_polysilicon-1##23 9.938
R4330 NAND2_to_Nand5#9pin@589_polysilicon-1##23 NAND2_to_Nand5#9pin@589_polysilicon-1##24 9.938
R4331 NAND2_to_Nand5#9pin@589_polysilicon-1##24 NAND2_to_Nand5#9pin@589_polysilicon-1##25 9.938
R4332 NAND2_to_Nand5#9pin@589_polysilicon-1##25 NAND2_to_Nand5#9pin@589_polysilicon-1##26 9.938
R4333 NAND2_to_Nand5#9pin@589_polysilicon-1##26 NAND2_to_Nand5#9pin@589_polysilicon-1##27 9.938
R4334 NAND2_to_Nand5#9pin@589_polysilicon-1##27 NAND2_to_Nand5#9pin@589_polysilicon-1##28 9.938
R4335 NAND2_to_Nand5#9pin@589_polysilicon-1##28 NAND2_to_Nand5#9pin@589_polysilicon-1##29 9.938
R4336 NAND2_to_Nand5#9pin@589_polysilicon-1##29 NAND2_to_Nand5#9pin@589_polysilicon-1##30 9.938
R4337 NAND2_to_Nand5#9pin@589_polysilicon-1##30 NAND2_to_Nand5#9pin@589_polysilicon-1##31 9.938
R4338 NAND2_to_Nand5#9pin@589_polysilicon-1##31 NAND2_to_Nand5#9pin@589_polysilicon-1##32 9.938
R4339 NAND2_to_Nand5#9pin@589_polysilicon-1##32 NAND2_to_Nand5#9pin@589_polysilicon-1##33 9.938
R4340 NAND2_to_Nand5#9pin@589_polysilicon-1##33 NAND2_to_Nand5#9pin@589_polysilicon-1##34 9.938
R4341 NAND2_to_Nand5#9pin@589_polysilicon-1##34 NAND2_to_Nand5#9pin@589_polysilicon-1##35 9.938
R4342 NAND2_to_Nand5#9pin@589_polysilicon-1##35 NAND2_to_Nand5#9pin@589_polysilicon-1##36 9.938
R4343 NAND2_to_Nand5#9pin@589_polysilicon-1##36 NAND2_to_Nand5#9pin@589_polysilicon-1##37 9.938
R4344 NAND2_to_Nand5#9pin@589_polysilicon-1##37 NAND2_to_Nand5#9pin@589_polysilicon-1##38 9.938
R4345 NAND2_to_Nand5#9pin@589_polysilicon-1##38 NAND2_to_Nand5#9pin@589_polysilicon-1##39 9.938
R4346 NAND2_to_Nand5#9pin@589_polysilicon-1##39 NAND2_to_Nand5#9pin@589_polysilicon-1##40 9.938
R4347 NAND2_to_Nand5#9pin@589_polysilicon-1##40 NAND2_to_Nand5#9pin@589_polysilicon-1##41 9.938
R4348 NAND2_to_Nand5#9pin@589_polysilicon-1##41 NAND2_to_Nand5#9pin@589_polysilicon-1##42 9.938
R4349 NAND2_to_Nand5#9pin@589_polysilicon-1##42 NAND2_to_Nand5#9pin@589_polysilicon-1##43 9.938
R4350 NAND2_to_Nand5#9pin@589_polysilicon-1##43 NAND2_to_Nand5#9pin@589_polysilicon-1##44 9.938
R4351 NAND2_to_Nand5#9pin@589_polysilicon-1##44 NAND2_to_Nand5#9pin@589_polysilicon-1##45 9.938
R4352 NAND2_to_Nand5#9pin@589_polysilicon-1##45 NAND2_to_Nand5#9pin@589_polysilicon-1##46 9.938
R4353 NAND2_to_Nand5#9pin@589_polysilicon-1##46 NAND2_to_Nand5#9pin@589_polysilicon-1##47 9.938
R4354 NAND2_to_Nand5#9pin@589_polysilicon-1##47 NAND2_to_Nand5#9pin@589_polysilicon-1##48 9.938
R4355 NAND2_to_Nand5#9pin@589_polysilicon-1##48 NAND2_to_Nand5#9pin@589_polysilicon-1##49 9.938
R4356 NAND2_to_Nand5#9pin@589_polysilicon-1##49 NAND2_to_Nand5#11nmos@98_poly-right 9.938
R4357 NAND1_to_NAND5#14nmos@99_poly-right NAND1_to_NAND5#14nmos@99_poly-right##0 9.898
R4358 NAND1_to_NAND5#14nmos@99_poly-right##0 NAND1_to_NAND5#14nmos@99_poly-right##1 9.898
R4359 NAND1_to_NAND5#14nmos@99_poly-right##1 NAND1_to_NAND5#14nmos@99_poly-right##2 9.898
R4360 NAND1_to_NAND5#14nmos@99_poly-right##2 NAND1_to_NAND5#14nmos@99_poly-right##3 9.898
R4361 NAND1_to_NAND5#14nmos@99_poly-right##3 NAND1_to_NAND5#14nmos@99_poly-right##4 9.898
R4362 NAND1_to_NAND5#14nmos@99_poly-right##4 NAND1_to_NAND5#14nmos@99_poly-right##5 9.898
R4363 NAND1_to_NAND5#14nmos@99_poly-right##5 NAND1_to_NAND5#14nmos@99_poly-right##6 9.898
R4364 NAND1_to_NAND5#14nmos@99_poly-right##6 NAND1_to_NAND5#14nmos@99_poly-right##7 9.898
R4365 NAND1_to_NAND5#14nmos@99_poly-right##7 NAND1_to_NAND5#14nmos@99_poly-right##8 9.898
R4366 NAND1_to_NAND5#14nmos@99_poly-right##8 NAND1_to_NAND5#14nmos@99_poly-right##9 9.898
R4367 NAND1_to_NAND5#14nmos@99_poly-right##9 NAND1_to_NAND5#14nmos@99_poly-right##10 9.898
R4368 NAND1_to_NAND5#14nmos@99_poly-right##10 NAND1_to_NAND5#14nmos@99_poly-right##11 9.898
R4369 NAND1_to_NAND5#14nmos@99_poly-right##11 NAND1_to_NAND5#14nmos@99_poly-right##12 9.898
R4370 NAND1_to_NAND5#14nmos@99_poly-right##12 NAND1_to_NAND5#14nmos@99_poly-right##13 9.898
R4371 NAND1_to_NAND5#14nmos@99_poly-right##13 NAND1_to_NAND5#14nmos@99_poly-right##14 9.898
R4372 NAND1_to_NAND5#14nmos@99_poly-right##14 NAND1_to_NAND5#14nmos@99_poly-right##15 9.898
R4373 NAND1_to_NAND5#14nmos@99_poly-right##15 NAND1_to_NAND5#14nmos@99_poly-right##16 9.898
R4374 NAND1_to_NAND5#14nmos@99_poly-right##16 NAND1_to_NAND5#14nmos@99_poly-right##17 9.898
R4375 NAND1_to_NAND5#14nmos@99_poly-right##17 NAND1_to_NAND5#14nmos@99_poly-right##18 9.898
R4376 NAND1_to_NAND5#14nmos@99_poly-right##18 NAND1_to_NAND5#14nmos@99_poly-right##19 9.898
R4377 NAND1_to_NAND5#14nmos@99_poly-right##19 NAND1_to_NAND5#14nmos@99_poly-right##20 9.898
R4378 NAND1_to_NAND5#14nmos@99_poly-right##20 NAND1_to_NAND5#14nmos@99_poly-right##21 9.898
R4379 NAND1_to_NAND5#14nmos@99_poly-right##21 NAND1_to_NAND5#14nmos@99_poly-right##22 9.898
R4380 NAND1_to_NAND5#14nmos@99_poly-right##22 NAND1_to_NAND5#14nmos@99_poly-right##23 9.898
R4381 NAND1_to_NAND5#14nmos@99_poly-right##23 NAND1_to_NAND5#14nmos@99_poly-right##24 9.898
R4382 NAND1_to_NAND5#14nmos@99_poly-right##24 NAND1_to_NAND5#14nmos@99_poly-right##25 9.898
R4383 NAND1_to_NAND5#14nmos@99_poly-right##25 NAND1_to_NAND5#14nmos@99_poly-right##26 9.898
R4384 NAND1_to_NAND5#14nmos@99_poly-right##26 NAND1_to_NAND5#14nmos@99_poly-right##27 9.898
R4385 NAND1_to_NAND5#14nmos@99_poly-right##27 NAND1_to_NAND5#14nmos@99_poly-right##28 9.898
R4386 NAND1_to_NAND5#14nmos@99_poly-right##28 NAND1_to_NAND5#14nmos@99_poly-right##29 9.898
R4387 NAND1_to_NAND5#14nmos@99_poly-right##29 NAND1_to_NAND5#14nmos@99_poly-right##30 9.898
R4388 NAND1_to_NAND5#14nmos@99_poly-right##30 NAND1_to_NAND5#14nmos@99_poly-right##31 9.898
R4389 NAND1_to_NAND5#14nmos@99_poly-right##31 NAND1_to_NAND5#14nmos@99_poly-right##32 9.898
R4390 NAND1_to_NAND5#14nmos@99_poly-right##32 NAND1_to_NAND5#14nmos@99_poly-right##33 9.898
R4391 NAND1_to_NAND5#14nmos@99_poly-right##33 NAND1_to_NAND5#14nmos@99_poly-right##34 9.898
R4392 NAND1_to_NAND5#14nmos@99_poly-right##34 NAND1_to_NAND5#14nmos@99_poly-right##35 9.898
R4393 NAND1_to_NAND5#14nmos@99_poly-right##35 NAND1_to_NAND5#14nmos@99_poly-right##36 9.898
R4394 NAND1_to_NAND5#14nmos@99_poly-right##36 NAND1_to_NAND5#14nmos@99_poly-right##37 9.898
R4395 NAND1_to_NAND5#14nmos@99_poly-right##37 NAND1_to_NAND5#14nmos@99_poly-right##38 9.898
R4396 NAND1_to_NAND5#14nmos@99_poly-right##38 NAND1_to_NAND5#14nmos@99_poly-right##39 9.898
R4397 NAND1_to_NAND5#14nmos@99_poly-right##39 NAND1_to_NAND5#14nmos@99_poly-right##40 9.898
R4398 NAND1_to_NAND5#14nmos@99_poly-right##40 NAND1_to_NAND5#14nmos@99_poly-right##41 9.898
R4399 NAND1_to_NAND5#14nmos@99_poly-right##41 NAND1_to_NAND5#14nmos@99_poly-right##42 9.898
R4400 NAND1_to_NAND5#14nmos@99_poly-right##42 NAND1_to_NAND5#14nmos@99_poly-right##43 9.898
R4401 NAND1_to_NAND5#14nmos@99_poly-right##43 NAND1_to_NAND5#14nmos@99_poly-right##44 9.898
R4402 NAND1_to_NAND5#14nmos@99_poly-right##44 NAND1_to_NAND5#14nmos@99_poly-right##45 9.898
R4403 NAND1_to_NAND5#14nmos@99_poly-right##45 NAND1_to_NAND5#14nmos@99_poly-right##46 9.898
R4404 NAND1_to_NAND5#14nmos@99_poly-right##46 NAND1_to_NAND5#14nmos@99_poly-right##47 9.898
R4405 NAND1_to_NAND5#14nmos@99_poly-right##47 NAND1_to_NAND5#14nmos@99_poly-right##48 9.898
R4406 NAND1_to_NAND5#14nmos@99_poly-right##48 NAND1_to_NAND5#14nmos@99_poly-right##49 9.898
R4407 NAND1_to_NAND5#14nmos@99_poly-right##49 NAND1_to_NAND5#14nmos@99_poly-right##50 9.898
R4408 NAND1_to_NAND5#14nmos@99_poly-right##50 NAND1_to_NAND5#14nmos@99_poly-right##51 9.898
R4409 NAND1_to_NAND5#14nmos@99_poly-right##51 NAND1_to_NAND5#14nmos@99_poly-right##52 9.898
R4410 NAND1_to_NAND5#14nmos@99_poly-right##52 NAND1_to_NAND5#14nmos@99_poly-right##53 9.898
R4411 NAND1_to_NAND5#14nmos@99_poly-right##53 NAND1_to_NAND5#14nmos@99_poly-right##54 9.898
R4412 NAND1_to_NAND5#14nmos@99_poly-right##54 NAND1_to_NAND5#14nmos@99_poly-right##55 9.898
R4413 NAND1_to_NAND5#14nmos@99_poly-right##55 NAND1_to_NAND5#11pmos@99_poly-right 9.898
R4414 Cout Cout#2nmos@99_diff-bottom 4.42
R4415 NAND2_to_Nand5 NAND2_to_Nand5#4nmos@97_diff-bottom 4.42
R4416 A2 A2##0 9.854
C217 A2##0 0 10.57fF
R4417 A2##0 A2#1pin@586_metal-2 9.854
R4418 B2 B2##0 9.756
C218 B2##0 0 10.466fF
R4419 B2##0 B2#1pin@588_metal-2 9.756

* Spice Code nodes in cell cell 'Eight_bit_adder{lay}'
VDD VDD 0 DC 3.3
VGND GND 0 DC 0
vin1 A0 vdd
vin2 A1 vdd
vin3 A2 vdd
vin4 B0 vdd
vin5 B1 vdd
vin6 B2 0
vin7 Cin 0
cload out 0 250fF
.tran 0 10u
.include C:\Electric\C5_models.txt
.END
